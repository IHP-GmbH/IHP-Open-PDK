v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Low voltage 
CMOS devices} 40 -1690 0 0 0.6 0.6 {}
T {High voltage 
CMOS devices} 40 -1560 0 0 0.6 0.6 {}
T {ESD devices} 40 -1420 0 0 0.6 0.6 {}
T {Diodes} 40 -1280 0 0 0.6 0.6 {}
T {Polysilicon 
resistors} 40 -1170 0 0 0.6 0.6 {}
T {Tap devices} 40 -1010 0 0 0.6 0.6 {}
T {SVaricap} 40 -860 0 0 0.6 0.6 {}
T {Bondpad} 40 -740 0 0 0.6 0.6 {}
T {PNP lateral device} 40 -660 0 0 0.6 0.6 {}
C {title-3.sym} 0 0 0 0 {name=l2 author="IHP Open PDK Authors 2025" title="Device gallery" rev=1.0 lock=true}
