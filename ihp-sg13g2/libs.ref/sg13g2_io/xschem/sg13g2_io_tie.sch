v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 40 -60 40 -40 {
lab=vdd}
N 40 -20 40 10 {
lab=xxx}
C {devices/iopin.sym} 40 -60 0 0 {name=vdd lab=vdd}
C {devices/iopin.sym} 40 10 0 0 {name=vss lab=vss}
