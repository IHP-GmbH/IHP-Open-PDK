v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 750 -660 920 -660 {lab=VSS}
N 740 -890 920 -890 {lab=VDD}
C {devices/lab_pin.sym} 740 -890 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 750 -660 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {devices/title-3.sym} -420 100 0 0 {name=l1 author="IHP PDK AUTHORS"}
C {noconn.sym} 920 -890 0 1 {name=l2}
C {noconn.sym} 920 -660 0 1 {name=l3}
