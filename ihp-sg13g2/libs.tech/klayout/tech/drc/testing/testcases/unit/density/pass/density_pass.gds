# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
EdgeSeal_drawing = (39, 0)
EdgeSeal_boundary = (39, 4)
TopMetal2_drawing = (134, 0)

tm2_d = lib.new_cell('TM2.d')
P(tm2_d, EdgeSeal_drawing, [(0,0),(0,0),(0,0),(0,0)])
R(tm2_d, EdgeSeal_boundary, [(0,0,1146.62,1097.81)])
A(tm2_d, TopMetal2_drawing, 12.34, 12.34, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 140.35, 12.34, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 12.34, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 524.39, 12.34, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 12.34, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 12.34, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 12.34, 76.43, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 140.35, 76.43, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 76.43, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 524.39, 76.43, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 76.43, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 76.43, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 12.34, 140.5, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 140.35, 140.5, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 140.5, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 524.39, 140.5, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 140.5, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 140.5, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 12.34, 204.59, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 140.35, 204.59, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 204.59, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 524.39, 204.59, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 204.59, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 204.59, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 12.34, 268.62, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 140.35, 268.62, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 268.62, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 524.39, 268.62, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 268.62, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 268.62, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 12.34, 332.71, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 140.35, 332.71, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 332.71, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 524.39, 332.71, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 332.71, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 332.71, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 12.34, 396.78, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 140.35, 396.78, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 396.78, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 396.78, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 396.78, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 12.34, 460.87, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 140.35, 460.87, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 460.87, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 460.87, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 460.87, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 525.17, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 525.17, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 525.17, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 268.36, 589.26, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 589.26, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 589.26, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 589.26, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 268.36, 653.33, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 653.33, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 653.33, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 653.33, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 268.36, 717.42, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 717.42, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 717.42, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 717.42, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 268.36, 781.45, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 781.45, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 781.45, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 780.41, 781.45, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 781.45, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 268.36, 845.54, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 396.37, 845.54, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 652.4, 845.54, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 780.41, 845.54, 30, 30, 4, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 908.43, 845.54, 30, 30, 3, 2, 32, 32.01)
A(tm2_d, TopMetal2_drawing, 268.36, 909.61, 30, 30, 4, 2, 32, 32.63)
A(tm2_d, TopMetal2_drawing, 396.37, 909.61, 30, 30, 3, 2, 32, 32.63)
A(tm2_d, TopMetal2_drawing, 652.4, 909.61, 30, 30, 4, 2, 32, 32.63)
A(tm2_d, TopMetal2_drawing, 780.41, 909.61, 30, 30, 4, 2, 32, 32.63)
A(tm2_d, TopMetal2_drawing, 908.43, 909.61, 30, 30, 3, 2, 32, 32.63)
A(tm2_d, TopMetal2_drawing, 268.36, 974.25, 30, 30, 4, 2, 32, 32.06)
A(tm2_d, TopMetal2_drawing, 396.37, 974.25, 30, 30, 3, 2, 32, 32.06)
A(tm2_d, TopMetal2_drawing, 652.4, 974.25, 30, 30, 4, 2, 32, 32.06)
A(tm2_d, TopMetal2_drawing, 780.41, 974.25, 30, 30, 4, 2, 32, 32.06)
A(tm2_d, TopMetal2_drawing, 908.43, 974.25, 30, 30, 3, 2, 32, 32.06)
R(tm2_d, TopMetal2_drawing, [(780.41,12.34,810.41,42.34), (876.41,12.34,906.41,42.34), (780.41,44.35,810.41,74.35), (876.41,44.35,906.41,74.35), (780.41,76.43,810.41,106.43), (876.41,76.43,906.41,106.43), (780.41,108.44,810.41,138.44), (876.41,108.44,906.41,138.44), (780.41,140.5,810.41,170.5), (876.41,140.5,906.41,170.5), (780.41,172.51,810.41,202.51), (876.41,172.51,906.41,202.51), (780.41,204.59,810.41,234.59), (876.41,204.59,906.41,234.59), (780.41,236.6,810.41,266.6), (876.41,236.6,906.41,266.6), (780.41,268.62,810.41,298.62), (876.41,268.62,906.41,298.62), (780.41,300.63,810.41,330.63), (876.41,300.63,906.41,330.63), (780.41,332.71,810.41,362.71), (876.41,332.71,906.41,362.71), (780.41,364.72,810.41,394.72), (876.41,364.72,906.41,394.72), (780.41,396.78,810.41,426.78), (876.41,396.78,906.41,426.78), (780.41,428.79,810.41,458.79), (876.41,428.79,906.41,458.79), (780.41,460.87,810.41,490.87), (876.41,460.87,906.41,490.87), (780.41,492.88,810.41,522.88), (876.41,492.88,906.41,522.88), (12.34,525.17,42.34,555.17), (44.34,525.17,74.34,555.17), (204.35,525.17,234.35,555.17), (236.35,525.17,266.35,555.17), (780.41,525.17,810.41,555.17), (876.41,525.17,906.41,555.17), (12.34,557.18,42.34,587.18), (44.34,557.18,74.34,587.18), (204.35,557.18,234.35,587.18), (236.35,557.18,266.35,587.18), (780.41,557.18,810.41,587.18), (876.41,557.18,906.41,587.18), (12.34,589.26,42.34,619.26), (44.34,589.26,74.34,619.26), (204.35,589.26,234.35,619.26), (236.35,589.26,266.35,619.26), (780.41,589.26,810.41,619.26), (876.41,589.26,906.41,619.26), (12.34,621.27,42.34,651.27), (44.34,621.27,74.34,651.27), (204.35,621.27,234.35,651.27), (236.35,621.27,266.35,651.27), (780.41,621.27,810.41,651.27), (876.41,621.27,906.41,651.27), (12.34,653.33,42.34,683.33), (44.34,653.33,74.34,683.33), (204.35,653.33,234.35,683.33), (236.35,653.33,266.35,683.33), (780.41,653.33,810.41,683.33), (876.41,653.33,906.41,683.33), (12.34,685.34,42.34,715.34), (44.34,685.34,74.34,715.34), (204.35,685.34,234.35,715.34), (236.35,685.34,266.35,715.34), (780.41,685.34,810.41,715.34), (876.41,685.34,906.41,715.34), (12.34,717.42,42.34,747.42), (44.34,717.42,74.34,747.42), (204.35,717.42,234.35,747.42), (236.35,717.42,266.35,747.42), (780.41,717.42,810.41,747.42), (876.41,717.42,906.41,747.42), (12.34,749.43,42.34,779.43), (44.34,749.43,74.34,779.43), (204.35,749.43,234.35,779.43), (236.35,749.43,266.35,779.43), (780.41,749.43,810.41,779.43), (876.41,749.43,906.41,779.43), (12.34,781.45,42.34,811.45), (44.34,781.45,74.34,811.45), (204.35,781.45,234.35,811.45), (236.35,781.45,266.35,811.45), (12.34,813.46,42.34,843.46), (44.34,813.46,74.34,843.46), (204.35,813.46,234.35,843.46), (236.35,813.46,266.35,843.46), (12.34,845.54,42.34,875.54), (44.34,845.54,74.34,875.54), (204.35,845.54,234.35,875.54), (236.35,845.54,266.35,875.54), (12.34,877.55,42.34,907.55), (44.34,877.55,74.34,907.55), (204.35,877.55,234.35,907.55), (236.35,877.55,266.35,907.55), (12.34,909.61,42.34,939.61), (44.34,909.61,74.34,939.61), (204.35,909.61,234.35,939.61), (236.35,909.61,266.35,939.61), (12.34,942.24,42.34,972.24), (44.34,942.24,74.34,972.24), (204.35,942.24,234.35,972.24), (236.35,942.24,266.35,972.24), (12.34,974.25,42.34,1004.25), (44.34,974.25,74.34,1004.25), (204.35,974.25,234.35,1004.25), (236.35,974.25,266.35,1004.25), (12.34,1006.31,42.34,1036.31), (44.34,1006.31,74.34,1036.31), (204.35,1006.31,234.35,1036.31), (236.35,1006.31,266.35,1036.31)])

lib.write_gds('TM2.d.gds')
