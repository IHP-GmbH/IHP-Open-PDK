# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
Activ_drawing = (1, 0)
EdgeSeal_boundary = (39, 4)

afil_g2 = lib.new_cell('AFil.g2')
A(afil_g2, Activ_drawing, 0, 0, 35, 50, 8, 5, 35.5, 50.5)
A(afil_g2, Activ_drawing, 456.17, 37.335, 50, 35, 3, 4, 50.5, 35.5)
A(afil_g2, Activ_drawing, 842.445, 46.18, 50, 35, 5, 8, 50.5, 35.5)
A(afil_g2, Activ_drawing, 419.065, 317.14, 50, 35, 5, 3, 50.5, 35.5)
A(afil_g2, Activ_drawing, 35.235, 357.9, 35, 50, 8, 8, 35.5, 50.5)
A(afil_g2, Activ_drawing, 853.765, 423.64, 50, 35, 5, 3, 50.5, 35.5)
A(afil_g2, Activ_drawing, 419.065, 530.14, 50, 35, 5, 2, 50.5, 35.5)
A(afil_g2, Activ_drawing, 972.075, 616.935, 50, 35, 3, 3, 50.5, 35.5)
A(afil_g2, Activ_drawing, 1212.3, 670.675, 50, 35, 1, 4, 0, 35.5)
A(afil_g2, Activ_drawing, 972.075, 756.92, 50, 35, 3, 3, 50.5, 35.5)
A(afil_g2, Activ_drawing, 421.515, 804.71, 50, 35, 5, 8, 50.5, 35.5)
A(afil_g2, Activ_drawing, 1161.8, 875.715, 50, 35, 1, 4, 0, 35.5)
A(afil_g2, Activ_drawing, 1212.3, 875.715, 50, 35, 1, 4, 0, 35.5)
A(afil_g2, Activ_drawing, 88.995, 879.115, 50, 35, 3, 4, 50.5, 35.5)
A(afil_g2, Activ_drawing, 910.625, 887.55, 50, 35, 3, 4, 50.5, 35.5)
A(afil_g2, Activ_drawing, 1024.76, 1049.95, 50, 35, 3, 4, 50.5, 35.5)
R(afil_g2, EdgeSeal_boundary, [(0,0,1300,1300)])

lib.write_gds('AFil.g2.gds')
