# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
EdgeSeal_boundary = (39, 4)
Metal4_drawing = (50, 0)
Metal4_filler = (50, 22)

m4fil_h = lib.new_cell('M4Fil.h')
R(m4fil_h, EdgeSeal_boundary, [(0,0,1200,1200)])
A(m4fil_h, Metal4_drawing, 419.065, 565.64, 50, 35, 5, 1, 50.5, 0)
A(m4fil_h, Metal4_drawing, 35.235, 610.4, 35, 50, 8, 3, 35.5, 50.5)
A(m4fil_h, Metal4_drawing, 972.075, 616.935, 50, 35, 3, 4, 50.5, 35.5)
A(m4fil_h, Metal4_drawing, 421.515, 804.71, 50, 35, 5, 8, 50.5, 35.5)
A(m4fil_h, Metal4_drawing, 88.995, 879.115, 50, 35, 3, 4, 50.5, 35.5)
A(m4fil_h, Metal4_drawing, 910.625, 887.55, 50, 35, 3, 4, 50.5, 35.5)
A(m4fil_h, Metal4_drawing, 1016.98, 1044.75, 50, 35, 3, 4, 50.5, 35.5)
A(m4fil_h, Metal4_filler, 0, 0, 35, 50, 8, 5, 35.5, 50.5)
A(m4fil_h, Metal4_filler, 456.17, 37.335, 50, 35, 3, 4, 50.5, 35.5)
A(m4fil_h, Metal4_filler, 842.445, 46.18, 50, 35, 5, 8, 50.5, 35.5)
A(m4fil_h, Metal4_filler, 419.065, 317.14, 50, 35, 5, 3, 50.5, 35.5)
A(m4fil_h, Metal4_filler, 35.235, 357.9, 35, 50, 8, 5, 35.5, 50.5)
A(m4fil_h, Metal4_filler, 853.765, 423.64, 50, 35, 5, 3, 50.5, 35.5)
A(m4fil_h, Metal4_filler, 419.065, 530.14, 50, 35, 5, 1, 50.5, 0)

lib.write_gds('M4Fil.h.gds')
