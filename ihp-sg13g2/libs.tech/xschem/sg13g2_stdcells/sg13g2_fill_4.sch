v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 750 -660 920 -660 {}
N 740 -890 920 -890 {}
C {devices/iopin.sym} 740 -890 2 0 {name=p1 lab=VDD}
C {devices/iopin.sym} 750 -660 2 0 {name=p2 lab=VSS}
C {devices/title-3.sym} -420 100 0 0 {name=l1 author="IHP PDK AUTHORS"}
