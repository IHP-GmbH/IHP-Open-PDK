* ISCAS85 benchmark circuit SPICE netlist
* generated by spicegen.pl 1.0
* by Jingye Xu @ VLSI group, Dept of ECE, UIC

* Path to the models
.lib ../models/cornerMOSlv.lib mos_tt

*.OPTIONS GMIN=1e-015 ABSTOL=1e-13 ACCT noopiter
*.options vntol=10u

**** the input ports: g110_0 g21_0 g18_1 g189_1 g172_2 g70_1 g103_0 g114_0 g92_1 g150_1 g198_1 g125_0 g30_0 g69_1 g45_0 g83_1 g157_0 g182_1 g82_0 g63_1 g42_1 g51_2 g99_1 g62_0 g169_2 g39_0 g128_1 g130_0 g78_1 g195_2 g38_1 g134_1 g191_2 g5_1 g176_1 g117_1 g35_1 g194_1 g41_0 g97_0 g147_1 g14_2 g137_0 g66_2 g26_1 g140_1 g154_1 g185_0 g48_0 g87_0 g106_1 g151_0 g158_0 g15_0 g7_1 g74_1 g122_0 g86_1 g56_1 g165_0 g34_0 g206_6 g57_1 g138_1 g168_0 g17_0 g27_1 g93_0 g199_0 g180_0 g202_0 g173_0 g22_1 g131_0 g192_1 g135_1 g4_1 g77_1 g111_1 g126_1 g52_2 g79_1 g81_1 g156_1 g64_1 g43_0 g183_1 g23_1 g13_2 g53_1 g90_0 g143_0 g153_1 g177_2 g98_0 g19_1 g118_1 g146_1 g102_1 g186_2 g6_4 g1_2 g28_0 g164_1 g33_0 g49_1 g123_0 g205_1 g105_0 g73_1 g170_1 g85_1 g44_0 g67_1 g204_1 g163_1 g159_0 g76_0 g94_0 g139_1 g193_2 g58_1 g100_0 g32_2 g50_0 g132_1 g174_0 g149_1 g12_2 g112_1 g101_0 g119_1 g24_1 g127_1 g201_2 g37_0 g9_2 g207_1 g120_1 g60_1 g108_1 g171_2 g72_2 g46_1 g3_1 g80_1 g59_1 g54_0 g10_1 g152_1 g115_0 g166_2 g95_0 g167_1 g178_2 g187_1 g142_1 g196_0 g113_1 g31_1 g124_1 g190_0 g175_2 g84_0 g133_0 g68_1 g203_2 g75_0 g162_0 g11_1 g144_1 g136_0 g129_1 g91_1 g161_1 g29_1 g155_0 g200_0 g89_1 g141_0 g20_1 g188_2 g104_1 g148_0 g61_1 g65_2 g2_0 g184_3 g109_0 g71_2 g40_0 g47_1 g107_0 g36_1 g121_1 g8_0 g88_0 g16_1 g160_0 g179_0 g96_0 g55_1 g181_3 g25_0 g197_2 g116_0 g145_1 ****
**** the output ports: g7529_1 g7509_0 g7484_1 g7477_1 g7460_0 g7503_1 g7522_0 g7485_1 g7453_0 g7474_0 g7500_0 g7514_0 g7546_1 g7549_0 g7467_0 g7491_0 g7456_0 g7495_1 g7545_0 g7473_0 g7541_0 g7448_1 g7525_1 g7550_1 g165_1 g7510_1 g7535_1 g7534_1 g7469_1 g7476_0 g7517_1 g7537_0 g7489_1 g7521_1 g7486_0 g7533_1 g7449_0 g7447_0 g7528_0 g7513_1 g7548_0 g7544_1 g7552_0 g7540_1 g7507_0 g7481_0 g7455_0 g7502_1 g7446_1 g7478_1 g7470_0 g7526_0 g7494_1 g7452_1 g7463_0 g7532_1 g7512_0 g7527_0 g7451_0 g7472_0 g7498_1 g7475_0 g7536_0 g7488_1 g7493_1 g7551_1 g7482_0 g7487_1 g7501_1 g7520_1 g7516_1 g7450_1 g7508_0 g7458_1 g7479_1 g7506_1 g7499_0 g7471_0 g7465_1 g7464_1 g7543_1 g7524_0 g7539_1 g7468_1 g7459_0 g7504_1 g7515_1 g7492_1 g7511_0 g7462_1 g7530_0 g7497_1 g7454_1 g7519_1 g7531_0 g7547_0 g7483_1 g7466_1 g7480_1 g7523_1 g7496_0 g7538_0 g7490_1 g7518_1 g7461_0 g7542_0 g7457_0 g7505_1 ****

* the voltage sources:
Vdd vdd 0 DC 1.8

* the input ports:
V1 g110_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V2 g21_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V3 g18_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V4 g189_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V5 g172_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V6 g70_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V7 g103_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V8 g114_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V9 g92_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V10 g150_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V11 g198_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V12 g125_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V13 g30_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V14 g69_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V15 g45_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V16 g83_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V17 g157_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V18 g182_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V19 g82_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V20 g63_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V21 g42_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V22 g51_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V23 g99_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V24 g62_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V25 g169_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V26 g39_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V27 g128_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V28 g130_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V29 g78_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V30 g195_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V31 g38_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V32 g134_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V33 g191_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V34 g5_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V35 g176_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V36 g117_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V37 g35_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V38 g194_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V39 g41_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V40 g97_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V41 g147_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V42 g14_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V43 g137_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V44 g66_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V45 g26_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V46 g140_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V47 g154_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V48 g185_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V49 g48_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V50 g87_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V51 g106_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V52 g151_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V53 g158_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V54 g15_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V55 g7_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V56 g74_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V57 g122_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V58 g86_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V59 g56_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V60 g165_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V61 g34_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V62 g206_6 0 pulse(0 1 0p 200p 100p 1n 2n)
V63 g57_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V64 g138_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V65 g168_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V66 g17_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V67 g27_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V68 g93_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V69 g199_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V70 g180_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V71 g202_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V72 g173_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V73 g22_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V74 g131_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V75 g192_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V76 g135_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V77 g4_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V78 g77_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V79 g111_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V80 g126_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V81 g52_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V82 g79_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V83 g81_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V84 g156_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V85 g64_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V86 g43_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V87 g183_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V88 g23_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V89 g13_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V90 g53_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V91 g90_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V92 g143_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V93 g153_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V94 g177_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V95 g98_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V96 g19_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V97 g118_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V98 g146_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V99 g102_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V100 g186_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V101 g6_4 0 pulse(0 1 0p 200p 100p 1n 2n)
V102 g1_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V103 g28_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V104 g164_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V105 g33_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V106 g49_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V107 g123_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V108 g205_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V109 g105_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V110 g73_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V111 g170_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V112 g85_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V113 g44_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V114 g67_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V115 g204_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V116 g163_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V117 g159_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V118 g76_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V119 g94_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V120 g139_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V121 g193_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V122 g58_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V123 g100_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V124 g32_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V125 g50_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V126 g132_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V127 g174_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V128 g149_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V129 g12_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V130 g112_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V131 g101_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V132 g119_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V133 g24_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V134 g127_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V135 g201_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V136 g37_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V137 g9_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V138 g207_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V139 g120_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V140 g60_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V141 g108_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V142 g171_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V143 g72_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V144 g46_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V145 g3_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V146 g80_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V147 g59_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V148 g54_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V149 g10_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V150 g152_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V151 g115_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V152 g166_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V153 g95_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V154 g167_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V155 g178_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V156 g187_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V157 g142_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V158 g196_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V159 g113_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V160 g31_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V161 g124_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V162 g190_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V163 g175_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V164 g84_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V165 g133_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V166 g68_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V167 g203_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V168 g75_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V169 g162_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V170 g11_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V171 g144_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V172 g136_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V173 g129_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V174 g91_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V175 g161_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V176 g29_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V177 g155_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V178 g200_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V179 g89_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V180 g141_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V181 g20_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V182 g188_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V183 g104_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V184 g148_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V185 g61_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V186 g65_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V187 g2_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V188 g184_3 0 pulse(0 1 0p 200p 100p 1n 2n)
V189 g109_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V190 g71_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V191 g40_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V192 g47_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V193 g107_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V194 g36_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V195 g121_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V196 g8_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V197 g88_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V198 g16_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V199 g160_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V200 g179_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V201 g96_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V202 g55_1 0 pulse(0 1 0p 200p 100p 1n 2n)
V203 g181_3 0 pulse(0 1 0p 200p 100p 1n 2n)
V204 g25_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V205 g197_2 0 pulse(0 1 0p 200p 100p 1n 2n)
V206 g116_0 0 pulse(0 1 0p 200p 100p 1n 2n)
V207 g145_1 0 pulse(0 1 0p 200p 100p 1n 2n)

* the net sub circuits:

.subckt netx81 x81_1 x81_0 gnd
C1  x81_1 gnd 2.080806f
C2  x81_0 gnd 2.080806f
R1 x81_1 x81_0 2.224404
.ends

.subckt netg4055 g4055_1 g4055_0 gnd
C1  g4055_1 gnd 2.080806f
C2  g4055_0 gnd 2.080806f
R1 g4055_1 g4055_0 2.224404
.ends

.subckt netg6531 g6531_1 g6531_0 gnd
C1  g6531_1 gnd 2.080806f
C2  g6531_0 gnd 2.080806f
R1 g6531_0 g6531_1 2.224404
.ends

.subckt netg1255 g1255_0 g1255_1 gnd
C1  g1255_0 gnd 2.080806f
C2  g1255_1 gnd 2.080806f
R1 g1255_1 g1255_0 2.224404
.ends

.subckt netg5391 g5391_0 g5391_1 gnd
C1  g5391_0 gnd 2.080806f
C2  g5391_1 gnd 2.080806f
R1 g5391_1 g5391_0 2.224404
.ends

.subckt netg4749 g4749_0 g4749_1 gnd
C1  g4749_0 gnd 2.080806f
C2  g4749_1 gnd 2.080806f
R1 g4749_0 g4749_1 2.224404
.ends

.subckt netg7003 g7003_0 g7003_1 gnd
C1  g7003_0 gnd 2.080806f
C2  g7003_1 gnd 2.080806f
R1 g7003_0 g7003_1 2.224404
.ends

.subckt netx242 x242_1 x242_0 gnd
C1  x242_1 gnd 2.080806f
C2  x242_0 gnd 2.080806f
R1 x242_0 x242_1 2.224404
.ends

.subckt netg6733 g6733_0 g6733_1 gnd
C1  g6733_0 gnd 2.080806f
C2  g6733_1 gnd 2.080806f
R1 g6733_1 g6733_0 2.224404
.ends

.subckt netg404 g404_2 g404_0 gnd
C1  g404_2 gnd 2.080806f
C2  g404_0 gnd 2.080806f
R1 g404_2 g404_0 2.224404
.ends

.subckt netg2934 g2934_1 g2934_0 gnd
C1  g2934_1 gnd 2.080806f
C2  g2934_0 gnd 2.080806f
R1 g2934_0 g2934_1 2.224404
.ends

.subckt netg6397 g6397_0 g6397_1 gnd
C1  g6397_0 gnd 2.080806f
C2  g6397_1 gnd 2.080806f
R1 g6397_1 g6397_0 2.224404
.ends

.subckt netg7266 g7266_1 g7266_0 gnd
C1  g7266_1 gnd 2.080806f
C2  g7266_0 gnd 2.080806f
R1 g7266_0 g7266_1 2.224404
.ends

.subckt netg5784 g5784_0 g5784_1 gnd
C1  g5784_0 gnd 2.080806f
C2  g5784_1 gnd 2.080806f
R1 g5784_1 g5784_0 2.224404
.ends

.subckt netg6546 g6546_1 g6546_2 gnd
C1  g6546_1 gnd 2.080806f
C2  g6546_2 gnd 2.080806f
R1 g6546_2 g6546_1 2.224404
.ends

.subckt netg6937 g6937_1 g6937_0 gnd
C1  g6937_1 gnd 2.080806f
C2  g6937_0 gnd 2.080806f
R1 g6937_0 g6937_1 2.224404
.ends

.subckt netg2929 g2929_1 g2929_0 gnd
C1  g2929_1 gnd 2.080806f
C2  g2929_0 gnd 2.080806f
R1 g2929_0 g2929_1 2.224404
.ends

.subckt netg4099 g4099_1 g4099_0 gnd
C1  g4099_1 gnd 2.080806f
C2  g4099_0 gnd 2.080806f
R1 g4099_1 g4099_0 2.224404
.ends

.subckt netg3537 g3537_0 g3537_1 gnd
C1  g3537_0 gnd 2.080806f
C2  g3537_1 gnd 2.080806f
R1 g3537_1 g3537_0 2.224404
.ends

.subckt netg4245 g4245_0 g4245_1 gnd
C1  g4245_0 gnd 2.080806f
C2  g4245_1 gnd 2.080806f
R1 g4245_0 g4245_1 2.224404
.ends

.subckt netg5584 g5584_1 g5584_0 gnd
C1  g5584_1 gnd 2.080806f
C2  g5584_0 gnd 2.080806f
R1 g5584_0 g5584_1 2.224404
.ends

.subckt netg4531 g4531_1 g4531_0 gnd
C1  g4531_1 gnd 2.080806f
C2  g4531_0 gnd 2.080806f
R1 g4531_1 g4531_0 2.224404
.ends

.subckt netg3903 g3903_1 g3903_0 gnd
C1  g3903_1 gnd 2.080806f
C2  g3903_0 gnd 2.080806f
R1 g3903_1 g3903_0 2.224404
.ends

.subckt netg7164 g7164_1 g7164_0 gnd
C1  g7164_1 gnd 2.080806f
C2  g7164_0 gnd 2.080806f
R1 g7164_0 g7164_1 2.224404
.ends

.subckt netg1998 g1998_0 g1998_1 gnd
C1  g1998_0 gnd 2.080806f
C2  g1998_1 gnd 2.080806f
R1 g1998_1 g1998_0 2.224404
.ends

.subckt netx461 x461_0 x461_1 gnd
C1  x461_0 gnd 2.080806f
C2  x461_1 gnd 2.080806f
R1 x461_0 x461_1 2.224404
.ends

.subckt netg4257 g4257_0 g4257_1 gnd
C1  g4257_0 gnd 2.080806f
C2  g4257_1 gnd 2.080806f
R1 g4257_1 g4257_0 2.224404
.ends

.subckt netg961 g961_2 g961_1 gnd
C1  g961_2 gnd 2.080806f
C2  g961_1 gnd 2.080806f
R1 g961_2 g961_1 2.224404
.ends

.subckt netg2816 g2816_0 g2816_1 gnd
C1  g2816_0 gnd 2.080806f
C2  g2816_1 gnd 2.080806f
R1 g2816_0 g2816_1 2.224404
.ends

.subckt netg6439 g6439_1 g6439_0 gnd
C1  g6439_1 gnd 2.080806f
C2  g6439_0 gnd 2.080806f
R1 g6439_1 g6439_0 2.224404
.ends

.subckt netg6979 g6979_1 g6979_0 gnd
C1  g6979_1 gnd 2.080806f
C2  g6979_0 gnd 2.080806f
R1 g6979_0 g6979_1 2.224404
.ends

.subckt netg6213 g6213_0 g6213_1 gnd
C1  g6213_0 gnd 2.080806f
C2  g6213_1 gnd 2.080806f
R1 g6213_0 g6213_1 2.224404
.ends

.subckt netg7268 g7268_1 g7268_0 gnd
C1  g7268_1 gnd 2.080806f
C2  g7268_0 gnd 2.080806f
R1 g7268_0 g7268_1 2.224404
.ends

.subckt netg1933 g1933_1 g1933_0 gnd
C1  g1933_1 gnd 2.080806f
C2  g1933_0 gnd 2.080806f
R1 g1933_1 g1933_0 2.224404
.ends

.subckt netg3986 g3986_0 g3986_1 gnd
C1  g3986_0 gnd 2.080806f
C2  g3986_1 gnd 2.080806f
R1 g3986_1 g3986_0 2.224404
.ends

.subckt netg2916 g2916_1 g2916_0 gnd
C1  g2916_1 gnd 2.080806f
C2  g2916_0 gnd 2.080806f
R1 g2916_1 g2916_0 2.224404
.ends

.subckt netg6553 g6553_0 g6553_1 gnd
C1  g6553_0 gnd 2.080806f
C2  g6553_1 gnd 2.080806f
R1 g6553_1 g6553_0 2.224404
.ends

.subckt netg2788 g2788_0 g2788_1 gnd
C1  g2788_0 gnd 2.080806f
C2  g2788_1 gnd 2.080806f
R1 g2788_1 g2788_0 2.224404
.ends

.subckt netg5960 g5960_0 g5960_1 gnd
C1  g5960_0 gnd 2.080806f
C2  g5960_1 gnd 2.080806f
R1 g5960_1 g5960_0 2.224404
.ends

.subckt netg3549 g3549_0 g3549_1 gnd
C1  g3549_0 gnd 2.080806f
C2  g3549_1 gnd 2.080806f
R1 g3549_1 g3549_0 2.224404
.ends

.subckt netg6206 g6206_0 g6206_1 gnd
C1  g6206_0 gnd 2.080806f
C2  g6206_1 gnd 2.080806f
R1 g6206_1 g6206_0 2.224404
.ends

.subckt netg1874 g1874_2 g1874_1 gnd
C1  g1874_2 gnd 2.080806f
C2  g1874_1 gnd 2.080806f
R1 g1874_1 g1874_2 2.224404
.ends

.subckt netg6916 g6916_1 g6916_0 gnd
C1  g6916_1 gnd 2.080806f
C2  g6916_0 gnd 2.080806f
R1 g6916_0 g6916_1 2.224404
.ends

.subckt netg5365 g5365_0 g5365_1 gnd
C1  g5365_0 gnd 2.080806f
C2  g5365_1 gnd 2.080806f
R1 g5365_1 g5365_0 2.224404
.ends

.subckt netg1131 g1131_1 g1131_0 gnd
C1  g1131_1 gnd 2.080806f
C2  g1131_0 gnd 2.080806f
R1 g1131_0 g1131_1 2.224404
.ends

.subckt netg7189 g7189_1 g7189_0 gnd
C1  g7189_1 gnd 2.080806f
C2  g7189_0 gnd 2.080806f
R1 g7189_1 g7189_0 2.224404
.ends

.subckt netg4313 g4313_1 g4313_0 gnd
C1  g4313_1 gnd 2.080806f
C2  g4313_0 gnd 2.080806f
R1 g4313_1 g4313_0 2.224404
.ends

.subckt netg2426 g2426_0 g2426_2 gnd
C1  g2426_0 gnd 2.080806f
C2  g2426_2 gnd 2.080806f
R1 g2426_0 g2426_2 2.224404
.ends

.subckt netg7001 g7001_1 g7001_0 gnd
C1  g7001_1 gnd 2.080806f
C2  g7001_0 gnd 2.080806f
R1 g7001_1 g7001_0 2.224404
.ends

.subckt netg2952 g2952_1 g2952_0 gnd
C1  g2952_1 gnd 2.080806f
C2  g2952_0 gnd 2.080806f
R1 g2952_1 g2952_0 2.224404
.ends

.subckt netg5880 g5880_1 g5880_0 gnd
C1  g5880_1 gnd 2.080806f
C2  g5880_0 gnd 2.080806f
R1 g5880_0 g5880_1 2.224404
.ends

.subckt netg3513 g3513_1 g3513_0 gnd
C1  g3513_1 gnd 2.080806f
C2  g3513_0 gnd 2.080806f
R1 g3513_1 g3513_0 2.224404
.ends

.subckt netg2939 g2939_0 g2939_1 gnd
C1  g2939_0 gnd 2.080806f
C2  g2939_1 gnd 2.080806f
R1 g2939_1 g2939_0 2.224404
.ends

.subckt netg3524 g3524_0 g3524_1 gnd
C1  g3524_0 gnd 2.080806f
C2  g3524_1 gnd 2.080806f
R1 g3524_1 g3524_0 2.224404
.ends

.subckt netg6729 g6729_1 g6729_0 gnd
C1  g6729_1 gnd 2.080806f
C2  g6729_0 gnd 2.080806f
R1 g6729_0 g6729_1 2.224404
.ends

.subckt netg7354 g7354_1 g7354_0 gnd
C1  g7354_1 gnd 2.080806f
C2  g7354_0 gnd 2.080806f
R1 g7354_0 g7354_1 2.224404
.ends

.subckt netg2818 g2818_0 g2818_1 gnd
C1  g2818_0 gnd 2.080806f
C2  g2818_1 gnd 2.080806f
R1 g2818_1 g2818_0 2.224404
.ends

.subckt netg6447 g6447_1 g6447_0 gnd
C1  g6447_1 gnd 2.080806f
C2  g6447_0 gnd 2.080806f
R1 g6447_0 g6447_1 2.224404
.ends

.subckt netg6132 g6132_0 g6132_1 gnd
C1  g6132_0 gnd 2.080806f
C2  g6132_1 gnd 2.080806f
R1 g6132_0 g6132_1 2.224404
.ends

.subckt netg3510 g3510_0 g3510_1 gnd
C1  g3510_0 gnd 2.080806f
C2  g3510_1 gnd 2.080806f
R1 g3510_0 g3510_1 2.224404
.ends

.subckt netg3486 g3486_1 g3486_0 gnd
C1  g3486_1 gnd 2.080806f
C2  g3486_0 gnd 2.080806f
R1 g3486_0 g3486_1 2.224404
.ends

.subckt netg6042 g6042_0 g6042_1 gnd
C1  g6042_0 gnd 2.080806f
C2  g6042_1 gnd 2.080806f
R1 g6042_0 g6042_1 2.224404
.ends

.subckt netg1591 g1591_1 g1591_0 gnd
C1  g1591_1 gnd 2.080806f
C2  g1591_0 gnd 2.080806f
R1 g1591_0 g1591_1 2.224404
.ends

.subckt netg4096 g4096_1 g4096_0 gnd
C1  g4096_1 gnd 2.080806f
C2  g4096_0 gnd 2.080806f
R1 g4096_1 g4096_0 2.224404
.ends

.subckt netg4048 g4048_1 g4048_0 gnd
C1  g4048_1 gnd 2.080806f
C2  g4048_0 gnd 2.080806f
R1 g4048_1 g4048_0 2.224404
.ends

.subckt netg2813 g2813_1 g2813_0 gnd
C1  g2813_1 gnd 2.080806f
C2  g2813_0 gnd 2.080806f
R1 g2813_0 g2813_1 2.224404
.ends

.subckt netg1928 g1928_0 g1928_1 gnd
C1  g1928_0 gnd 2.080806f
C2  g1928_1 gnd 2.080806f
R1 g1928_1 g1928_0 2.224404
.ends

.subckt netg5233 g5233_0 g5233_1 gnd
C1  g5233_0 gnd 2.080806f
C2  g5233_1 gnd 2.080806f
R1 g5233_1 g5233_0 2.224404
.ends

.subckt netg5369 g5369_1 g5369_0 gnd
C1  g5369_1 gnd 2.080806f
C2  g5369_0 gnd 2.080806f
R1 g5369_1 g5369_0 2.224404
.ends

.subckt netg4451 g4451_1 g4451_0 gnd
C1  g4451_1 gnd 2.080806f
C2  g4451_0 gnd 2.080806f
R1 g4451_1 g4451_0 2.224404
.ends

.subckt netg3480 g3480_1 g3480_0 gnd
C1  g3480_1 gnd 2.080806f
C2  g3480_0 gnd 2.080806f
R1 g3480_0 g3480_1 2.224404
.ends

.subckt netg7359 g7359_0 g7359_1 gnd
C1  g7359_0 gnd 2.080806f
C2  g7359_1 gnd 2.080806f
R1 g7359_1 g7359_0 2.224404
.ends

.subckt netg4302 g4302_0 g4302_1 gnd
C1  g4302_0 gnd 2.080806f
C2  g4302_1 gnd 2.080806f
R1 g4302_0 g4302_1 2.224404
.ends

.subckt netg6047 g6047_1 g6047_0 gnd
C1  g6047_1 gnd 2.080806f
C2  g6047_0 gnd 2.080806f
R1 g6047_1 g6047_0 2.224404
.ends

.subckt netg7358 g7358_0 g7358_1 gnd
C1  g7358_0 gnd 2.080806f
C2  g7358_1 gnd 2.080806f
R1 g7358_1 g7358_0 2.224404
.ends

.subckt netg4280 g4280_1 g4280_0 gnd
C1  g4280_1 gnd 2.080806f
C2  g4280_0 gnd 2.080806f
R1 g4280_0 g4280_1 2.224404
.ends

.subckt netg5411 g5411_1 g5411_0 gnd
C1  g5411_1 gnd 2.080806f
C2  g5411_0 gnd 2.080806f
R1 g5411_1 g5411_0 2.224404
.ends

.subckt netx22 x22_0 x22_1 gnd
C1  x22_0 gnd 2.080806f
C2  x22_1 gnd 2.080806f
R1 x22_0 x22_1 2.224404
.ends

.subckt netg1128 g1128_0 g1128_1 gnd
C1  g1128_0 gnd 2.080806f
C2  g1128_1 gnd 2.080806f
R1 g1128_0 g1128_1 2.224404
.ends

.subckt netg3691 g3691_2 g3691_0 gnd
C1  g3691_2 gnd 2.080806f
C2  g3691_0 gnd 2.080806f
R1 g3691_0 g3691_2 2.224404
.ends

.subckt netg7213 g7213_1 g7213_0 gnd
C1  g7213_1 gnd 2.080806f
C2  g7213_0 gnd 2.080806f
R1 g7213_0 g7213_1 2.224404
.ends

.subckt netg2764 g2764_0 g2764_1 gnd
C1  g2764_0 gnd 2.080806f
C2  g2764_1 gnd 2.080806f
R1 g2764_0 g2764_1 2.224404
.ends

.subckt netg6382 g6382_1 g6382_0 gnd
C1  g6382_1 gnd 2.080806f
C2  g6382_0 gnd 2.080806f
R1 g6382_1 g6382_0 2.224404
.ends

.subckt netg3894 g3894_1 g3894_0 gnd
C1  g3894_1 gnd 2.080806f
C2  g3894_0 gnd 2.080806f
R1 g3894_0 g3894_1 2.224404
.ends

.subckt netg6815 g6815_1 g6815_0 gnd
C1  g6815_1 gnd 2.080806f
C2  g6815_0 gnd 2.080806f
R1 g6815_0 g6815_1 2.224404
.ends

.subckt netg2773 g2773_0 g2773_1 gnd
C1  g2773_0 gnd 2.080806f
C2  g2773_1 gnd 2.080806f
R1 g2773_1 g2773_0 2.224404
.ends

.subckt netg2228 g2228_1 g2228_0 gnd
C1  g2228_1 gnd 2.080806f
C2  g2228_0 gnd 2.080806f
R1 g2228_1 g2228_0 2.224404
.ends

.subckt netg5246 g5246_1 g5246_0 gnd
C1  g5246_1 gnd 2.080806f
C2  g5246_0 gnd 2.080806f
R1 g5246_0 g5246_1 2.224404
.ends

.subckt netg2821 g2821_0 g2821_1 gnd
C1  g2821_0 gnd 2.080806f
C2  g2821_1 gnd 2.080806f
R1 g2821_0 g2821_1 2.224404
.ends

.subckt netx312 x312_0 x312_1 gnd
C1  x312_0 gnd 2.080806f
C2  x312_1 gnd 2.080806f
R1 x312_1 x312_0 2.224404
.ends

.subckt netg3983 g3983_1 g3983_0 gnd
C1  g3983_1 gnd 2.080806f
C2  g3983_0 gnd 2.080806f
R1 g3983_1 g3983_0 2.224404
.ends

.subckt netg4329 g4329_1 g4329_0 gnd
C1  g4329_1 gnd 2.080806f
C2  g4329_0 gnd 2.080806f
R1 g4329_1 g4329_0 2.224404
.ends

.subckt netg7374 g7374_0 g7374_1 gnd
C1  g7374_0 gnd 2.080806f
C2  g7374_1 gnd 2.080806f
R1 g7374_0 g7374_1 2.224404
.ends

.subckt netg2501 g2501_2 g2501_0 gnd
C1  g2501_2 gnd 2.080806f
C2  g2501_0 gnd 2.080806f
R1 g2501_0 g2501_2 2.224404
.ends

.subckt netg4100 g4100_1 g4100_0 gnd
C1  g4100_1 gnd 2.080806f
C2  g4100_0 gnd 2.080806f
R1 g4100_1 g4100_0 2.224404
.ends

.subckt netg6013 g6013_0 g6013_1 gnd
C1  g6013_0 gnd 2.080806f
C2  g6013_1 gnd 2.080806f
R1 g6013_0 g6013_1 2.224404
.ends

.subckt netg2760 g2760_1 g2760_0 gnd
C1  g2760_1 gnd 2.080806f
C2  g2760_0 gnd 2.080806f
R1 g2760_1 g2760_0 2.224404
.ends

.subckt netg7212 g7212_0 g7212_1 gnd
C1  g7212_0 gnd 2.080806f
C2  g7212_1 gnd 2.080806f
R1 g7212_1 g7212_0 2.224404
.ends

.subckt netg3923 g3923_1 g3923_0 gnd
C1  g3923_1 gnd 2.080806f
C2  g3923_0 gnd 2.080806f
R1 g3923_1 g3923_0 2.224404
.ends

.subckt netg3414 g3414_2 g3414_1 gnd
C1  g3414_2 gnd 2.080806f
C2  g3414_1 gnd 2.080806f
R1 g3414_1 g3414_2 2.224404
.ends

.subckt netg5597 g5597_0 g5597_1 gnd
C1  g5597_0 gnd 2.080806f
C2  g5597_1 gnd 2.080806f
R1 g5597_0 g5597_1 2.224404
.ends

.subckt netg4298 g4298_0 g4298_1 gnd
C1  g4298_0 gnd 2.080806f
C2  g4298_1 gnd 2.080806f
R1 g4298_1 g4298_0 2.224404
.ends

.subckt netg7046 g7046_0 g7046_1 gnd
C1  g7046_0 gnd 2.080806f
C2  g7046_1 gnd 2.080806f
R1 g7046_0 g7046_1 2.224404
.ends

.subckt netg6452 g6452_1 g6452_0 gnd
C1  g6452_1 gnd 2.080806f
C2  g6452_0 gnd 2.080806f
R1 g6452_1 g6452_0 2.224404
.ends

.subckt netg6081 g6081_1 g6081_0 gnd
C1  g6081_1 gnd 2.080806f
C2  g6081_0 gnd 2.080806f
R1 g6081_0 g6081_1 2.224404
.ends

.subckt netg5448 g5448_2 g5448_1 gnd
C1  g5448_2 gnd 2.080806f
C2  g5448_1 gnd 2.080806f
R1 g5448_1 g5448_2 2.224404
.ends

.subckt netg3367 g3367_1 g3367_0 gnd
C1  g3367_1 gnd 2.080806f
C2  g3367_0 gnd 2.080806f
R1 g3367_0 g3367_1 2.224404
.ends

.subckt netg5353 g5353_0 g5353_1 gnd
C1  g5353_0 gnd 2.080806f
C2  g5353_1 gnd 2.080806f
R1 g5353_1 g5353_0 2.224404
.ends

.subckt netg7191 g7191_0 g7191_1 gnd
C1  g7191_0 gnd 2.080806f
C2  g7191_1 gnd 2.080806f
R1 g7191_1 g7191_0 2.224404
.ends

.subckt netg4013 g4013_0 g4013_1 gnd
C1  g4013_0 gnd 2.080806f
C2  g4013_1 gnd 2.080806f
R1 g4013_0 g4013_1 2.224404
.ends

.subckt netg6580 g6580_0 g6580_1 gnd
C1  g6580_0 gnd 2.080806f
C2  g6580_1 gnd 2.080806f
R1 g6580_1 g6580_0 2.224404
.ends

.subckt netg2350 g2350_2 g2350_0 gnd
C1  g2350_2 gnd 2.080806f
C2  g2350_0 gnd 2.080806f
R1 g2350_2 g2350_0 2.224404
.ends

.subckt netg3519 g3519_1 g3519_0 gnd
C1  g3519_1 gnd 2.080806f
C2  g3519_0 gnd 2.080806f
R1 g3519_1 g3519_0 2.224404
.ends

.subckt netg387 g387_0 g387_1 gnd
C1  g387_0 gnd 2.080806f
C2  g387_1 gnd 2.080806f
R1 g387_0 g387_1 2.224404
.ends

.subckt netg6199 g6199_2 g6199_0 gnd
C1  g6199_2 gnd 2.080806f
C2  g6199_0 gnd 2.080806f
R1 g6199_2 g6199_0 2.224404
.ends

.subckt netg7293 g7293_1 g7293_0 gnd
C1  g7293_1 gnd 2.080806f
C2  g7293_0 gnd 2.080806f
R1 g7293_1 g7293_0 2.224404
.ends

.subckt netg1432 g1432_0 g1432_1 gnd
C1  g1432_0 gnd 2.080806f
C2  g1432_1 gnd 2.080806f
R1 g1432_0 g1432_1 2.224404
.ends

.subckt netg1378 g1378_1 g1378_0 gnd
C1  g1378_1 gnd 2.080806f
C2  g1378_0 gnd 2.080806f
R1 g1378_1 g1378_0 2.224404
.ends

.subckt netx332 x332_0 x332_1 gnd
C1  x332_0 gnd 2.080806f
C2  x332_1 gnd 2.080806f
R1 x332_0 x332_1 2.224404
.ends

.subckt netg6611 g6611_1 g6611_0 gnd
C1  g6611_1 gnd 2.080806f
C2  g6611_0 gnd 2.080806f
R1 g6611_0 g6611_1 2.224404
.ends

.subckt netg3564 g3564_0 g3564_1 gnd
C1  g3564_0 gnd 2.080806f
C2  g3564_1 gnd 2.080806f
R1 g3564_0 g3564_1 2.224404
.ends

.subckt netg2774 g2774_1 g2774_0 gnd
C1  g2774_1 gnd 2.080806f
C2  g2774_0 gnd 2.080806f
R1 g2774_0 g2774_1 2.224404
.ends

.subckt netg1313 g1313_0 g1313_1 gnd
C1  g1313_0 gnd 2.080806f
C2  g1313_1 gnd 2.080806f
R1 g1313_1 g1313_0 2.224404
.ends

.subckt netg6741 g6741_1 g6741_0 gnd
C1  g6741_1 gnd 2.080806f
C2  g6741_0 gnd 2.080806f
R1 g6741_0 g6741_1 2.224404
.ends

.subckt netg4290 g4290_0 g4290_1 gnd
C1  g4290_0 gnd 2.080806f
C2  g4290_1 gnd 2.080806f
R1 g4290_1 g4290_0 2.224404
.ends

.subckt netg6931 g6931_1 g6931_0 gnd
C1  g6931_1 gnd 2.080806f
C2  g6931_0 gnd 2.080806f
R1 g6931_0 g6931_1 2.224404
.ends

.subckt netg5859 g5859_1 g5859_0 gnd
C1  g5859_1 gnd 2.080806f
C2  g5859_0 gnd 2.080806f
R1 g5859_0 g5859_1 2.224404
.ends

.subckt netg5827 g5827_0 g5827_1 gnd
C1  g5827_0 gnd 2.080806f
C2  g5827_1 gnd 2.080806f
R1 g5827_1 g5827_0 2.224404
.ends

.subckt netg4428 g4428_0 g4428_1 gnd
C1  g4428_0 gnd 2.080806f
C2  g4428_1 gnd 2.080806f
R1 g4428_1 g4428_0 2.224404
.ends

.subckt netg4220 g4220_0 g4220_1 gnd
C1  g4220_0 gnd 2.080806f
C2  g4220_1 gnd 2.080806f
R1 g4220_0 g4220_1 2.224404
.ends

.subckt netg1174 g1174_0 g1174_1 gnd
C1  g1174_0 gnd 2.080806f
C2  g1174_1 gnd 2.080806f
R1 g1174_0 g1174_1 2.224404
.ends

.subckt netg5857 g5857_0 g5857_1 gnd
C1  g5857_0 gnd 2.080806f
C2  g5857_1 gnd 2.080806f
R1 g5857_0 g5857_1 2.224404
.ends

.subckt netg4103 g4103_1 g4103_0 gnd
C1  g4103_1 gnd 2.080806f
C2  g4103_0 gnd 2.080806f
R1 g4103_0 g4103_1 2.224404
.ends

.subckt netg6102 g6102_0 g6102_1 gnd
C1  g6102_0 gnd 2.080806f
C2  g6102_1 gnd 2.080806f
R1 g6102_1 g6102_0 2.224404
.ends

.subckt netg3070 g3070_0 g3070_1 gnd
C1  g3070_0 gnd 2.080806f
C2  g3070_1 gnd 2.080806f
R1 g3070_1 g3070_0 2.224404
.ends

.subckt netg6474 g6474_1 g6474_0 gnd
C1  g6474_1 gnd 2.080806f
C2  g6474_0 gnd 2.080806f
R1 g6474_1 g6474_0 2.224404
.ends

.subckt netg2781 g2781_1 g2781_0 gnd
C1  g2781_1 gnd 2.080806f
C2  g2781_0 gnd 2.080806f
R1 g2781_0 g2781_1 2.224404
.ends

.subckt netg7397 g7397_1 g7397_0 gnd
C1  g7397_1 gnd 2.080806f
C2  g7397_0 gnd 2.080806f
R1 g7397_0 g7397_1 2.224404
.ends

.subckt netg1284 g1284_0 g1284_1 gnd
C1  g1284_0 gnd 2.080806f
C2  g1284_1 gnd 2.080806f
R1 g1284_1 g1284_0 2.224404
.ends

.subckt netg410 g410_2 g410_0 gnd
C1  g410_2 gnd 2.080806f
C2  g410_0 gnd 2.080806f
R1 g410_2 g410_0 2.224404
.ends

.subckt netg2778 g2778_0 g2778_1 gnd
C1  g2778_0 gnd 2.080806f
C2  g2778_1 gnd 2.080806f
R1 g2778_0 g2778_1 2.224404
.ends

.subckt netg4283 g4283_0 g4283_1 gnd
C1  g4283_0 gnd 2.080806f
C2  g4283_1 gnd 2.080806f
R1 g4283_0 g4283_1 2.224404
.ends

.subckt netg6345 g6345_0 g6345_1 gnd
C1  g6345_0 gnd 2.080806f
C2  g6345_1 gnd 2.080806f
R1 g6345_0 g6345_1 2.224404
.ends

.subckt netg5766 g5766_0 g5766_1 gnd
C1  g5766_0 gnd 2.080806f
C2  g5766_1 gnd 2.080806f
R1 g5766_1 g5766_0 2.224404
.ends

.subckt netg6254 g6254_0 g6254_1 gnd
C1  g6254_0 gnd 2.080806f
C2  g6254_1 gnd 2.080806f
R1 g6254_0 g6254_1 2.224404
.ends

.subckt netg3069 g3069_1 g3069_0 gnd
C1  g3069_1 gnd 2.080806f
C2  g3069_0 gnd 2.080806f
R1 g3069_1 g3069_0 2.224404
.ends

.subckt netg6640 g6640_1 g6640_0 gnd
C1  g6640_1 gnd 2.080806f
C2  g6640_0 gnd 2.080806f
R1 g6640_1 g6640_0 2.224404
.ends

.subckt netg6014 g6014_1 g6014_0 gnd
C1  g6014_1 gnd 2.080806f
C2  g6014_0 gnd 2.080806f
R1 g6014_1 g6014_0 2.224404
.ends

.subckt netg4216 g4216_1 g4216_0 gnd
C1  g4216_1 gnd 2.080806f
C2  g4216_0 gnd 2.080806f
R1 g4216_0 g4216_1 2.224404
.ends

.subckt netg1945 g1945_2 g1945_1 gnd
C1  g1945_2 gnd 2.080806f
C2  g1945_1 gnd 2.080806f
R1 g1945_1 g1945_2 2.224404
.ends

.subckt netg5527 g5527_0 g5527_1 gnd
C1  g5527_0 gnd 2.080806f
C2  g5527_1 gnd 2.080806f
R1 g5527_1 g5527_0 2.224404
.ends

.subckt netg2371 g2371_1 g2371_2 gnd
C1  g2371_1 gnd 2.080806f
C2  g2371_2 gnd 2.080806f
R1 g2371_1 g2371_2 2.224404
.ends

.subckt netx82 x82_1 x82_0 gnd
C1  x82_1 gnd 2.080806f
C2  x82_0 gnd 2.080806f
R1 x82_1 x82_0 2.224404
.ends

.subckt netg2751 g2751_0 g2751_1 gnd
C1  g2751_0 gnd 2.080806f
C2  g2751_1 gnd 2.080806f
R1 g2751_0 g2751_1 2.224404
.ends

.subckt netg4219 g4219_1 g4219_0 gnd
C1  g4219_1 gnd 2.080806f
C2  g4219_0 gnd 2.080806f
R1 g4219_1 g4219_0 2.224404
.ends

.subckt netg5998 g5998_0 g5998_1 gnd
C1  g5998_0 gnd 2.080806f
C2  g5998_1 gnd 2.080806f
R1 g5998_0 g5998_1 2.224404
.ends

.subckt netg5065 g5065_2 g5065_1 gnd
C1  g5065_2 gnd 2.080806f
C2  g5065_1 gnd 2.080806f
R1 g5065_2 g5065_1 2.224404
.ends

.subckt netg6103 g6103_0 g6103_1 gnd
C1  g6103_0 gnd 2.080806f
C2  g6103_1 gnd 2.080806f
R1 g6103_0 g6103_1 2.224404
.ends

.subckt netg7047 g7047_0 g7047_1 gnd
C1  g7047_0 gnd 2.080806f
C2  g7047_1 gnd 2.080806f
R1 g7047_0 g7047_1 2.224404
.ends

.subckt netg5316 g5316_0 g5316_1 gnd
C1  g5316_0 gnd 2.080806f
C2  g5316_1 gnd 2.080806f
R1 g5316_1 g5316_0 2.224404
.ends

.subckt netg7405 g7405_1 g7405_0 gnd
C1  g7405_1 gnd 2.080806f
C2  g7405_0 gnd 2.080806f
R1 g7405_1 g7405_0 2.224404
.ends

.subckt netg1518 g1518_1 g1518_0 gnd
C1  g1518_1 gnd 2.080806f
C2  g1518_0 gnd 2.080806f
R1 g1518_1 g1518_0 2.224404
.ends

.subckt netg5191 g5191_0 g5191_2 gnd
C1  g5191_0 gnd 2.080806f
C2  g5191_2 gnd 2.080806f
R1 g5191_0 g5191_2 2.224404
.ends

.subckt netg5996 g5996_0 g5996_1 gnd
C1  g5996_0 gnd 2.080806f
C2  g5996_1 gnd 2.080806f
R1 g5996_0 g5996_1 2.224404
.ends

.subckt netg1125 g1125_1 g1125_0 gnd
C1  g1125_1 gnd 2.080806f
C2  g1125_0 gnd 2.080806f
R1 g1125_1 g1125_0 2.224404
.ends

.subckt netg5792 g5792_1 g5792_0 gnd
C1  g5792_1 gnd 2.080806f
C2  g5792_0 gnd 2.080806f
R1 g5792_1 g5792_0 2.224404
.ends

.subckt netg2380 g2380_2 g2380_1 gnd
C1  g2380_2 gnd 2.080806f
C2  g2380_1 gnd 2.080806f
R1 g2380_1 g2380_2 2.224404
.ends

.subckt netg6084 g6084_0 g6084_1 gnd
C1  g6084_0 gnd 2.080806f
C2  g6084_1 gnd 2.080806f
R1 g6084_1 g6084_0 2.224404
.ends

.subckt netg6052 g6052_0 g6052_1 gnd
C1  g6052_0 gnd 2.080806f
C2  g6052_1 gnd 2.080806f
R1 g6052_1 g6052_0 2.224404
.ends

.subckt netg5297 g5297_1 g5297_0 gnd
C1  g5297_1 gnd 2.080806f
C2  g5297_0 gnd 2.080806f
R1 g5297_0 g5297_1 2.224404
.ends

.subckt netg4323 g4323_1 g4323_0 gnd
C1  g4323_1 gnd 2.080806f
C2  g4323_0 gnd 2.080806f
R1 g4323_0 g4323_1 2.224404
.ends

.subckt netg4628 g4628_0 g4628_1 gnd
C1  g4628_0 gnd 2.080806f
C2  g4628_1 gnd 2.080806f
R1 g4628_0 g4628_1 2.224404
.ends

.subckt netg3540 g3540_1 g3540_0 gnd
C1  g3540_1 gnd 2.080806f
C2  g3540_0 gnd 2.080806f
R1 g3540_1 g3540_0 2.224404
.ends

.subckt netg4065 g4065_1 g4065_0 gnd
C1  g4065_1 gnd 2.080806f
C2  g4065_0 gnd 2.080806f
R1 g4065_1 g4065_0 2.224404
.ends

.subckt netg4239 g4239_1 g4239_0 gnd
C1  g4239_1 gnd 2.080806f
C2  g4239_0 gnd 2.080806f
R1 g4239_1 g4239_0 2.224404
.ends

.subckt netg5350 g5350_0 g5350_1 gnd
C1  g5350_0 gnd 2.080806f
C2  g5350_1 gnd 2.080806f
R1 g5350_0 g5350_1 2.224404
.ends

.subckt netg1234 g1234_0 g1234_1 gnd
C1  g1234_0 gnd 2.080806f
C2  g1234_1 gnd 2.080806f
R1 g1234_0 g1234_1 2.224404
.ends

.subckt netg4318 g4318_1 g4318_0 gnd
C1  g4318_1 gnd 2.080806f
C2  g4318_0 gnd 2.080806f
R1 g4318_1 g4318_0 2.224404
.ends

.subckt netg6667 g6667_1 g6667_0 gnd
C1  g6667_1 gnd 2.080806f
C2  g6667_0 gnd 2.080806f
R1 g6667_0 g6667_1 2.224404
.ends

.subckt netg5737 g5737_2 g5737_1 gnd
C1  g5737_2 gnd 2.080806f
C2  g5737_1 gnd 2.080806f
R1 g5737_1 g5737_2 2.224404
.ends

.subckt netg7004 g7004_1 g7004_2 gnd
C1  g7004_1 gnd 2.080806f
C2  g7004_2 gnd 2.080806f
R1 g7004_2 g7004_1 2.224404
.ends

.subckt netg5244 g5244_1 g5244_0 gnd
C1  g5244_1 gnd 2.080806f
C2  g5244_0 gnd 2.080806f
R1 g5244_1 g5244_0 2.224404
.ends

.subckt netg6184 g6184_1 g6184_0 gnd
C1  g6184_1 gnd 2.080806f
C2  g6184_0 gnd 2.080806f
R1 g6184_0 g6184_1 2.224404
.ends

.subckt netg6862 g6862_0 g6862_1 gnd
C1  g6862_0 gnd 2.080806f
C2  g6862_1 gnd 2.080806f
R1 g6862_0 g6862_1 2.224404
.ends

.subckt netg1264 g1264_0 g1264_1 gnd
C1  g1264_0 gnd 2.080806f
C2  g1264_1 gnd 2.080806f
R1 g1264_0 g1264_1 2.224404
.ends

.subckt netg2879 g2879_1 g2879_0 gnd
C1  g2879_1 gnd 2.080806f
C2  g2879_0 gnd 2.080806f
R1 g2879_0 g2879_1 2.224404
.ends

.subckt netg3509 g3509_0 g3509_1 gnd
C1  g3509_0 gnd 2.080806f
C2  g3509_1 gnd 2.080806f
R1 g3509_0 g3509_1 2.224404
.ends

.subckt netg3411 g3411_0 g3411_1 gnd
C1  g3411_0 gnd 2.080806f
C2  g3411_1 gnd 2.080806f
R1 g3411_0 g3411_1 2.224404
.ends

.subckt netg2719 g2719_1 g2719_2 gnd
C1  g2719_1 gnd 2.080806f
C2  g2719_2 gnd 2.080806f
R1 g2719_2 g2719_1 2.224404
.ends

.subckt netg6642 g6642_1 g6642_2 gnd
C1  g6642_1 gnd 2.080806f
C2  g6642_2 gnd 2.080806f
R1 g6642_1 g6642_2 2.224404
.ends

.subckt netg5601 g5601_1 g5601_0 gnd
C1  g5601_1 gnd 2.080806f
C2  g5601_0 gnd 2.080806f
R1 g5601_1 g5601_0 2.224404
.ends

.subckt netg6287 g6287_0 g6287_1 gnd
C1  g6287_0 gnd 2.080806f
C2  g6287_1 gnd 2.080806f
R1 g6287_1 g6287_0 2.224404
.ends

.subckt netg5182 g5182_0 g5182_1 gnd
C1  g5182_0 gnd 2.080806f
C2  g5182_1 gnd 2.080806f
R1 g5182_0 g5182_1 2.224404
.ends

.subckt netg4344 g4344_1 g4344_0 gnd
C1  g4344_1 gnd 2.080806f
C2  g4344_0 gnd 2.080806f
R1 g4344_1 g4344_0 2.224404
.ends

.subckt netg7399 g7399_1 g7399_0 gnd
C1  g7399_1 gnd 2.080806f
C2  g7399_0 gnd 2.080806f
R1 g7399_0 g7399_1 2.224404
.ends

.subckt netg1461 g1461_1 g1461_0 gnd
C1  g1461_1 gnd 2.080806f
C2  g1461_0 gnd 2.080806f
R1 g1461_0 g1461_1 2.224404
.ends

.subckt netg1123 g1123_1 g1123_0 gnd
C1  g1123_1 gnd 2.080806f
C2  g1123_0 gnd 2.080806f
R1 g1123_0 g1123_1 2.224404
.ends

.subckt netg5322 g5322_1 g5322_0 gnd
C1  g5322_1 gnd 2.080806f
C2  g5322_0 gnd 2.080806f
R1 g5322_0 g5322_1 2.224404
.ends

.subckt netg4010 g4010_1 g4010_0 gnd
C1  g4010_1 gnd 2.080806f
C2  g4010_0 gnd 2.080806f
R1 g4010_0 g4010_1 2.224404
.ends

.subckt netx21 x21_0 x21_1 gnd
C1  x21_0 gnd 2.080806f
C2  x21_1 gnd 2.080806f
R1 x21_1 x21_0 2.224404
.ends

.subckt netg2847 g2847_1 g2847_0 gnd
C1  g2847_1 gnd 2.080806f
C2  g2847_0 gnd 2.080806f
R1 g2847_0 g2847_1 2.224404
.ends

.subckt netg1222 g1222_0 g1222_1 gnd
C1  g1222_0 gnd 2.080806f
C2  g1222_1 gnd 2.080806f
R1 g1222_1 g1222_0 2.224404
.ends

.subckt netg1916 g1916_1 g1916_0 gnd
C1  g1916_1 gnd 2.080806f
C2  g1916_0 gnd 2.080806f
R1 g1916_1 g1916_0 2.224404
.ends

.subckt netg5425 g5425_1 g5425_0 gnd
C1  g5425_1 gnd 2.080806f
C2  g5425_0 gnd 2.080806f
R1 g5425_1 g5425_0 2.224404
.ends

.subckt netg6385 g6385_0 g6385_1 gnd
C1  g6385_0 gnd 2.080806f
C2  g6385_1 gnd 2.080806f
R1 g6385_1 g6385_0 2.224404
.ends

.subckt netg2240 g2240_1 g2240_0 gnd
C1  g2240_1 gnd 2.080806f
C2  g2240_0 gnd 2.080806f
R1 g2240_0 g2240_1 2.224404
.ends

.subckt netg5603 g5603_1 g5603_0 gnd
C1  g5603_1 gnd 2.080806f
C2  g5603_0 gnd 2.080806f
R1 g5603_0 g5603_1 2.224404
.ends

.subckt netg4043 g4043_0 g4043_1 gnd
C1  g4043_0 gnd 2.080806f
C2  g4043_1 gnd 2.080806f
R1 g4043_1 g4043_0 2.224404
.ends

.subckt netg4404 g4404_1 g4404_0 gnd
C1  g4404_1 gnd 2.080806f
C2  g4404_0 gnd 2.080806f
R1 g4404_0 g4404_1 2.224404
.ends

.subckt netg1491 g1491_0 g1491_1 gnd
C1  g1491_0 gnd 2.080806f
C2  g1491_1 gnd 2.080806f
R1 g1491_1 g1491_0 2.224404
.ends

.subckt netg5965 g5965_0 g5965_1 gnd
C1  g5965_0 gnd 2.080806f
C2  g5965_1 gnd 2.080806f
R1 g5965_1 g5965_0 2.224404
.ends

.subckt netg6137 g6137_0 g6137_1 gnd
C1  g6137_0 gnd 2.080806f
C2  g6137_1 gnd 2.080806f
R1 g6137_1 g6137_0 2.224404
.ends

.subckt netg2945 g2945_1 g2945_0 gnd
C1  g2945_1 gnd 2.080806f
C2  g2945_0 gnd 2.080806f
R1 g2945_1 g2945_0 2.224404
.ends

.subckt netx61 x61_0 x61_1 gnd
C1  x61_0 gnd 2.080806f
C2  x61_1 gnd 2.080806f
R1 x61_1 x61_0 2.224404
.ends

.subckt netg7093 g7093_1 g7093_2 gnd
C1  g7093_1 gnd 2.080806f
C2  g7093_2 gnd 2.080806f
R1 g7093_1 g7093_2 2.224404
.ends

.subckt netg6420 g6420_0 g6420_1 gnd
C1  g6420_0 gnd 2.080806f
C2  g6420_1 gnd 2.080806f
R1 g6420_0 g6420_1 2.224404
.ends

.subckt netg874 g874_0 g874_2 gnd
C1  g874_0 gnd 2.080806f
C2  g874_2 gnd 2.080806f
R1 g874_2 g874_0 2.224404
.ends

.subckt netg7344 g7344_1 g7344_0 gnd
C1  g7344_1 gnd 2.080806f
C2  g7344_0 gnd 2.080806f
R1 g7344_0 g7344_1 2.224404
.ends

.subckt netg6243 g6243_1 g6243_0 gnd
C1  g6243_1 gnd 2.080806f
C2  g6243_0 gnd 2.080806f
R1 g6243_1 g6243_0 2.224404
.ends

.subckt netg1069 g1069_0 g1069_1 gnd
C1  g1069_0 gnd 2.080806f
C2  g1069_1 gnd 2.080806f
R1 g1069_1 g1069_0 2.224404
.ends

.subckt netg6846 g6846_1 g6846_0 gnd
C1  g6846_1 gnd 2.080806f
C2  g6846_0 gnd 2.080806f
R1 g6846_0 g6846_1 2.224404
.ends

.subckt netg4353 g4353_1 g4353_0 gnd
C1  g4353_1 gnd 2.080806f
C2  g4353_0 gnd 2.080806f
R1 g4353_1 g4353_0 2.224404
.ends

.subckt netg1250 g1250_1 g1250_0 gnd
C1  g1250_1 gnd 2.080806f
C2  g1250_0 gnd 2.080806f
R1 g1250_0 g1250_1 2.224404
.ends

.subckt netg5270 g5270_0 g5270_1 gnd
C1  g5270_0 gnd 2.080806f
C2  g5270_1 gnd 2.080806f
R1 g5270_0 g5270_1 2.224404
.ends

.subckt netg2918 g2918_0 g2918_1 gnd
C1  g2918_0 gnd 2.080806f
C2  g2918_1 gnd 2.080806f
R1 g2918_0 g2918_1 2.224404
.ends

.subckt netg5980 g5980_0 g5980_1 gnd
C1  g5980_0 gnd 2.080806f
C2  g5980_1 gnd 2.080806f
R1 g5980_0 g5980_1 2.224404
.ends

.subckt netg1307 g1307_1 g1307_0 gnd
C1  g1307_1 gnd 2.080806f
C2  g1307_0 gnd 2.080806f
R1 g1307_1 g1307_0 2.224404
.ends

.subckt netg7273 g7273_1 g7273_0 gnd
C1  g7273_1 gnd 2.080806f
C2  g7273_0 gnd 2.080806f
R1 g7273_1 g7273_0 2.224404
.ends

.subckt netg2743 g2743_2 g2743_1 gnd
C1  g2743_2 gnd 2.080806f
C2  g2743_1 gnd 2.080806f
R1 g2743_2 g2743_1 2.224404
.ends

.subckt netg3207 g3207_1 g3207_2 gnd
C1  g3207_1 gnd 2.080806f
C2  g3207_2 gnd 2.080806f
R1 g3207_1 g3207_2 2.224404
.ends

.subckt netx471 x471_0 x471_1 gnd
C1  x471_0 gnd 2.080806f
C2  x471_1 gnd 2.080806f
R1 x471_1 x471_0 2.224404
.ends

.subckt netg7275 g7275_0 g7275_1 gnd
C1  g7275_0 gnd 2.080806f
C2  g7275_1 gnd 2.080806f
R1 g7275_0 g7275_1 2.224404
.ends

.subckt netg5266 g5266_1 g5266_0 gnd
C1  g5266_1 gnd 2.080806f
C2  g5266_0 gnd 2.080806f
R1 g5266_0 g5266_1 2.224404
.ends

.subckt netg4265 g4265_0 g4265_1 gnd
C1  g4265_0 gnd 2.080806f
C2  g4265_1 gnd 2.080806f
R1 g4265_0 g4265_1 2.224404
.ends

.subckt netg4022 g4022_1 g4022_0 gnd
C1  g4022_1 gnd 2.080806f
C2  g4022_0 gnd 2.080806f
R1 g4022_1 g4022_0 2.224404
.ends

.subckt netg1360 g1360_0 g1360_1 gnd
C1  g1360_0 gnd 2.080806f
C2  g1360_1 gnd 2.080806f
R1 g1360_0 g1360_1 2.224404
.ends

.subckt netg6399 g6399_0 g6399_1 gnd
C1  g6399_0 gnd 2.080806f
C2  g6399_1 gnd 2.080806f
R1 g6399_0 g6399_1 2.224404
.ends

.subckt netg6182 g6182_0 g6182_1 gnd
C1  g6182_0 gnd 2.080806f
C2  g6182_1 gnd 2.080806f
R1 g6182_0 g6182_1 2.224404
.ends

.subckt netg6673 g6673_0 g6673_1 gnd
C1  g6673_0 gnd 2.080806f
C2  g6673_1 gnd 2.080806f
R1 g6673_0 g6673_1 2.224404
.ends

.subckt netg3082 g3082_1 g3082_0 gnd
C1  g3082_1 gnd 2.080806f
C2  g3082_0 gnd 2.080806f
R1 g3082_0 g3082_1 2.224404
.ends

.subckt netg2930 g2930_1 g2930_0 gnd
C1  g2930_1 gnd 2.080806f
C2  g2930_0 gnd 2.080806f
R1 g2930_1 g2930_0 2.224404
.ends

.subckt netg1494 g1494_0 g1494_1 gnd
C1  g1494_0 gnd 2.080806f
C2  g1494_1 gnd 2.080806f
R1 g1494_1 g1494_0 2.224404
.ends

.subckt netg5368 g5368_0 g5368_1 gnd
C1  g5368_0 gnd 2.080806f
C2  g5368_1 gnd 2.080806f
R1 g5368_1 g5368_0 2.224404
.ends

.subckt netg1422 g1422_0 g1422_1 gnd
C1  g1422_0 gnd 2.080806f
C2  g1422_1 gnd 2.080806f
R1 g1422_0 g1422_1 2.224404
.ends

.subckt netg2937 g2937_1 g2937_0 gnd
C1  g2937_1 gnd 2.080806f
C2  g2937_0 gnd 2.080806f
R1 g2937_0 g2937_1 2.224404
.ends

.subckt netg2555 g2555_1 g2555_2 gnd
C1  g2555_1 gnd 2.080806f
C2  g2555_2 gnd 2.080806f
R1 g2555_1 g2555_2 2.224404
.ends

.subckt netg3061 g3061_0 g3061_1 gnd
C1  g3061_0 gnd 2.080806f
C2  g3061_1 gnd 2.080806f
R1 g3061_0 g3061_1 2.224404
.ends

.subckt netg5394 g5394_0 g5394_1 gnd
C1  g5394_0 gnd 2.080806f
C2  g5394_1 gnd 2.080806f
R1 g5394_1 g5394_0 2.224404
.ends

.subckt netg2845 g2845_1 g2845_0 gnd
C1  g2845_1 gnd 2.080806f
C2  g2845_0 gnd 2.080806f
R1 g2845_0 g2845_1 2.224404
.ends

.subckt netg1534 g1534_1 g1534_0 gnd
C1  g1534_1 gnd 2.080806f
C2  g1534_0 gnd 2.080806f
R1 g1534_1 g1534_0 2.224404
.ends

.subckt netg3045 g3045_1 g3045_0 gnd
C1  g3045_1 gnd 2.080806f
C2  g3045_0 gnd 2.080806f
R1 g3045_0 g3045_1 2.224404
.ends

.subckt netg6887 g6887_1 g6887_0 gnd
C1  g6887_1 gnd 2.080806f
C2  g6887_0 gnd 2.080806f
R1 g6887_1 g6887_0 2.224404
.ends

.subckt netg6278 g6278_0 g6278_2 gnd
C1  g6278_0 gnd 2.080806f
C2  g6278_2 gnd 2.080806f
R1 g6278_0 g6278_2 2.224404
.ends

.subckt netg6977 g6977_0 g6977_1 gnd
C1  g6977_0 gnd 2.080806f
C2  g6977_1 gnd 2.080806f
R1 g6977_0 g6977_1 2.224404
.ends

.subckt netg3551 g3551_1 g3551_0 gnd
C1  g3551_1 gnd 2.080806f
C2  g3551_0 gnd 2.080806f
R1 g3551_0 g3551_1 2.224404
.ends

.subckt netg6751 g6751_2 g6751_0 gnd
C1  g6751_2 gnd 2.080806f
C2  g6751_0 gnd 2.080806f
R1 g6751_0 g6751_2 2.224404
.ends

.subckt netx72 x72_1 x72_0 gnd
C1  x72_1 gnd 2.080806f
C2  x72_0 gnd 2.080806f
R1 x72_1 x72_0 2.224404
.ends

.subckt netg5421 g5421_1 g5421_0 gnd
C1  g5421_1 gnd 2.080806f
C2  g5421_0 gnd 2.080806f
R1 g5421_0 g5421_1 2.224404
.ends

.subckt netx122 x122_1 x122_0 gnd
C1  x122_1 gnd 2.080806f
C2  x122_0 gnd 2.080806f
R1 x122_0 x122_1 2.224404
.ends

.subckt netg5251 g5251_1 g5251_0 gnd
C1  g5251_1 gnd 2.080806f
C2  g5251_0 gnd 2.080806f
R1 g5251_0 g5251_1 2.224404
.ends

.subckt netg2784 g2784_1 g2784_0 gnd
C1  g2784_1 gnd 2.080806f
C2  g2784_0 gnd 2.080806f
R1 g2784_1 g2784_0 2.224404
.ends

.subckt netx131 x131_1 x131_0 gnd
C1  x131_1 gnd 2.080806f
C2  x131_0 gnd 2.080806f
R1 x131_0 x131_1 2.224404
.ends

.subckt netg6814 g6814_1 g6814_0 gnd
C1  g6814_1 gnd 2.080806f
C2  g6814_0 gnd 2.080806f
R1 g6814_0 g6814_1 2.224404
.ends

.subckt netg6205 g6205_1 g6205_0 gnd
C1  g6205_1 gnd 2.080806f
C2  g6205_0 gnd 2.080806f
R1 g6205_0 g6205_1 2.224404
.ends

.subckt netg6693 g6693_1 g6693_0 gnd
C1  g6693_1 gnd 2.080806f
C2  g6693_0 gnd 2.080806f
R1 g6693_0 g6693_1 2.224404
.ends

.subckt netg6465 g6465_0 g6465_1 gnd
C1  g6465_0 gnd 2.080806f
C2  g6465_1 gnd 2.080806f
R1 g6465_0 g6465_1 2.224404
.ends

.subckt netg2995 g2995_1 g2995_0 gnd
C1  g2995_1 gnd 2.080806f
C2  g2995_0 gnd 2.080806f
R1 g2995_0 g2995_1 2.224404
.ends

.subckt netg3261 g3261_2 g3261_0 gnd
C1  g3261_2 gnd 2.080806f
C2  g3261_0 gnd 2.080806f
R1 g3261_0 g3261_2 2.224404
.ends

.subckt netg1236 g1236_0 g1236_1 gnd
C1  g1236_0 gnd 2.080806f
C2  g1236_1 gnd 2.080806f
R1 g1236_0 g1236_1 2.224404
.ends

.subckt netg5333 g5333_0 g5333_1 gnd
C1  g5333_0 gnd 2.080806f
C2  g5333_1 gnd 2.080806f
R1 g5333_1 g5333_0 2.224404
.ends

.subckt netg4098 g4098_1 g4098_0 gnd
C1  g4098_1 gnd 2.080806f
C2  g4098_0 gnd 2.080806f
R1 g4098_0 g4098_1 2.224404
.ends

.subckt netg5144 g5144_1 g5144_2 gnd
C1  g5144_1 gnd 2.080806f
C2  g5144_2 gnd 2.080806f
R1 g5144_2 g5144_1 2.224404
.ends

.subckt netg1375 g1375_0 g1375_1 gnd
C1  g1375_0 gnd 2.080806f
C2  g1375_1 gnd 2.080806f
R1 g1375_1 g1375_0 2.224404
.ends

.subckt netg5366 g5366_0 g5366_1 gnd
C1  g5366_0 gnd 2.080806f
C2  g5366_1 gnd 2.080806f
R1 g5366_0 g5366_1 2.224404
.ends

.subckt netg4131 g4131_0 g4131_1 gnd
C1  g4131_0 gnd 2.080806f
C2  g4131_1 gnd 2.080806f
R1 g4131_1 g4131_0 2.224404
.ends

.subckt netg4240 g4240_1 g4240_0 gnd
C1  g4240_1 gnd 2.080806f
C2  g4240_0 gnd 2.080806f
R1 g4240_0 g4240_1 2.224404
.ends

.subckt netg3563 g3563_0 g3563_1 gnd
C1  g3563_0 gnd 2.080806f
C2  g3563_1 gnd 2.080806f
R1 g3563_0 g3563_1 2.224404
.ends

.subckt netg1158 g1158_0 g1158_1 gnd
C1  g1158_0 gnd 2.080806f
C2  g1158_1 gnd 2.080806f
R1 g1158_1 g1158_0 2.224404
.ends

.subckt netg7002 g7002_0 g7002_1 gnd
C1  g7002_0 gnd 2.080806f
C2  g7002_1 gnd 2.080806f
R1 g7002_0 g7002_1 2.224404
.ends

.subckt netg5870 g5870_1 g5870_0 gnd
C1  g5870_1 gnd 2.080806f
C2  g5870_0 gnd 2.080806f
R1 g5870_0 g5870_1 2.224404
.ends

.subckt netg4106 g4106_0 g4106_1 gnd
C1  g4106_0 gnd 2.080806f
C2  g4106_1 gnd 2.080806f
R1 g4106_0 g4106_1 2.224404
.ends

.subckt netg4352 g4352_1 g4352_0 gnd
C1  g4352_1 gnd 2.080806f
C2  g4352_0 gnd 2.080806f
R1 g4352_1 g4352_0 2.224404
.ends

.subckt netx91 x91_1 x91_0 gnd
C1  x91_1 gnd 2.080806f
C2  x91_0 gnd 2.080806f
R1 x91_0 x91_1 2.224404
.ends

.subckt netg5932 g5932_1 g5932_0 gnd
C1  g5932_1 gnd 2.080806f
C2  g5932_0 gnd 2.080806f
R1 g5932_1 g5932_0 2.224404
.ends

.subckt netg7306 g7306_2 g7306_1 gnd
C1  g7306_2 gnd 2.080806f
C2  g7306_1 gnd 2.080806f
R1 g7306_2 g7306_1 2.224404
.ends

.subckt netg2579 g2579_1 g2579_2 gnd
C1  g2579_1 gnd 2.080806f
C2  g2579_2 gnd 2.080806f
R1 g2579_1 g2579_2 2.224404
.ends

.subckt netg2919 g2919_0 g2919_1 gnd
C1  g2919_0 gnd 2.080806f
C2  g2919_1 gnd 2.080806f
R1 g2919_0 g2919_1 2.224404
.ends

.subckt netg3429 g3429_2 g3429_0 gnd
C1  g3429_2 gnd 2.080806f
C2  g3429_0 gnd 2.080806f
R1 g3429_0 g3429_2 2.224404
.ends

.subckt netg4082 g4082_1 g4082_0 gnd
C1  g4082_1 gnd 2.080806f
C2  g4082_0 gnd 2.080806f
R1 g4082_1 g4082_0 2.224404
.ends

.subckt netg3901 g3901_0 g3901_1 gnd
C1  g3901_0 gnd 2.080806f
C2  g3901_1 gnd 2.080806f
R1 g3901_1 g3901_0 2.224404
.ends

.subckt netg5999 g5999_1 g5999_0 gnd
C1  g5999_1 gnd 2.080806f
C2  g5999_0 gnd 2.080806f
R1 g5999_0 g5999_1 2.224404
.ends

.subckt netg4309 g4309_0 g4309_1 gnd
C1  g4309_0 gnd 2.080806f
C2  g4309_1 gnd 2.080806f
R1 g4309_1 g4309_0 2.224404
.ends

.subckt netg5705 g5705_1 g5705_0 gnd
C1  g5705_1 gnd 2.080806f
C2  g5705_0 gnd 2.080806f
R1 g5705_1 g5705_0 2.224404
.ends

.subckt netg6450 g6450_1 g6450_0 gnd
C1  g6450_1 gnd 2.080806f
C2  g6450_0 gnd 2.080806f
R1 g6450_1 g6450_0 2.224404
.ends

.subckt netg7240 g7240_1 g7240_0 gnd
C1  g7240_1 gnd 2.080806f
C2  g7240_0 gnd 2.080806f
R1 g7240_0 g7240_1 2.224404
.ends

.subckt netg6392 g6392_0 g6392_1 gnd
C1  g6392_0 gnd 2.080806f
C2  g6392_1 gnd 2.080806f
R1 g6392_0 g6392_1 2.224404
.ends

.subckt netg1169 g1169_1 g1169_0 gnd
C1  g1169_1 gnd 2.080806f
C2  g1169_0 gnd 2.080806f
R1 g1169_0 g1169_1 2.224404
.ends

.subckt netg6871 g6871_1 g6871_0 gnd
C1  g6871_1 gnd 2.080806f
C2  g6871_0 gnd 2.080806f
R1 g6871_0 g6871_1 2.224404
.ends

.subckt netg4138 g4138_0 g4138_1 gnd
C1  g4138_0 gnd 2.080806f
C2  g4138_1 gnd 2.080806f
R1 g4138_0 g4138_1 2.224404
.ends

.subckt netg6363 g6363_1 g6363_0 gnd
C1  g6363_1 gnd 2.080806f
C2  g6363_0 gnd 2.080806f
R1 g6363_1 g6363_0 2.224404
.ends

.subckt netg5278 g5278_0 g5278_1 gnd
C1  g5278_0 gnd 2.080806f
C2  g5278_1 gnd 2.080806f
R1 g5278_0 g5278_1 2.224404
.ends

.subckt netg1479 g1479_1 g1479_0 gnd
C1  g1479_1 gnd 2.080806f
C2  g1479_0 gnd 2.080806f
R1 g1479_0 g1479_1 2.224404
.ends

.subckt netg6167 g6167_0 g6167_1 gnd
C1  g6167_0 gnd 2.080806f
C2  g6167_1 gnd 2.080806f
R1 g6167_0 g6167_1 2.224404
.ends

.subckt netg6131 g6131_0 g6131_1 gnd
C1  g6131_0 gnd 2.080806f
C2  g6131_1 gnd 2.080806f
R1 g6131_1 g6131_0 2.224404
.ends

.subckt netg2933 g2933_0 g2933_1 gnd
C1  g2933_0 gnd 2.080806f
C2  g2933_1 gnd 2.080806f
R1 g2933_0 g2933_1 2.224404
.ends

.subckt netg6744 g6744_1 g6744_0 gnd
C1  g6744_1 gnd 2.080806f
C2  g6744_0 gnd 2.080806f
R1 g6744_0 g6744_1 2.224404
.ends

.subckt netg7400 g7400_1 g7400_0 gnd
C1  g7400_1 gnd 2.080806f
C2  g7400_0 gnd 2.080806f
R1 g7400_1 g7400_0 2.224404
.ends

.subckt netg1852 g1852_1 g1852_0 gnd
C1  g1852_1 gnd 2.080806f
C2  g1852_0 gnd 2.080806f
R1 g1852_0 g1852_1 2.224404
.ends

.subckt netg2731 g2731_1 g2731_2 gnd
C1  g2731_1 gnd 2.080806f
C2  g2731_2 gnd 2.080806f
R1 g2731_1 g2731_2 2.224404
.ends

.subckt netg3453 g3453_2 g3453_0 gnd
C1  g3453_2 gnd 2.080806f
C2  g3453_0 gnd 2.080806f
R1 g3453_0 g3453_2 2.224404
.ends

.subckt netg1151 g1151_0 g1151_1 gnd
C1  g1151_0 gnd 2.080806f
C2  g1151_1 gnd 2.080806f
R1 g1151_0 g1151_1 2.224404
.ends

.subckt netg1421 g1421_1 g1421_0 gnd
C1  g1421_1 gnd 2.080806f
C2  g1421_0 gnd 2.080806f
R1 g1421_0 g1421_1 2.224404
.ends

.subckt netg3113 g3113_1 g3113_0 gnd
C1  g3113_1 gnd 2.080806f
C2  g3113_0 gnd 2.080806f
R1 g3113_1 g3113_0 2.224404
.ends

.subckt netg3089 g3089_1 g3089_0 gnd
C1  g3089_1 gnd 2.080806f
C2  g3089_0 gnd 2.080806f
R1 g3089_0 g3089_1 2.224404
.ends

.subckt netx192 x192_0 x192_1 gnd
C1  x192_0 gnd 2.080806f
C2  x192_1 gnd 2.080806f
R1 x192_1 x192_0 2.224404
.ends

.subckt netg6000 g6000_1 g6000_0 gnd
C1  g6000_1 gnd 2.080806f
C2  g6000_0 gnd 2.080806f
R1 g6000_0 g6000_1 2.224404
.ends

.subckt netg1573 g1573_0 g1573_1 gnd
C1  g1573_0 gnd 2.080806f
C2  g1573_1 gnd 2.080806f
R1 g1573_0 g1573_1 2.224404
.ends

.subckt netg6373 g6373_1 g6373_0 gnd
C1  g6373_1 gnd 2.080806f
C2  g6373_0 gnd 2.080806f
R1 g6373_0 g6373_1 2.224404
.ends

.subckt netg456 g456_0 g456_1 gnd
C1  g456_0 gnd 2.080806f
C2  g456_1 gnd 2.080806f
R1 g456_1 g456_0 2.224404
.ends

.subckt netg3180 g3180_2 g3180_1 gnd
C1  g3180_2 gnd 2.080806f
C2  g3180_1 gnd 2.080806f
R1 g3180_1 g3180_2 2.224404
.ends

.subckt netg5313 g5313_1 g5313_0 gnd
C1  g5313_1 gnd 2.080806f
C2  g5313_0 gnd 2.080806f
R1 g5313_1 g5313_0 2.224404
.ends

.subckt netg6413 g6413_1 g6413_0 gnd
C1  g6413_1 gnd 2.080806f
C2  g6413_0 gnd 2.080806f
R1 g6413_0 g6413_1 2.224404
.ends

.subckt netg4149 g4149_0 g4149_1 gnd
C1  g4149_0 gnd 2.080806f
C2  g4149_1 gnd 2.080806f
R1 g4149_0 g4149_1 2.224404
.ends

.subckt netg6105 g6105_1 g6105_0 gnd
C1  g6105_1 gnd 2.080806f
C2  g6105_0 gnd 2.080806f
R1 g6105_1 g6105_0 2.224404
.ends

.subckt netg6448 g6448_0 g6448_1 gnd
C1  g6448_0 gnd 2.080806f
C2  g6448_1 gnd 2.080806f
R1 g6448_1 g6448_0 2.224404
.ends

.subckt netg4247 g4247_1 g4247_0 gnd
C1  g4247_1 gnd 2.080806f
C2  g4247_0 gnd 2.080806f
R1 g4247_1 g4247_0 2.224404
.ends

.subckt netg7269 g7269_0 g7269_1 gnd
C1  g7269_0 gnd 2.080806f
C2  g7269_1 gnd 2.080806f
R1 g7269_1 g7269_0 2.224404
.ends

.subckt netg4436 g4436_0 g4436_1 gnd
C1  g4436_0 gnd 2.080806f
C2  g4436_1 gnd 2.080806f
R1 g4436_1 g4436_0 2.224404
.ends

.subckt netg7346 g7346_1 g7346_0 gnd
C1  g7346_1 gnd 2.080806f
C2  g7346_0 gnd 2.080806f
R1 g7346_0 g7346_1 2.224404
.ends

.subckt netg5134 g5134_0 g5134_1 gnd
C1  g5134_0 gnd 2.080806f
C2  g5134_1 gnd 2.080806f
R1 g5134_1 g5134_0 2.224404
.ends

.subckt netg2822 g2822_1 g2822_0 gnd
C1  g2822_1 gnd 2.080806f
C2  g2822_0 gnd 2.080806f
R1 g2822_0 g2822_1 2.224404
.ends

.subckt netg4403 g4403_0 g4403_1 gnd
C1  g4403_0 gnd 2.080806f
C2  g4403_1 gnd 2.080806f
R1 g4403_1 g4403_0 2.224404
.ends

.subckt netg3968 g3968_0 g3968_1 gnd
C1  g3968_0 gnd 2.080806f
C2  g3968_1 gnd 2.080806f
R1 g3968_1 g3968_0 2.224404
.ends

.subckt netg1308 g1308_0 g1308_1 gnd
C1  g1308_0 gnd 2.080806f
C2  g1308_1 gnd 2.080806f
R1 g1308_0 g1308_1 2.224404
.ends

.subckt netg1165 g1165_1 g1165_0 gnd
C1  g1165_1 gnd 2.080806f
C2  g1165_0 gnd 2.080806f
R1 g1165_1 g1165_0 2.224404
.ends

.subckt netg6976 g6976_0 g6976_1 gnd
C1  g6976_0 gnd 2.080806f
C2  g6976_1 gnd 2.080806f
R1 g6976_0 g6976_1 2.224404
.ends

.subckt netg3315 g3315_0 g3315_2 gnd
C1  g3315_0 gnd 2.080806f
C2  g3315_2 gnd 2.080806f
R1 g3315_0 g3315_2 2.224404
.ends

.subckt netg2749 g2749_0 g2749_1 gnd
C1  g2749_0 gnd 2.080806f
C2  g2749_1 gnd 2.080806f
R1 g2749_0 g2749_1 2.224404
.ends

.subckt netg6732 g6732_1 g6732_0 gnd
C1  g6732_1 gnd 2.080806f
C2  g6732_0 gnd 2.080806f
R1 g6732_0 g6732_1 2.224404
.ends

.subckt netg5634 g5634_2 g5634_1 gnd
C1  g5634_2 gnd 2.080806f
C2  g5634_1 gnd 2.080806f
R1 g5634_1 g5634_2 2.224404
.ends

.subckt netg1380 g1380_1 g1380_0 gnd
C1  g1380_1 gnd 2.080806f
C2  g1380_0 gnd 2.080806f
R1 g1380_0 g1380_1 2.224404
.ends

.subckt netg6326 g6326_0 g6326_1 gnd
C1  g6326_0 gnd 2.080806f
C2  g6326_1 gnd 2.080806f
R1 g6326_0 g6326_1 2.224404
.ends

.subckt netg3225 g3225_0 g3225_2 gnd
C1  g3225_0 gnd 2.080806f
C2  g3225_2 gnd 2.080806f
R1 g3225_2 g3225_0 2.224404
.ends

.subckt netg7437 g7437_1 g7437_0 gnd
C1  g7437_1 gnd 2.080806f
C2  g7437_0 gnd 2.080806f
R1 g7437_0 g7437_1 2.224404
.ends

.subckt netx162 x162_0 x162_1 gnd
C1  x162_0 gnd 2.080806f
C2  x162_1 gnd 2.080806f
R1 x162_1 x162_0 2.224404
.ends

.subckt netg6139 g6139_1 g6139_0 gnd
C1  g6139_1 gnd 2.080806f
C2  g6139_0 gnd 2.080806f
R1 g6139_1 g6139_0 2.224404
.ends

.subckt netg6106 g6106_1 g6106_0 gnd
C1  g6106_1 gnd 2.080806f
C2  g6106_0 gnd 2.080806f
R1 g6106_0 g6106_1 2.224404
.ends

.subckt netg1510 g1510_1 g1510_0 gnd
C1  g1510_1 gnd 2.080806f
C2  g1510_0 gnd 2.080806f
R1 g1510_0 g1510_1 2.224404
.ends

.subckt netg1585 g1585_0 g1585_1 gnd
C1  g1585_0 gnd 2.080806f
C2  g1585_1 gnd 2.080806f
R1 g1585_0 g1585_1 2.224404
.ends

.subckt netg4047 g4047_0 g4047_1 gnd
C1  g4047_0 gnd 2.080806f
C2  g4047_1 gnd 2.080806f
R1 g4047_1 g4047_0 2.224404
.ends

.subckt netg5415 g5415_1 g5415_0 gnd
C1  g5415_1 gnd 2.080806f
C2  g5415_0 gnd 2.080806f
R1 g5415_1 g5415_0 2.224404
.ends

.subckt netg3897 g3897_1 g3897_0 gnd
C1  g3897_1 gnd 2.080806f
C2  g3897_0 gnd 2.080806f
R1 g3897_1 g3897_0 2.224404
.ends

.subckt netg6584 g6584_1 g6584_0 gnd
C1  g6584_1 gnd 2.080806f
C2  g6584_0 gnd 2.080806f
R1 g6584_1 g6584_0 2.224404
.ends

.subckt netg1815 g1815_1 g1815_0 gnd
C1  g1815_1 gnd 2.080806f
C2  g1815_0 gnd 2.080806f
R1 g1815_1 g1815_0 2.224404
.ends

.subckt netg6962 g6962_1 g6962_0 gnd
C1  g6962_1 gnd 2.080806f
C2  g6962_0 gnd 2.080806f
R1 g6962_1 g6962_0 2.224404
.ends

.subckt netg5879 g5879_0 g5879_1 gnd
C1  g5879_0 gnd 2.080806f
C2  g5879_1 gnd 2.080806f
R1 g5879_0 g5879_1 2.224404
.ends

.subckt netg2486 g2486_1 g2486_2 gnd
C1  g2486_1 gnd 2.080806f
C2  g2486_2 gnd 2.080806f
R1 g2486_1 g2486_2 2.224404
.ends

.subckt netg4206 g4206_0 g4206_1 gnd
C1  g4206_0 gnd 2.080806f
C2  g4206_1 gnd 2.080806f
R1 g4206_0 g4206_1 2.224404
.ends

.subckt netg4070 g4070_1 g4070_0 gnd
C1  g4070_1 gnd 2.080806f
C2  g4070_0 gnd 2.080806f
R1 g4070_0 g4070_1 2.224404
.ends

.subckt netg7156 g7156_1 g7156_0 gnd
C1  g7156_1 gnd 2.080806f
C2  g7156_0 gnd 2.080806f
R1 g7156_1 g7156_0 2.224404
.ends

.subckt netg1519 g1519_0 g1519_1 gnd
C1  g1519_0 gnd 2.080806f
C2  g1519_1 gnd 2.080806f
R1 g1519_1 g1519_0 2.224404
.ends

.subckt netg6669 g6669_0 g6669_1 gnd
C1  g6669_0 gnd 2.080806f
C2  g6669_1 gnd 2.080806f
R1 g6669_1 g6669_0 2.224404
.ends

.subckt netg1492 g1492_1 g1492_0 gnd
C1  g1492_1 gnd 2.080806f
C2  g1492_0 gnd 2.080806f
R1 g1492_0 g1492_1 2.224404
.ends

.subckt netg6272 g6272_0 g6272_1 gnd
C1  g6272_0 gnd 2.080806f
C2  g6272_1 gnd 2.080806f
R1 g6272_1 g6272_0 2.224404
.ends

.subckt netg1122 g1122_0 g1122_1 gnd
C1  g1122_0 gnd 2.080806f
C2  g1122_1 gnd 2.080806f
R1 g1122_1 g1122_0 2.224404
.ends

.subckt netg5526 g5526_1 g5526_0 gnd
C1  g5526_1 gnd 2.080806f
C2  g5526_0 gnd 2.080806f
R1 g5526_0 g5526_1 2.224404
.ends

.subckt netg3557 g3557_1 g3557_0 gnd
C1  g3557_1 gnd 2.080806f
C2  g3557_0 gnd 2.080806f
R1 g3557_1 g3557_0 2.224404
.ends

.subckt netg3568 g3568_1 g3568_0 gnd
C1  g3568_1 gnd 2.080806f
C2  g3568_0 gnd 2.080806f
R1 g3568_0 g3568_1 2.224404
.ends

.subckt netg6464 g6464_0 g6464_1 gnd
C1  g6464_0 gnd 2.080806f
C2  g6464_1 gnd 2.080806f
R1 g6464_1 g6464_0 2.224404
.ends

.subckt netg7129 g7129_0 g7129_1 gnd
C1  g7129_0 gnd 2.080806f
C2  g7129_1 gnd 2.080806f
R1 g7129_0 g7129_1 2.224404
.ends

.subckt netg4982 g4982_1 g4982_2 gnd
C1  g4982_1 gnd 2.080806f
C2  g4982_2 gnd 2.080806f
R1 g4982_2 g4982_1 2.224404
.ends

.subckt netg1134 g1134_1 g1134_0 gnd
C1  g1134_1 gnd 2.080806f
C2  g1134_0 gnd 2.080806f
R1 g1134_1 g1134_0 2.224404
.ends

.subckt netg7099 g7099_0 g7099_1 gnd
C1  g7099_0 gnd 2.080806f
C2  g7099_1 gnd 2.080806f
R1 g7099_0 g7099_1 2.224404
.ends

.subckt netg6920 g6920_1 g6920_0 gnd
C1  g6920_1 gnd 2.080806f
C2  g6920_0 gnd 2.080806f
R1 g6920_0 g6920_1 2.224404
.ends

.subckt netg6011 g6011_1 g6011_0 gnd
C1  g6011_1 gnd 2.080806f
C2  g6011_0 gnd 2.080806f
R1 g6011_0 g6011_1 2.224404
.ends

.subckt netg1252 g1252_0 g1252_1 gnd
C1  g1252_0 gnd 2.080806f
C2  g1252_1 gnd 2.080806f
R1 g1252_1 g1252_0 2.224404
.ends

.subckt netg6894 g6894_0 g6894_1 gnd
C1  g6894_0 gnd 2.080806f
C2  g6894_1 gnd 2.080806f
R1 g6894_0 g6894_1 2.224404
.ends

.subckt netg4067 g4067_1 g4067_0 gnd
C1  g4067_1 gnd 2.080806f
C2  g4067_0 gnd 2.080806f
R1 g4067_0 g4067_1 2.224404
.ends

.subckt netg1265 g1265_0 g1265_1 gnd
C1  g1265_0 gnd 2.080806f
C2  g1265_1 gnd 2.080806f
R1 g1265_0 g1265_1 2.224404
.ends

.subckt netg5249 g5249_1 g5249_0 gnd
C1  g5249_1 gnd 2.080806f
C2  g5249_0 gnd 2.080806f
R1 g5249_0 g5249_1 2.224404
.ends

.subckt netg4230 g4230_0 g4230_1 gnd
C1  g4230_0 gnd 2.080806f
C2  g4230_1 gnd 2.080806f
R1 g4230_0 g4230_1 2.224404
.ends

.subckt netg4414 g4414_0 g4414_1 gnd
C1  g4414_0 gnd 2.080806f
C2  g4414_1 gnd 2.080806f
R1 g4414_0 g4414_1 2.224404
.ends

.subckt netx221 x221_0 x221_1 gnd
C1  x221_0 gnd 2.080806f
C2  x221_1 gnd 2.080806f
R1 x221_0 x221_1 2.224404
.ends

.subckt netg3487 g3487_1 g3487_0 gnd
C1  g3487_1 gnd 2.080806f
C2  g3487_0 gnd 2.080806f
R1 g3487_1 g3487_0 2.224404
.ends

.subckt netg6720 g6720_0 g6720_1 gnd
C1  g6720_0 gnd 2.080806f
C2  g6720_1 gnd 2.080806f
R1 g6720_0 g6720_1 2.224404
.ends

.subckt netg1452 g1452_0 g1452_1 gnd
C1  g1452_0 gnd 2.080806f
C2  g1452_1 gnd 2.080806f
R1 g1452_1 g1452_0 2.224404
.ends

.subckt netg6134 g6134_0 g6134_1 gnd
C1  g6134_0 gnd 2.080806f
C2  g6134_1 gnd 2.080806f
R1 g6134_1 g6134_0 2.224404
.ends

.subckt netg3500 g3500_1 g3500_0 gnd
C1  g3500_1 gnd 2.080806f
C2  g3500_0 gnd 2.080806f
R1 g3500_1 g3500_0 2.224404
.ends

.subckt netg4237 g4237_1 g4237_0 gnd
C1  g4237_1 gnd 2.080806f
C2  g4237_0 gnd 2.080806f
R1 g4237_0 g4237_1 2.224404
.ends

.subckt netg4530 g4530_1 g4530_0 gnd
C1  g4530_1 gnd 2.080806f
C2  g4530_0 gnd 2.080806f
R1 g4530_1 g4530_0 2.224404
.ends

.subckt netg6554 g6554_1 g6554_0 gnd
C1  g6554_1 gnd 2.080806f
C2  g6554_0 gnd 2.080806f
R1 g6554_1 g6554_0 2.224404
.ends

.subckt netg7131 g7131_2 g7131_1 gnd
C1  g7131_2 gnd 2.080806f
C2  g7131_1 gnd 2.080806f
R1 g7131_1 g7131_2 2.224404
.ends

.subckt netg6207 g6207_1 g6207_0 gnd
C1  g6207_1 gnd 2.080806f
C2  g6207_0 gnd 2.080806f
R1 g6207_1 g6207_0 2.224404
.ends

.subckt netg4997 g4997_1 g4997_2 gnd
C1  g4997_1 gnd 2.080806f
C2  g4997_2 gnd 2.080806f
R1 g4997_2 g4997_1 2.224404
.ends

.subckt netg5458 g5458_0 g5458_1 gnd
C1  g5458_0 gnd 2.080806f
C2  g5458_1 gnd 2.080806f
R1 g5458_1 g5458_0 2.224404
.ends

.subckt netg7381 g7381_1 g7381_0 gnd
C1  g7381_1 gnd 2.080806f
C2  g7381_0 gnd 2.080806f
R1 g7381_0 g7381_1 2.224404
.ends

.subckt netg2404 g2404_1 g2404_0 gnd
C1  g2404_1 gnd 2.080806f
C2  g2404_0 gnd 2.080806f
R1 g2404_0 g2404_1 2.224404
.ends

.subckt netg3468 g3468_1 g3468_0 gnd
C1  g3468_1 gnd 2.080806f
C2  g3468_0 gnd 2.080806f
R1 g3468_0 g3468_1 2.224404
.ends

.subckt netg4256 g4256_1 g4256_0 gnd
C1  g4256_1 gnd 2.080806f
C2  g4256_0 gnd 2.080806f
R1 g4256_0 g4256_1 2.224404
.ends

.subckt netg5298 g5298_1 g5298_0 gnd
C1  g5298_1 gnd 2.080806f
C2  g5298_0 gnd 2.080806f
R1 g5298_0 g5298_1 2.224404
.ends

.subckt netg6141 g6141_1 g6141_0 gnd
C1  g6141_1 gnd 2.080806f
C2  g6141_0 gnd 2.080806f
R1 g6141_1 g6141_0 2.224404
.ends

.subckt netg6175 g6175_0 g6175_1 gnd
C1  g6175_0 gnd 2.080806f
C2  g6175_1 gnd 2.080806f
R1 g6175_0 g6175_1 2.224404
.ends

.subckt netg1948 g1948_2 g1948_0 gnd
C1  g1948_2 gnd 2.080806f
C2  g1948_0 gnd 2.080806f
R1 g1948_0 g1948_2 2.224404
.ends

.subckt netg5330 g5330_1 g5330_0 gnd
C1  g5330_1 gnd 2.080806f
C2  g5330_0 gnd 2.080806f
R1 g5330_0 g5330_1 2.224404
.ends

.subckt netg2786 g2786_0 g2786_1 gnd
C1  g2786_0 gnd 2.080806f
C2  g2786_1 gnd 2.080806f
R1 g2786_1 g2786_0 2.224404
.ends

.subckt netg4226 g4226_0 g4226_1 gnd
C1  g4226_0 gnd 2.080806f
C2  g4226_1 gnd 2.080806f
R1 g4226_1 g4226_0 2.224404
.ends

.subckt netg5143 g5143_0 g5143_1 gnd
C1  g5143_0 gnd 2.080806f
C2  g5143_1 gnd 2.080806f
R1 g5143_0 g5143_1 2.224404
.ends

.subckt netg2792 g2792_0 g2792_1 gnd
C1  g2792_0 gnd 2.080806f
C2  g2792_1 gnd 2.080806f
R1 g2792_0 g2792_1 2.224404
.ends

.subckt netg6507 g6507_0 g6507_1 gnd
C1  g6507_0 gnd 2.080806f
C2  g6507_1 gnd 2.080806f
R1 g6507_1 g6507_0 2.224404
.ends

.subckt netg3570 g3570_1 g3570_0 gnd
C1  g3570_1 gnd 2.080806f
C2  g3570_0 gnd 2.080806f
R1 g3570_0 g3570_1 2.224404
.ends

.subckt netg6259 g6259_2 g6259_1 gnd
C1  g6259_2 gnd 2.080806f
C2  g6259_1 gnd 2.080806f
R1 g6259_2 g6259_1 2.224404
.ends

.subckt netg5606 g5606_1 g5606_0 gnd
C1  g5606_1 gnd 2.080806f
C2  g5606_0 gnd 2.080806f
R1 g5606_0 g5606_1 2.224404
.ends

.subckt netg2835 g2835_0 g2835_1 gnd
C1  g2835_0 gnd 2.080806f
C2  g2835_1 gnd 2.080806f
R1 g2835_0 g2835_1 2.224404
.ends

.subckt netg1533 g1533_1 g1533_0 gnd
C1  g1533_1 gnd 2.080806f
C2  g1533_0 gnd 2.080806f
R1 g1533_1 g1533_0 2.224404
.ends

.subckt netg6820 g6820_1 g6820_0 gnd
C1  g6820_1 gnd 2.080806f
C2  g6820_0 gnd 2.080806f
R1 g6820_1 g6820_0 2.224404
.ends

.subckt netg3547 g3547_0 g3547_1 gnd
C1  g3547_0 gnd 2.080806f
C2  g3547_1 gnd 2.080806f
R1 g3547_1 g3547_0 2.224404
.ends

.subckt netg7347 g7347_0 g7347_1 gnd
C1  g7347_0 gnd 2.080806f
C2  g7347_1 gnd 2.080806f
R1 g7347_1 g7347_0 2.224404
.ends

.subckt netg3717 g3717_1 g3717_0 gnd
C1  g3717_1 gnd 2.080806f
C2  g3717_0 gnd 2.080806f
R1 g3717_0 g3717_1 2.224404
.ends

.subckt netg5592 g5592_1 g5592_0 gnd
C1  g5592_1 gnd 2.080806f
C2  g5592_0 gnd 2.080806f
R1 g5592_1 g5592_0 2.224404
.ends

.subckt netg6073 g6073_0 g6073_1 gnd
C1  g6073_0 gnd 2.080806f
C2  g6073_1 gnd 2.080806f
R1 g6073_0 g6073_1 2.224404
.ends

.subckt netg4424 g4424_0 g4424_1 gnd
C1  g4424_0 gnd 2.080806f
C2  g4424_1 gnd 2.080806f
R1 g4424_1 g4424_0 2.224404
.ends

.subckt netg1582 g1582_0 g1582_1 gnd
C1  g1582_0 gnd 2.080806f
C2  g1582_1 gnd 2.080806f
R1 g1582_1 g1582_0 2.224404
.ends

.subckt netg6902 g6902_0 g6902_1 gnd
C1  g6902_0 gnd 2.080806f
C2  g6902_1 gnd 2.080806f
R1 g6902_0 g6902_1 2.224404
.ends

.subckt netg5706 g5706_1 g5706_0 gnd
C1  g5706_1 gnd 2.080806f
C2  g5706_0 gnd 2.080806f
R1 g5706_0 g5706_1 2.224404
.ends

.subckt netg1227 g1227_1 g1227_0 gnd
C1  g1227_1 gnd 2.080806f
C2  g1227_0 gnd 2.080806f
R1 g1227_1 g1227_0 2.224404
.ends

.subckt netg2846 g2846_0 g2846_1 gnd
C1  g2846_0 gnd 2.080806f
C2  g2846_1 gnd 2.080806f
R1 g2846_1 g2846_0 2.224404
.ends

.subckt netg1173 g1173_0 g1173_1 gnd
C1  g1173_0 gnd 2.080806f
C2  g1173_1 gnd 2.080806f
R1 g1173_1 g1173_0 2.224404
.ends

.subckt netg5769 g5769_1 g5769_0 gnd
C1  g5769_1 gnd 2.080806f
C2  g5769_0 gnd 2.080806f
R1 g5769_0 g5769_1 2.224404
.ends

.subckt netg2785 g2785_0 g2785_1 gnd
C1  g2785_0 gnd 2.080806f
C2  g2785_1 gnd 2.080806f
R1 g2785_0 g2785_1 2.224404
.ends

.subckt netg7332 g7332_1 g7332_0 gnd
C1  g7332_1 gnd 2.080806f
C2  g7332_0 gnd 2.080806f
R1 g7332_0 g7332_1 2.224404
.ends

.subckt netg1481 g1481_1 g1481_0 gnd
C1  g1481_1 gnd 2.080806f
C2  g1481_0 gnd 2.080806f
R1 g1481_1 g1481_0 2.224404
.ends

.subckt netg3541 g3541_1 g3541_0 gnd
C1  g3541_1 gnd 2.080806f
C2  g3541_0 gnd 2.080806f
R1 g3541_0 g3541_1 2.224404
.ends

.subckt netg3096 g3096_2 g3096_1 gnd
C1  g3096_2 gnd 2.080806f
C2  g3096_1 gnd 2.080806f
R1 g3096_2 g3096_1 2.224404
.ends

.subckt netg4452 g4452_1 g4452_0 gnd
C1  g4452_1 gnd 2.080806f
C2  g4452_0 gnd 2.080806f
R1 g4452_1 g4452_0 2.224404
.ends

.subckt netg7183 g7183_0 g7183_1 gnd
C1  g7183_0 gnd 2.080806f
C2  g7183_1 gnd 2.080806f
R1 g7183_1 g7183_0 2.224404
.ends

.subckt netg1457 g1457_1 g1457_0 gnd
C1  g1457_1 gnd 2.080806f
C2  g1457_0 gnd 2.080806f
R1 g1457_1 g1457_0 2.224404
.ends

.subckt netg6737 g6737_1 g6737_0 gnd
C1  g6737_1 gnd 2.080806f
C2  g6737_0 gnd 2.080806f
R1 g6737_1 g6737_0 2.224404
.ends

.subckt netg7013 g7013_1 g7013_0 gnd
C1  g7013_1 gnd 2.080806f
C2  g7013_0 gnd 2.080806f
R1 g7013_0 g7013_1 2.224404
.ends

.subckt netg6697 g6697_0 g6697_1 gnd
C1  g6697_0 gnd 2.080806f
C2  g6697_1 gnd 2.080806f
R1 g6697_1 g6697_0 2.224404
.ends

.subckt netg3915 g3915_1 g3915_0 gnd
C1  g3915_1 gnd 2.080806f
C2  g3915_0 gnd 2.080806f
R1 g3915_1 g3915_0 2.224404
.ends

.subckt netg6460 g6460_1 g6460_0 gnd
C1  g6460_1 gnd 2.080806f
C2  g6460_0 gnd 2.080806f
R1 g6460_1 g6460_0 2.224404
.ends

.subckt netg5476 g5476_1 g5476_0 gnd
C1  g5476_1 gnd 2.080806f
C2  g5476_0 gnd 2.080806f
R1 g5476_0 g5476_1 2.224404
.ends

.subckt netg5114 g5114_1 g5114_0 gnd
C1  g5114_1 gnd 2.080806f
C2  g5114_0 gnd 2.080806f
R1 g5114_1 g5114_0 2.224404
.ends

.subckt netg7092 g7092_1 g7092_0 gnd
C1  g7092_1 gnd 2.080806f
C2  g7092_0 gnd 2.080806f
R1 g7092_1 g7092_0 2.224404
.ends

.subckt netg7249 g7249_0 g7249_1 gnd
C1  g7249_0 gnd 2.080806f
C2  g7249_1 gnd 2.080806f
R1 g7249_0 g7249_1 2.224404
.ends

.subckt netg6244 g6244_0 g6244_1 gnd
C1  g6244_0 gnd 2.080806f
C2  g6244_1 gnd 2.080806f
R1 g6244_0 g6244_1 2.224404
.ends

.subckt netg3578 g3578_1 g3578_0 gnd
C1  g3578_1 gnd 2.080806f
C2  g3578_0 gnd 2.080806f
R1 g3578_0 g3578_1 2.224404
.ends

.subckt netx231 x231_0 x231_1 gnd
C1  x231_0 gnd 2.080806f
C2  x231_1 gnd 2.080806f
R1 x231_0 x231_1 2.224404
.ends

.subckt netg7279 g7279_0 g7279_1 gnd
C1  g7279_0 gnd 2.080806f
C2  g7279_1 gnd 2.080806f
R1 g7279_1 g7279_0 2.224404
.ends

.subckt netg6088 g6088_1 g6088_0 gnd
C1  g6088_1 gnd 2.080806f
C2  g6088_0 gnd 2.080806f
R1 g6088_1 g6088_0 2.224404
.ends

.subckt netg5546 g5546_0 g5546_2 gnd
C1  g5546_0 gnd 2.080806f
C2  g5546_2 gnd 2.080806f
R1 g5546_0 g5546_2 2.224404
.ends

.subckt netg6696 g6696_0 g6696_1 gnd
C1  g6696_0 gnd 2.080806f
C2  g6696_1 gnd 2.080806f
R1 g6696_1 g6696_0 2.224404
.ends

.subckt netg4340 g4340_1 g4340_0 gnd
C1  g4340_1 gnd 2.080806f
C2  g4340_0 gnd 2.080806f
R1 g4340_0 g4340_1 2.224404
.ends

.subckt netg6008 g6008_0 g6008_1 gnd
C1  g6008_0 gnd 2.080806f
C2  g6008_1 gnd 2.080806f
R1 g6008_0 g6008_1 2.224404
.ends

.subckt netg7076 g7076_1 g7076_0 gnd
C1  g7076_1 gnd 2.080806f
C2  g7076_0 gnd 2.080806f
R1 g7076_1 g7076_0 2.224404
.ends

.subckt netg5776 g5776_0 g5776_1 gnd
C1  g5776_0 gnd 2.080806f
C2  g5776_1 gnd 2.080806f
R1 g5776_1 g5776_0 2.224404
.ends

.subckt netg6229 g6229_1 g6229_0 gnd
C1  g6229_1 gnd 2.080806f
C2  g6229_0 gnd 2.080806f
R1 g6229_0 g6229_1 2.224404
.ends

.subckt netg1051 g1051_2 g1051_0 gnd
C1  g1051_2 gnd 2.080806f
C2  g1051_0 gnd 2.080806f
R1 g1051_2 g1051_0 2.224404
.ends

.subckt netg2435 g2435_0 g2435_2 gnd
C1  g2435_0 gnd 2.080806f
C2  g2435_2 gnd 2.080806f
R1 g2435_0 g2435_2 2.224404
.ends

.subckt netg3900 g3900_1 g3900_0 gnd
C1  g3900_1 gnd 2.080806f
C2  g3900_0 gnd 2.080806f
R1 g3900_1 g3900_0 2.224404
.ends

.subckt netg455 g455_0 g455_1 gnd
C1  g455_0 gnd 2.080806f
C2  g455_1 gnd 2.080806f
R1 g455_1 g455_0 2.224404
.ends

.subckt netg6684 g6684_0 g6684_1 gnd
C1  g6684_0 gnd 2.080806f
C2  g6684_1 gnd 2.080806f
R1 g6684_1 g6684_0 2.224404
.ends

.subckt netg6006 g6006_1 g6006_0 gnd
C1  g6006_1 gnd 2.080806f
C2  g6006_0 gnd 2.080806f
R1 g6006_1 g6006_0 2.224404
.ends

.subckt netg1314 g1314_1 g1314_0 gnd
C1  g1314_1 gnd 2.080806f
C2  g1314_0 gnd 2.080806f
R1 g1314_1 g1314_0 2.224404
.ends

.subckt netg5238 g5238_1 g5238_0 gnd
C1  g5238_1 gnd 2.080806f
C2  g5238_0 gnd 2.080806f
R1 g5238_1 g5238_0 2.224404
.ends

.subckt netg5538 g5538_1 g5538_0 gnd
C1  g5538_1 gnd 2.080806f
C2  g5538_0 gnd 2.080806f
R1 g5538_0 g5538_1 2.224404
.ends

.subckt netg3573 g3573_1 g3573_0 gnd
C1  g3573_1 gnd 2.080806f
C2  g3573_0 gnd 2.080806f
R1 g3573_0 g3573_1 2.224404
.ends

.subckt netg5362 g5362_1 g5362_0 gnd
C1  g5362_1 gnd 2.080806f
C2  g5362_0 gnd 2.080806f
R1 g5362_1 g5362_0 2.224404
.ends

.subckt netg5252 g5252_1 g5252_0 gnd
C1  g5252_1 gnd 2.080806f
C2  g5252_0 gnd 2.080806f
R1 g5252_0 g5252_1 2.224404
.ends

.subckt netg6135 g6135_0 g6135_1 gnd
C1  g6135_0 gnd 2.080806f
C2  g6135_1 gnd 2.080806f
R1 g6135_1 g6135_0 2.224404
.ends

.subckt netg4023 g4023_0 g4023_1 gnd
C1  g4023_0 gnd 2.080806f
C2  g4023_1 gnd 2.080806f
R1 g4023_1 g4023_0 2.224404
.ends

.subckt netg7442 g7442_1 g7442_0 gnd
C1  g7442_1 gnd 2.080806f
C2  g7442_0 gnd 2.080806f
R1 g7442_1 g7442_0 2.224404
.ends

.subckt netg910 g910_1 g910_2 gnd
C1  g910_1 gnd 2.080806f
C2  g910_2 gnd 2.080806f
R1 g910_2 g910_1 2.224404
.ends

.subckt netg5671 g5671_1 g5671_2 gnd
C1  g5671_1 gnd 2.080806f
C2  g5671_2 gnd 2.080806f
R1 g5671_2 g5671_1 2.224404
.ends

.subckt netg1929 g1929_0 g1929_1 gnd
C1  g1929_0 gnd 2.080806f
C2  g1929_1 gnd 2.080806f
R1 g1929_1 g1929_0 2.224404
.ends

.subckt netg4137 g4137_0 g4137_1 gnd
C1  g4137_0 gnd 2.080806f
C2  g4137_1 gnd 2.080806f
R1 g4137_0 g4137_1 2.224404
.ends

.subckt netg1359 g1359_0 g1359_1 gnd
C1  g1359_0 gnd 2.080806f
C2  g1359_1 gnd 2.080806f
R1 g1359_0 g1359_1 2.224404
.ends

.subckt netg6648 g6648_1 g6648_0 gnd
C1  g6648_1 gnd 2.080806f
C2  g6648_0 gnd 2.080806f
R1 g6648_1 g6648_0 2.224404
.ends

.subckt netg6940 g6940_0 g6940_1 gnd
C1  g6940_0 gnd 2.080806f
C2  g6940_1 gnd 2.080806f
R1 g6940_0 g6940_1 2.224404
.ends

.subckt netg6099 g6099_0 g6099_1 gnd
C1  g6099_0 gnd 2.080806f
C2  g6099_1 gnd 2.080806f
R1 g6099_0 g6099_1 2.224404
.ends

.subckt netg6362 g6362_1 g6362_0 gnd
C1  g6362_1 gnd 2.080806f
C2  g6362_0 gnd 2.080806f
R1 g6362_0 g6362_1 2.224404
.ends

.subckt netg4321 g4321_0 g4321_1 gnd
C1  g4321_0 gnd 2.080806f
C2  g4321_1 gnd 2.080806f
R1 g4321_0 g4321_1 2.224404
.ends

.subckt netg3920 g3920_1 g3920_0 gnd
C1  g3920_1 gnd 2.080806f
C2  g3920_0 gnd 2.080806f
R1 g3920_1 g3920_0 2.224404
.ends

.subckt netg5540 g5540_1 g5540_2 gnd
C1  g5540_1 gnd 2.080806f
C2  g5540_2 gnd 2.080806f
R1 g5540_1 g5540_2 2.224404
.ends

.subckt netg4160 g4160_0 g4160_1 gnd
C1  g4160_0 gnd 2.080806f
C2  g4160_1 gnd 2.080806f
R1 g4160_1 g4160_0 2.224404
.ends

.subckt netg6936 g6936_1 g6936_0 gnd
C1  g6936_1 gnd 2.080806f
C2  g6936_0 gnd 2.080806f
R1 g6936_1 g6936_0 2.224404
.ends

.subckt netg7185 g7185_1 g7185_0 gnd
C1  g7185_1 gnd 2.080806f
C2  g7185_0 gnd 2.080806f
R1 g7185_1 g7185_0 2.224404
.ends

.subckt netg6665 g6665_0 g6665_1 gnd
C1  g6665_0 gnd 2.080806f
C2  g6665_1 gnd 2.080806f
R1 g6665_1 g6665_0 2.224404
.ends

.subckt netg1939 g1939_0 g1939_1 gnd
C1  g1939_0 gnd 2.080806f
C2  g1939_1 gnd 2.080806f
R1 g1939_0 g1939_1 2.224404
.ends

.subckt netg6996 g6996_1 g6996_0 gnd
C1  g6996_1 gnd 2.080806f
C2  g6996_0 gnd 2.080806f
R1 g6996_1 g6996_0 2.224404
.ends

.subckt netg6529 g6529_1 g6529_0 gnd
C1  g6529_1 gnd 2.080806f
C2  g6529_0 gnd 2.080806f
R1 g6529_0 g6529_1 2.224404
.ends

.subckt netg1232 g1232_0 g1232_1 gnd
C1  g1232_0 gnd 2.080806f
C2  g1232_1 gnd 2.080806f
R1 g1232_0 g1232_1 2.224404
.ends

.subckt netg3529 g3529_1 g3529_0 gnd
C1  g3529_1 gnd 2.080806f
C2  g3529_0 gnd 2.080806f
R1 g3529_0 g3529_1 2.224404
.ends

.subckt netg6191 g6191_1 g6191_0 gnd
C1  g6191_1 gnd 2.080806f
C2  g6191_0 gnd 2.080806f
R1 g6191_1 g6191_0 2.224404
.ends

.subckt netg3198 g3198_1 g3198_2 gnd
C1  g3198_1 gnd 2.080806f
C2  g3198_2 gnd 2.080806f
R1 g3198_2 g3198_1 2.224404
.ends

.subckt netg4328 g4328_0 g4328_1 gnd
C1  g4328_0 gnd 2.080806f
C2  g4328_1 gnd 2.080806f
R1 g4328_0 g4328_1 2.224404
.ends

.subckt netg3514 g3514_1 g3514_0 gnd
C1  g3514_1 gnd 2.080806f
C2  g3514_0 gnd 2.080806f
R1 g3514_0 g3514_1 2.224404
.ends

.subckt netg7022 g7022_1 g7022_0 gnd
C1  g7022_1 gnd 2.080806f
C2  g7022_0 gnd 2.080806f
R1 g7022_0 g7022_1 2.224404
.ends

.subckt netg7198 g7198_0 g7198_1 gnd
C1  g7198_0 gnd 2.080806f
C2  g7198_1 gnd 2.080806f
R1 g7198_0 g7198_1 2.224404
.ends

.subckt netg1431 g1431_0 g1431_1 gnd
C1  g1431_0 gnd 2.080806f
C2  g1431_1 gnd 2.080806f
R1 g1431_0 g1431_1 2.224404
.ends

.subckt netg2701 g2701_1 g2701_2 gnd
C1  g2701_1 gnd 2.080806f
C2  g2701_2 gnd 2.080806f
R1 g2701_1 g2701_2 2.224404
.ends

.subckt netg7353 g7353_1 g7353_0 gnd
C1  g7353_1 gnd 2.080806f
C2  g7353_0 gnd 2.080806f
R1 g7353_0 g7353_1 2.224404
.ends

.subckt netg4053 g4053_0 g4053_1 gnd
C1  g4053_0 gnd 2.080806f
C2  g4053_1 gnd 2.080806f
R1 g4053_1 g4053_0 2.224404
.ends

.subckt netg5410 g5410_0 g5410_1 gnd
C1  g5410_0 gnd 2.080806f
C2  g5410_1 gnd 2.080806f
R1 g5410_0 g5410_1 2.224404
.ends

.subckt netg6525 g6525_1 g6525_0 gnd
C1  g6525_1 gnd 2.080806f
C2  g6525_0 gnd 2.080806f
R1 g6525_1 g6525_0 2.224404
.ends

.subckt netx281 x281_1 x281_0 gnd
C1  x281_1 gnd 2.080806f
C2  x281_0 gnd 2.080806f
R1 x281_1 x281_0 2.224404
.ends

.subckt netg4332 g4332_1 g4332_0 gnd
C1  g4332_1 gnd 2.080806f
C2  g4332_0 gnd 2.080806f
R1 g4332_1 g4332_0 2.224404
.ends

.subckt netg2558 g2558_2 g2558_1 gnd
C1  g2558_2 gnd 2.080806f
C2  g2558_1 gnd 2.080806f
R1 g2558_1 g2558_2 2.224404
.ends

.subckt netg2914 g2914_1 g2914_0 gnd
C1  g2914_1 gnd 2.080806f
C2  g2914_0 gnd 2.080806f
R1 g2914_0 g2914_1 2.224404
.ends

.subckt netg7107 g7107_0 g7107_1 gnd
C1  g7107_0 gnd 2.080806f
C2  g7107_1 gnd 2.080806f
R1 g7107_1 g7107_0 2.224404
.ends

.subckt netg6186 g6186_1 g6186_0 gnd
C1  g6186_1 gnd 2.080806f
C2  g6186_0 gnd 2.080806f
R1 g6186_1 g6186_0 2.224404
.ends

.subckt netg7228 g7228_1 g7228_2 gnd
C1  g7228_1 gnd 2.080806f
C2  g7228_2 gnd 2.080806f
R1 g7228_2 g7228_1 2.224404
.ends

.subckt netg4173 g4173_1 g4173_0 gnd
C1  g4173_1 gnd 2.080806f
C2  g4173_0 gnd 2.080806f
R1 g4173_0 g4173_1 2.224404
.ends

.subckt netg6356 g6356_1 g6356_0 gnd
C1  g6356_1 gnd 2.080806f
C2  g6356_0 gnd 2.080806f
R1 g6356_0 g6356_1 2.224404
.ends

.subckt netg6317 g6317_0 g6317_1 gnd
C1  g6317_0 gnd 2.080806f
C2  g6317_1 gnd 2.080806f
R1 g6317_1 g6317_0 2.224404
.ends

.subckt netg5443 g5443_1 g5443_0 gnd
C1  g5443_1 gnd 2.080806f
C2  g5443_0 gnd 2.080806f
R1 g5443_1 g5443_0 2.224404
.ends

.subckt netg1999 g1999_0 g1999_1 gnd
C1  g1999_0 gnd 2.080806f
C2  g1999_1 gnd 2.080806f
R1 g1999_0 g1999_1 2.224404
.ends

.subckt netg6163 g6163_1 g6163_0 gnd
C1  g6163_1 gnd 2.080806f
C2  g6163_0 gnd 2.080806f
R1 g6163_1 g6163_0 2.224404
.ends

.subckt netg6731 g6731_0 g6731_1 gnd
C1  g6731_0 gnd 2.080806f
C2  g6731_1 gnd 2.080806f
R1 g6731_0 g6731_1 2.224404
.ends

.subckt netg4134 g4134_1 g4134_0 gnd
C1  g4134_1 gnd 2.080806f
C2  g4134_0 gnd 2.080806f
R1 g4134_0 g4134_1 2.224404
.ends

.subckt netg1162 g1162_1 g1162_0 gnd
C1  g1162_1 gnd 2.080806f
C2  g1162_0 gnd 2.080806f
R1 g1162_0 g1162_1 2.224404
.ends

.subckt netg6298 g6298_0 g6298_1 gnd
C1  g6298_0 gnd 2.080806f
C2  g6298_1 gnd 2.080806f
R1 g6298_0 g6298_1 2.224404
.ends

.subckt netg4286 g4286_0 g4286_1 gnd
C1  g4286_0 gnd 2.080806f
C2  g4286_1 gnd 2.080806f
R1 g4286_1 g4286_0 2.224404
.ends

.subckt netg6694 g6694_1 g6694_0 gnd
C1  g6694_1 gnd 2.080806f
C2  g6694_0 gnd 2.080806f
R1 g6694_1 g6694_0 2.224404
.ends

.subckt netg1408 g1408_0 g1408_1 gnd
C1  g1408_0 gnd 2.080806f
C2  g1408_1 gnd 2.080806f
R1 g1408_0 g1408_1 2.224404
.ends

.subckt netg6087 g6087_0 g6087_1 gnd
C1  g6087_0 gnd 2.080806f
C2  g6087_1 gnd 2.080806f
R1 g6087_1 g6087_0 2.224404
.ends

.subckt netg1231 g1231_0 g1231_1 gnd
C1  g1231_0 gnd 2.080806f
C2  g1231_1 gnd 2.080806f
R1 g1231_0 g1231_1 2.224404
.ends

.subckt netx402 x402_1 x402_0 gnd
C1  x402_1 gnd 2.080806f
C2  x402_0 gnd 2.080806f
R1 x402_1 x402_0 2.224404
.ends

.subckt netg5423 g5423_0 g5423_1 gnd
C1  g5423_0 gnd 2.080806f
C2  g5423_1 gnd 2.080806f
R1 g5423_0 g5423_1 2.224404
.ends

.subckt netg5992 g5992_0 g5992_1 gnd
C1  g5992_0 gnd 2.080806f
C2  g5992_1 gnd 2.080806f
R1 g5992_0 g5992_1 2.224404
.ends

.subckt netg3508 g3508_1 g3508_0 gnd
C1  g3508_1 gnd 2.080806f
C2  g3508_0 gnd 2.080806f
R1 g3508_0 g3508_1 2.224404
.ends

.subckt netg2823 g2823_0 g2823_1 gnd
C1  g2823_0 gnd 2.080806f
C2  g2823_1 gnd 2.080806f
R1 g2823_0 g2823_1 2.224404
.ends

.subckt netg6169 g6169_0 g6169_1 gnd
C1  g6169_0 gnd 2.080806f
C2  g6169_1 gnd 2.080806f
R1 g6169_0 g6169_1 2.224404
.ends

.subckt netg4062 g4062_1 g4062_0 gnd
C1  g4062_1 gnd 2.080806f
C2  g4062_0 gnd 2.080806f
R1 g4062_1 g4062_0 2.224404
.ends

.subckt netg4129 g4129_0 g4129_1 gnd
C1  g4129_0 gnd 2.080806f
C2  g4129_1 gnd 2.080806f
R1 g4129_1 g4129_0 2.224404
.ends

.subckt netg2795 g2795_0 g2795_1 gnd
C1  g2795_0 gnd 2.080806f
C2  g2795_1 gnd 2.080806f
R1 g2795_1 g2795_0 2.224404
.ends

.subckt netg2923 g2923_1 g2923_0 gnd
C1  g2923_1 gnd 2.080806f
C2  g2923_0 gnd 2.080806f
R1 g2923_0 g2923_1 2.224404
.ends

.subckt netg4203 g4203_0 g4203_1 gnd
C1  g4203_0 gnd 2.080806f
C2  g4203_1 gnd 2.080806f
R1 g4203_1 g4203_0 2.224404
.ends

.subckt netg4057 g4057_1 g4057_0 gnd
C1  g4057_1 gnd 2.080806f
C2  g4057_0 gnd 2.080806f
R1 g4057_0 g4057_1 2.224404
.ends

.subckt netg1886 g1886_1 g1886_0 gnd
C1  g1886_1 gnd 2.080806f
C2  g1886_0 gnd 2.080806f
R1 g1886_1 g1886_0 2.224404
.ends

.subckt netx121 x121_1 x121_0 gnd
C1  x121_1 gnd 2.080806f
C2  x121_0 gnd 2.080806f
R1 x121_1 x121_0 2.224404
.ends

.subckt netg5994 g5994_1 g5994_0 gnd
C1  g5994_1 gnd 2.080806f
C2  g5994_0 gnd 2.080806f
R1 g5994_0 g5994_1 2.224404
.ends

.subckt netg6395 g6395_0 g6395_1 gnd
C1  g6395_0 gnd 2.080806f
C2  g6395_1 gnd 2.080806f
R1 g6395_1 g6395_0 2.224404
.ends

.subckt netg6166 g6166_1 g6166_0 gnd
C1  g6166_1 gnd 2.080806f
C2  g6166_0 gnd 2.080806f
R1 g6166_1 g6166_0 2.224404
.ends

.subckt netg1921 g1921_1 g1921_0 gnd
C1  g1921_1 gnd 2.080806f
C2  g1921_0 gnd 2.080806f
R1 g1921_0 g1921_1 2.224404
.ends

.subckt netx291 x291_1 x291_0 gnd
C1  x291_1 gnd 2.080806f
C2  x291_0 gnd 2.080806f
R1 x291_1 x291_0 2.224404
.ends

.subckt netg5982 g5982_1 g5982_0 gnd
C1  g5982_1 gnd 2.080806f
C2  g5982_0 gnd 2.080806f
R1 g5982_0 g5982_1 2.224404
.ends

.subckt netg5408 g5408_0 g5408_1 gnd
C1  g5408_0 gnd 2.080806f
C2  g5408_1 gnd 2.080806f
R1 g5408_0 g5408_1 2.224404
.ends

.subckt netg6333 g6333_1 g6333_0 gnd
C1  g6333_1 gnd 2.080806f
C2  g6333_0 gnd 2.080806f
R1 g6333_0 g6333_1 2.224404
.ends

.subckt netg1168 g1168_1 g1168_0 gnd
C1  g1168_1 gnd 2.080806f
C2  g1168_0 gnd 2.080806f
R1 g1168_1 g1168_0 2.224404
.ends

.subckt netg1394 g1394_1 g1394_0 gnd
C1  g1394_1 gnd 2.080806f
C2  g1394_0 gnd 2.080806f
R1 g1394_1 g1394_0 2.224404
.ends

.subckt netg6440 g6440_0 g6440_1 gnd
C1  g6440_0 gnd 2.080806f
C2  g6440_1 gnd 2.080806f
R1 g6440_1 g6440_0 2.224404
.ends

.subckt netg5354 g5354_1 g5354_0 gnd
C1  g5354_1 gnd 2.080806f
C2  g5354_0 gnd 2.080806f
R1 g5354_0 g5354_1 2.224404
.ends

.subckt netg6437 g6437_0 g6437_1 gnd
C1  g6437_0 gnd 2.080806f
C2  g6437_1 gnd 2.080806f
R1 g6437_0 g6437_1 2.224404
.ends

.subckt netg865 g865_1 g865_2 gnd
C1  g865_1 gnd 2.080806f
C2  g865_2 gnd 2.080806f
R1 g865_2 g865_1 2.224404
.ends

.subckt netg2931 g2931_0 g2931_1 gnd
C1  g2931_0 gnd 2.080806f
C2  g2931_1 gnd 2.080806f
R1 g2931_0 g2931_1 2.224404
.ends

.subckt netg5135 g5135_0 g5135_1 gnd
C1  g5135_0 gnd 2.080806f
C2  g5135_1 gnd 2.080806f
R1 g5135_1 g5135_0 2.224404
.ends

.subckt netg6994 g6994_1 g6994_0 gnd
C1  g6994_1 gnd 2.080806f
C2  g6994_0 gnd 2.080806f
R1 g6994_1 g6994_0 2.224404
.ends

.subckt netg6194 g6194_1 g6194_0 gnd
C1  g6194_1 gnd 2.080806f
C2  g6194_0 gnd 2.080806f
R1 g6194_0 g6194_1 2.224404
.ends

.subckt netg752 g752_1 g752_0 gnd
C1  g752_1 gnd 2.080806f
C2  g752_0 gnd 2.080806f
R1 g752_1 g752_0 2.224404
.ends

.subckt netg7270 g7270_1 g7270_0 gnd
C1  g7270_1 gnd 2.080806f
C2  g7270_0 gnd 2.080806f
R1 g7270_1 g7270_0 2.224404
.ends

.subckt netx11 x11_1 x11_0 gnd
C1  x11_1 gnd 2.080806f
C2  x11_0 gnd 2.080806f
R1 x11_1 x11_0 2.224404
.ends

.subckt netg4108 g4108_0 g4108_1 gnd
C1  g4108_0 gnd 2.080806f
C2  g4108_1 gnd 2.080806f
R1 g4108_0 g4108_1 2.224404
.ends

.subckt netg6502 g6502_2 g6502_0 gnd
C1  g6502_2 gnd 2.080806f
C2  g6502_0 gnd 2.080806f
R1 g6502_0 g6502_2 2.224404
.ends

.subckt netg3904 g3904_1 g3904_0 gnd
C1  g3904_1 gnd 2.080806f
C2  g3904_0 gnd 2.080806f
R1 g3904_1 g3904_0 2.224404
.ends

.subckt netg1382 g1382_1 g1382_0 gnd
C1  g1382_1 gnd 2.080806f
C2  g1382_0 gnd 2.080806f
R1 g1382_1 g1382_0 2.224404
.ends

.subckt netg3497 g3497_1 g3497_0 gnd
C1  g3497_1 gnd 2.080806f
C2  g3497_0 gnd 2.080806f
R1 g3497_1 g3497_0 2.224404
.ends

.subckt netg6587 g6587_1 g6587_0 gnd
C1  g6587_1 gnd 2.080806f
C2  g6587_0 gnd 2.080806f
R1 g6587_1 g6587_0 2.224404
.ends

.subckt netg4242 g4242_1 g4242_0 gnd
C1  g4242_1 gnd 2.080806f
C2  g4242_0 gnd 2.080806f
R1 g4242_1 g4242_0 2.224404
.ends

.subckt netg4121 g4121_0 g4121_2 gnd
C1  g4121_0 gnd 2.080806f
C2  g4121_2 gnd 2.080806f
R1 g4121_2 g4121_0 2.224404
.ends

.subckt netg3081 g3081_0 g3081_1 gnd
C1  g3081_0 gnd 2.080806f
C2  g3081_1 gnd 2.080806f
R1 g3081_1 g3081_0 2.224404
.ends

.subckt netg6549 g6549_1 g6549_0 gnd
C1  g6549_1 gnd 2.080806f
C2  g6549_0 gnd 2.080806f
R1 g6549_1 g6549_0 2.224404
.ends

.subckt netg3129 g3129_2 g3129_1 gnd
C1  g3129_2 gnd 2.080806f
C2  g3129_1 gnd 2.080806f
R1 g3129_1 g3129_2 2.224404
.ends

.subckt netg1934 g1934_0 g1934_1 gnd
C1  g1934_0 gnd 2.080806f
C2  g1934_1 gnd 2.080806f
R1 g1934_1 g1934_0 2.224404
.ends

.subckt netg3577 g3577_1 g3577_0 gnd
C1  g3577_1 gnd 2.080806f
C2  g3577_0 gnd 2.080806f
R1 g3577_0 g3577_1 2.224404
.ends

.subckt netg2793 g2793_1 g2793_0 gnd
C1  g2793_1 gnd 2.080806f
C2  g2793_0 gnd 2.080806f
R1 g2793_0 g2793_1 2.224404
.ends

.subckt netg5604 g5604_1 g5604_0 gnd
C1  g5604_1 gnd 2.080806f
C2  g5604_0 gnd 2.080806f
R1 g5604_0 g5604_1 2.224404
.ends

.subckt netg1925 g1925_0 g1925_1 gnd
C1  g1925_0 gnd 2.080806f
C2  g1925_1 gnd 2.080806f
R1 g1925_1 g1925_0 2.224404
.ends

.subckt netg4264 g4264_0 g4264_1 gnd
C1  g4264_0 gnd 2.080806f
C2  g4264_1 gnd 2.080806f
R1 g4264_0 g4264_1 2.224404
.ends

.subckt netg6586 g6586_0 g6586_1 gnd
C1  g6586_0 gnd 2.080806f
C2  g6586_1 gnd 2.080806f
R1 g6586_1 g6586_0 2.224404
.ends

.subckt netg4223 g4223_0 g4223_1 gnd
C1  g4223_0 gnd 2.080806f
C2  g4223_1 gnd 2.080806f
R1 g4223_1 g4223_0 2.224404
.ends

.subckt netg3565 g3565_0 g3565_1 gnd
C1  g3565_0 gnd 2.080806f
C2  g3565_1 gnd 2.080806f
R1 g3565_0 g3565_1 2.224404
.ends

.subckt netg6390 g6390_0 g6390_1 gnd
C1  g6390_0 gnd 2.080806f
C2  g6390_1 gnd 2.080806f
R1 g6390_0 g6390_1 2.224404
.ends

.subckt netg7025 g7025_1 g7025_0 gnd
C1  g7025_1 gnd 2.080806f
C2  g7025_0 gnd 2.080806f
R1 g7025_0 g7025_1 2.224404
.ends

.subckt netg3049 g3049_1 g3049_0 gnd
C1  g3049_1 gnd 2.080806f
C2  g3049_0 gnd 2.080806f
R1 g3049_0 g3049_1 2.224404
.ends

.subckt netg6743 g6743_1 g6743_0 gnd
C1  g6743_1 gnd 2.080806f
C2  g6743_0 gnd 2.080806f
R1 g6743_1 g6743_0 2.224404
.ends

.subckt netg6101 g6101_1 g6101_0 gnd
C1  g6101_1 gnd 2.080806f
C2  g6101_0 gnd 2.080806f
R1 g6101_0 g6101_1 2.224404
.ends

.subckt netg1228 g1228_1 g1228_0 gnd
C1  g1228_1 gnd 2.080806f
C2  g1228_0 gnd 2.080806f
R1 g1228_0 g1228_1 2.224404
.ends

.subckt netg6451 g6451_1 g6451_0 gnd
C1  g6451_1 gnd 2.080806f
C2  g6451_0 gnd 2.080806f
R1 g6451_0 g6451_1 2.224404
.ends

.subckt netg2790 g2790_1 g2790_0 gnd
C1  g2790_1 gnd 2.080806f
C2  g2790_0 gnd 2.080806f
R1 g2790_0 g2790_1 2.224404
.ends

.subckt netg3067 g3067_0 g3067_1 gnd
C1  g3067_0 gnd 2.080806f
C2  g3067_1 gnd 2.080806f
R1 g3067_1 g3067_0 2.224404
.ends

.subckt netg6138 g6138_0 g6138_1 gnd
C1  g6138_0 gnd 2.080806f
C2  g6138_1 gnd 2.080806f
R1 g6138_1 g6138_0 2.224404
.ends

.subckt netx371 x371_1 x371_0 gnd
C1  x371_1 gnd 2.080806f
C2  x371_0 gnd 2.080806f
R1 x371_1 x371_0 2.224404
.ends

.subckt netg1172 g1172_0 g1172_1 gnd
C1  g1172_0 gnd 2.080806f
C2  g1172_1 gnd 2.080806f
R1 g1172_1 g1172_0 2.224404
.ends

.subckt netg2762 g2762_1 g2762_0 gnd
C1  g2762_1 gnd 2.080806f
C2  g2762_0 gnd 2.080806f
R1 g2762_1 g2762_0 2.224404
.ends

.subckt netg5599 g5599_1 g5599_0 gnd
C1  g5599_1 gnd 2.080806f
C2  g5599_0 gnd 2.080806f
R1 g5599_0 g5599_1 2.224404
.ends

.subckt netg5364 g5364_0 g5364_1 gnd
C1  g5364_0 gnd 2.080806f
C2  g5364_1 gnd 2.080806f
R1 g5364_0 g5364_1 2.224404
.ends

.subckt netg5318 g5318_0 g5318_1 gnd
C1  g5318_0 gnd 2.080806f
C2  g5318_1 gnd 2.080806f
R1 g5318_1 g5318_0 2.224404
.ends

.subckt netg6539 g6539_0 g6539_1 gnd
C1  g6539_0 gnd 2.080806f
C2  g6539_1 gnd 2.080806f
R1 g6539_1 g6539_0 2.224404
.ends

.subckt netg6742 g6742_0 g6742_1 gnd
C1  g6742_0 gnd 2.080806f
C2  g6742_1 gnd 2.080806f
R1 g6742_1 g6742_0 2.224404
.ends

.subckt netg7082 g7082_0 g7082_1 gnd
C1  g7082_0 gnd 2.080806f
C2  g7082_1 gnd 2.080806f
R1 g7082_0 g7082_1 2.224404
.ends

.subckt netg1930 g1930_0 g1930_1 gnd
C1  g1930_0 gnd 2.080806f
C2  g1930_1 gnd 2.080806f
R1 g1930_1 g1930_0 2.224404
.ends

.subckt netg4336 g4336_1 g4336_0 gnd
C1  g4336_1 gnd 2.080806f
C2  g4336_0 gnd 2.080806f
R1 g4336_0 g4336_1 2.224404
.ends

.subckt netg4529 g4529_1 g4529_0 gnd
C1  g4529_1 gnd 2.080806f
C2  g4529_0 gnd 2.080806f
R1 g4529_1 g4529_0 2.224404
.ends

.subckt netg5596 g5596_1 g5596_0 gnd
C1  g5596_1 gnd 2.080806f
C2  g5596_0 gnd 2.080806f
R1 g5596_0 g5596_1 2.224404
.ends

.subckt netg1369 g1369_2 g1369_0 gnd
C1  g1369_2 gnd 2.080806f
C2  g1369_0 gnd 2.080806f
R1 g1369_2 g1369_0 2.224404
.ends

.subckt netx512 x512_1 x512_0 gnd
C1  x512_1 gnd 2.080806f
C2  x512_0 gnd 2.080806f
R1 x512_1 x512_0 2.224404
.ends

.subckt netg4058 g4058_0 g4058_1 gnd
C1  g4058_0 gnd 2.080806f
C2  g4058_1 gnd 2.080806f
R1 g4058_0 g4058_1 2.224404
.ends

.subckt netg1906 g1906_1 g1906_0 gnd
C1  g1906_1 gnd 2.080806f
C2  g1906_0 gnd 2.080806f
R1 g1906_1 g1906_0 2.224404
.ends

.subckt netg4402 g4402_0 g4402_1 gnd
C1  g4402_0 gnd 2.080806f
C2  g4402_1 gnd 2.080806f
R1 g4402_0 g4402_1 2.224404
.ends

.subckt netg2833 g2833_1 g2833_0 gnd
C1  g2833_1 gnd 2.080806f
C2  g2833_0 gnd 2.080806f
R1 g2833_0 g2833_1 2.224404
.ends

.subckt netg5775 g5775_1 g5775_0 gnd
C1  g5775_1 gnd 2.080806f
C2  g5775_0 gnd 2.080806f
R1 g5775_1 g5775_0 2.224404
.ends

.subckt netg2998 g2998_1 g2998_0 gnd
C1  g2998_1 gnd 2.080806f
C2  g2998_0 gnd 2.080806f
R1 g2998_1 g2998_0 2.224404
.ends

.subckt netg3556 g3556_0 g3556_1 gnd
C1  g3556_0 gnd 2.080806f
C2  g3556_1 gnd 2.080806f
R1 g3556_0 g3556_1 2.224404
.ends

.subckt netg3365 g3365_0 g3365_1 gnd
C1  g3365_0 gnd 2.080806f
C2  g3365_1 gnd 2.080806f
R1 g3365_0 g3365_1 2.224404
.ends

.subckt netg5511 g5511_0 g5511_1 gnd
C1  g5511_0 gnd 2.080806f
C2  g5511_1 gnd 2.080806f
R1 g5511_0 g5511_1 2.224404
.ends

.subckt netg1251 g1251_0 g1251_1 gnd
C1  g1251_0 gnd 2.080806f
C2  g1251_1 gnd 2.080806f
R1 g1251_1 g1251_0 2.224404
.ends

.subckt netg4110 g4110_1 g4110_0 gnd
C1  g4110_1 gnd 2.080806f
C2  g4110_0 gnd 2.080806f
R1 g4110_1 g4110_0 2.224404
.ends

.subckt netg6649 g6649_1 g6649_0 gnd
C1  g6649_1 gnd 2.080806f
C2  g6649_0 gnd 2.080806f
R1 g6649_0 g6649_1 2.224404
.ends

.subckt netg5674 g5674_0 g5674_2 gnd
C1  g5674_0 gnd 2.080806f
C2  g5674_2 gnd 2.080806f
R1 g5674_0 g5674_2 2.224404
.ends

.subckt netg6150 g6150_1 g6150_0 gnd
C1  g6150_1 gnd 2.080806f
C2  g6150_0 gnd 2.080806f
R1 g6150_0 g6150_1 2.224404
.ends

.subckt netg7340 g7340_0 g7340_1 gnd
C1  g7340_0 gnd 2.080806f
C2  g7340_1 gnd 2.080806f
R1 g7340_0 g7340_1 2.224404
.ends

.subckt netg1033 g1033_2 g1033_1 gnd
C1  g1033_2 gnd 2.080806f
C2  g1033_1 gnd 2.080806f
R1 g1033_2 g1033_1 2.224404
.ends

.subckt netg6208 g6208_1 g6208_0 gnd
C1  g6208_1 gnd 2.080806f
C2  g6208_0 gnd 2.080806f
R1 g6208_0 g6208_1 2.224404
.ends

.subckt netg5969 g5969_1 g5969_0 gnd
C1  g5969_1 gnd 2.080806f
C2  g5969_0 gnd 2.080806f
R1 g5969_0 g5969_1 2.224404
.ends

.subckt netg6662 g6662_0 g6662_1 gnd
C1  g6662_0 gnd 2.080806f
C2  g6662_1 gnd 2.080806f
R1 g6662_1 g6662_0 2.224404
.ends

.subckt netg4132 g4132_1 g4132_0 gnd
C1  g4132_1 gnd 2.080806f
C2  g4132_0 gnd 2.080806f
R1 g4132_1 g4132_0 2.224404
.ends

.subckt netg5417 g5417_1 g5417_0 gnd
C1  g5417_1 gnd 2.080806f
C2  g5417_0 gnd 2.080806f
R1 g5417_1 g5417_0 2.224404
.ends

.subckt netg3109 g3109_0 g3109_1 gnd
C1  g3109_0 gnd 2.080806f
C2  g3109_1 gnd 2.080806f
R1 g3109_0 g3109_1 2.224404
.ends

.subckt netg2815 g2815_0 g2815_1 gnd
C1  g2815_0 gnd 2.080806f
C2  g2815_1 gnd 2.080806f
R1 g2815_0 g2815_1 2.224404
.ends

.subckt netg7045 g7045_0 g7045_1 gnd
C1  g7045_0 gnd 2.080806f
C2  g7045_1 gnd 2.080806f
R1 g7045_1 g7045_0 2.224404
.ends

.subckt netg3974 g3974_0 g3974_1 gnd
C1  g3974_0 gnd 2.080806f
C2  g3974_1 gnd 2.080806f
R1 g3974_1 g3974_0 2.224404
.ends

.subckt netx481 x481_0 x481_1 gnd
C1  x481_0 gnd 2.080806f
C2  x481_1 gnd 2.080806f
R1 x481_1 x481_0 2.224404
.ends

.subckt netx412 x412_1 x412_0 gnd
C1  x412_1 gnd 2.080806f
C2  x412_0 gnd 2.080806f
R1 x412_1 x412_0 2.224404
.ends

.subckt netg6624 g6624_1 g6624_0 gnd
C1  g6624_1 gnd 2.080806f
C2  g6624_0 gnd 2.080806f
R1 g6624_0 g6624_1 2.224404
.ends

.subckt netg5392 g5392_1 g5392_0 gnd
C1  g5392_1 gnd 2.080806f
C2  g5392_0 gnd 2.080806f
R1 g5392_0 g5392_1 2.224404
.ends

.subckt netg3477 g3477_1 g3477_0 gnd
C1  g3477_1 gnd 2.080806f
C2  g3477_0 gnd 2.080806f
R1 g3477_1 g3477_0 2.224404
.ends

.subckt netg1230 g1230_1 g1230_0 gnd
C1  g1230_1 gnd 2.080806f
C2  g1230_0 gnd 2.080806f
R1 g1230_0 g1230_1 2.224404
.ends

.subckt netg2944 g2944_0 g2944_1 gnd
C1  g2944_0 gnd 2.080806f
C2  g2944_1 gnd 2.080806f
R1 g2944_0 g2944_1 2.224404
.ends

.subckt netg4334 g4334_1 g4334_0 gnd
C1  g4334_1 gnd 2.080806f
C2  g4334_0 gnd 2.080806f
R1 g4334_0 g4334_1 2.224404
.ends

.subckt netg3682 g3682_0 g3682_1 gnd
C1  g3682_0 gnd 2.080806f
C2  g3682_1 gnd 2.080806f
R1 g3682_0 g3682_1 2.224404
.ends

.subckt netg7396 g7396_1 g7396_0 gnd
C1  g7396_1 gnd 2.080806f
C2  g7396_0 gnd 2.080806f
R1 g7396_1 g7396_0 2.224404
.ends

.subckt netg1480 g1480_0 g1480_1 gnd
C1  g1480_0 gnd 2.080806f
C2  g1480_1 gnd 2.080806f
R1 g1480_0 g1480_1 2.224404
.ends

.subckt netg2780 g2780_1 g2780_0 gnd
C1  g2780_1 gnd 2.080806f
C2  g2780_0 gnd 2.080806f
R1 g2780_0 g2780_1 2.224404
.ends

.subckt netg4299 g4299_1 g4299_0 gnd
C1  g4299_1 gnd 2.080806f
C2  g4299_0 gnd 2.080806f
R1 g4299_1 g4299_0 2.224404
.ends

.subckt netg7186 g7186_1 g7186_0 gnd
C1  g7186_1 gnd 2.080806f
C2  g7186_0 gnd 2.080806f
R1 g7186_0 g7186_1 2.224404
.ends

.subckt netg4308 g4308_1 g4308_0 gnd
C1  g4308_1 gnd 2.080806f
C2  g4308_0 gnd 2.080806f
R1 g4308_0 g4308_1 2.224404
.ends

.subckt netg2707 g2707_0 g2707_2 gnd
C1  g2707_0 gnd 2.080806f
C2  g2707_2 gnd 2.080806f
R1 g2707_2 g2707_0 2.224404
.ends

.subckt netg7272 g7272_0 g7272_1 gnd
C1  g7272_0 gnd 2.080806f
C2  g7272_1 gnd 2.080806f
R1 g7272_1 g7272_0 2.224404
.ends

.subckt netg6873 g6873_1 g6873_0 gnd
C1  g6873_1 gnd 2.080806f
C2  g6873_0 gnd 2.080806f
R1 g6873_0 g6873_1 2.224404
.ends

.subckt netg5247 g5247_1 g5247_0 gnd
C1  g5247_1 gnd 2.080806f
C2  g5247_0 gnd 2.080806f
R1 g5247_1 g5247_0 2.224404
.ends

.subckt netg5856 g5856_0 g5856_1 gnd
C1  g5856_0 gnd 2.080806f
C2  g5856_1 gnd 2.080806f
R1 g5856_1 g5856_0 2.224404
.ends

.subckt netg2941 g2941_0 g2941_1 gnd
C1  g2941_0 gnd 2.080806f
C2  g2941_1 gnd 2.080806f
R1 g2941_1 g2941_0 2.224404
.ends

.subckt netg5997 g5997_1 g5997_0 gnd
C1  g5997_1 gnd 2.080806f
C2  g5997_0 gnd 2.080806f
R1 g5997_0 g5997_1 2.224404
.ends

.subckt netg6040 g6040_0 g6040_1 gnd
C1  g6040_0 gnd 2.080806f
C2  g6040_1 gnd 2.080806f
R1 g6040_1 g6040_0 2.224404
.ends

.subckt netg1261 g1261_1 g1261_0 gnd
C1  g1261_1 gnd 2.080806f
C2  g1261_0 gnd 2.080806f
R1 g1261_0 g1261_1 2.224404
.ends

.subckt netg3555 g3555_1 g3555_0 gnd
C1  g3555_1 gnd 2.080806f
C2  g3555_0 gnd 2.080806f
R1 g3555_1 g3555_0 2.224404
.ends

.subckt netg6292 g6292_1 g6292_0 gnd
C1  g6292_1 gnd 2.080806f
C2  g6292_0 gnd 2.080806f
R1 g6292_1 g6292_0 2.224404
.ends

.subckt netg5684 g5684_1 g5684_0 gnd
C1  g5684_1 gnd 2.080806f
C2  g5684_0 gnd 2.080806f
R1 g5684_0 g5684_1 2.224404
.ends

.subckt netg4288 g4288_0 g4288_1 gnd
C1  g4288_0 gnd 2.080806f
C2  g4288_1 gnd 2.080806f
R1 g4288_0 g4288_1 2.224404
.ends

.subckt netg7175 g7175_1 g7175_0 gnd
C1  g7175_1 gnd 2.080806f
C2  g7175_0 gnd 2.080806f
R1 g7175_0 g7175_1 2.224404
.ends

.subckt netg4618 g4618_0 g4618_1 gnd
C1  g4618_0 gnd 2.080806f
C2  g4618_1 gnd 2.080806f
R1 g4618_0 g4618_1 2.224404
.ends

.subckt netg7403 g7403_1 g7403_0 gnd
C1  g7403_1 gnd 2.080806f
C2  g7403_0 gnd 2.080806f
R1 g7403_1 g7403_0 2.224404
.ends

.subckt netg4208 g4208_1 g4208_0 gnd
C1  g4208_1 gnd 2.080806f
C2  g4208_0 gnd 2.080806f
R1 g4208_0 g4208_1 2.224404
.ends

.subckt netg2644 g2644_2 g2644_1 gnd
C1  g2644_2 gnd 2.080806f
C2  g2644_1 gnd 2.080806f
R1 g2644_2 g2644_1 2.224404
.ends

.subckt netg4261 g4261_0 g4261_1 gnd
C1  g4261_0 gnd 2.080806f
C2  g4261_1 gnd 2.080806f
R1 g4261_0 g4261_1 2.224404
.ends

.subckt netg3438 g3438_2 g3438_1 gnd
C1  g3438_2 gnd 2.080806f
C2  g3438_1 gnd 2.080806f
R1 g3438_2 g3438_1 2.224404
.ends

.subckt netg7409 g7409_1 g7409_0 gnd
C1  g7409_1 gnd 2.080806f
C2  g7409_0 gnd 2.080806f
R1 g7409_0 g7409_1 2.224404
.ends

.subckt netg4234 g4234_0 g4234_1 gnd
C1  g4234_0 gnd 2.080806f
C2  g4234_1 gnd 2.080806f
R1 g4234_1 g4234_0 2.224404
.ends

.subckt netg1922 g1922_0 g1922_1 gnd
C1  g1922_0 gnd 2.080806f
C2  g1922_1 gnd 2.080806f
R1 g1922_1 g1922_0 2.224404
.ends

.subckt netg1254 g1254_0 g1254_1 gnd
C1  g1254_0 gnd 2.080806f
C2  g1254_1 gnd 2.080806f
R1 g1254_0 g1254_1 2.224404
.ends

.subckt netg4311 g4311_1 g4311_0 gnd
C1  g4311_1 gnd 2.080806f
C2  g4311_0 gnd 2.080806f
R1 g4311_1 g4311_0 2.224404
.ends

.subckt netg6082 g6082_1 g6082_0 gnd
C1  g6082_1 gnd 2.080806f
C2  g6082_0 gnd 2.080806f
R1 g6082_0 g6082_1 2.224404
.ends

.subckt netg3349 g3349_2 g3349_1 gnd
C1  g3349_2 gnd 2.080806f
C2  g3349_1 gnd 2.080806f
R1 g3349_1 g3349_2 2.224404
.ends

.subckt netg1893 g1893_1 g1893_0 gnd
C1  g1893_1 gnd 2.080806f
C2  g1893_0 gnd 2.080806f
R1 g1893_0 g1893_1 2.224404
.ends

.subckt netg6845 g6845_0 g6845_1 gnd
C1  g6845_0 gnd 2.080806f
C2  g6845_1 gnd 2.080806f
R1 g6845_1 g6845_0 2.224404
.ends

.subckt netg5788 g5788_1 g5788_0 gnd
C1  g5788_1 gnd 2.080806f
C2  g5788_0 gnd 2.080806f
R1 g5788_0 g5788_1 2.224404
.ends

.subckt netg6929 g6929_1 g6929_0 gnd
C1  g6929_1 gnd 2.080806f
C2  g6929_0 gnd 2.080806f
R1 g6929_1 g6929_0 2.224404
.ends

.subckt netg694 g694_1 g694_0 gnd
C1  g694_1 gnd 2.080806f
C2  g694_0 gnd 2.080806f
R1 g694_0 g694_1 2.224404
.ends

.subckt netg5071 g5071_2 g5071_0 gnd
C1  g5071_2 gnd 2.080806f
C2  g5071_0 gnd 2.080806f
R1 g5071_0 g5071_2 2.224404
.ends

.subckt netg4018 g4018_1 g4018_0 gnd
C1  g4018_1 gnd 2.080806f
C2  g4018_0 gnd 2.080806f
R1 g4018_0 g4018_1 2.224404
.ends

.subckt netg4398 g4398_1 g4398_0 gnd
C1  g4398_1 gnd 2.080806f
C2  g4398_0 gnd 2.080806f
R1 g4398_0 g4398_1 2.224404
.ends

.subckt netg6079 g6079_0 g6079_1 gnd
C1  g6079_0 gnd 2.080806f
C2  g6079_1 gnd 2.080806f
R1 g6079_1 g6079_0 2.224404
.ends

.subckt netg7277 g7277_0 g7277_1 gnd
C1  g7277_0 gnd 2.080806f
C2  g7277_1 gnd 2.080806f
R1 g7277_0 g7277_1 2.224404
.ends

.subckt netx52 x52_0 x52_1 gnd
C1  x52_0 gnd 2.080806f
C2  x52_1 gnd 2.080806f
R1 x52_0 x52_1 2.224404
.ends

.subckt netg1406 g1406_1 g1406_0 gnd
C1  g1406_1 gnd 2.080806f
C2  g1406_0 gnd 2.080806f
R1 g1406_0 g1406_1 2.224404
.ends

.subckt netg7439 g7439_1 g7439_0 gnd
C1  g7439_1 gnd 2.080806f
C2  g7439_0 gnd 2.080806f
R1 g7439_0 g7439_1 2.224404
.ends

.subckt netg6695 g6695_1 g6695_0 gnd
C1  g6695_1 gnd 2.080806f
C2  g6695_0 gnd 2.080806f
R1 g6695_0 g6695_1 2.224404
.ends

.subckt netg6490 g6490_1 g6490_0 gnd
C1  g6490_1 gnd 2.080806f
C2  g6490_0 gnd 2.080806f
R1 g6490_0 g6490_1 2.224404
.ends

.subckt netg690 g690_1 g690_0 gnd
C1  g690_1 gnd 2.080806f
C2  g690_0 gnd 2.080806f
R1 g690_1 g690_0 2.224404
.ends

.subckt netg6825 g6825_1 g6825_0 gnd
C1  g6825_1 gnd 2.080806f
C2  g6825_0 gnd 2.080806f
R1 g6825_0 g6825_1 2.224404
.ends

.subckt netg5119 g5119_1 g5119_0 gnd
C1  g5119_1 gnd 2.080806f
C2  g5119_0 gnd 2.080806f
R1 g5119_1 g5119_0 2.224404
.ends

.subckt netg7196 g7196_1 g7196_0 gnd
C1  g7196_1 gnd 2.080806f
C2  g7196_0 gnd 2.080806f
R1 g7196_1 g7196_0 2.224404
.ends

.subckt netg6404 g6404_1 g6404_0 gnd
C1  g6404_1 gnd 2.080806f
C2  g6404_0 gnd 2.080806f
R1 g6404_1 g6404_0 2.224404
.ends

.subckt netg5607 g5607_0 g5607_1 gnd
C1  g5607_0 gnd 2.080806f
C2  g5607_1 gnd 2.080806f
R1 g5607_0 g5607_1 2.224404
.ends

.subckt netg1377 g1377_1 g1377_0 gnd
C1  g1377_1 gnd 2.080806f
C2  g1377_0 gnd 2.080806f
R1 g1377_0 g1377_1 2.224404
.ends

.subckt netg4097 g4097_1 g4097_0 gnd
C1  g4097_1 gnd 2.080806f
C2  g4097_0 gnd 2.080806f
R1 g4097_1 g4097_0 2.224404
.ends

.subckt netg5321 g5321_1 g5321_0 gnd
C1  g5321_1 gnd 2.080806f
C2  g5321_0 gnd 2.080806f
R1 g5321_0 g5321_1 2.224404
.ends

.subckt netg3417 g3417_2 g3417_0 gnd
C1  g3417_2 gnd 2.080806f
C2  g3417_0 gnd 2.080806f
R1 g3417_0 g3417_2 2.224404
.ends

.subckt netg913 g913_1 g913_2 gnd
C1  g913_1 gnd 2.080806f
C2  g913_2 gnd 2.080806f
R1 g913_1 g913_2 2.224404
.ends

.subckt netg6461 g6461_0 g6461_1 gnd
C1  g6461_0 gnd 2.080806f
C2  g6461_1 gnd 2.080806f
R1 g6461_0 g6461_1 2.224404
.ends

.subckt netg2779 g2779_1 g2779_0 gnd
C1  g2779_1 gnd 2.080806f
C2  g2779_0 gnd 2.080806f
R1 g2779_0 g2779_1 2.224404
.ends

.subckt netg97 g97_0 g97_1 gnd
C1  g97_0 gnd 2.080806f
C2  g97_1 gnd 2.080806f
R1 g97_1 g97_0 2.224404
.ends

.subckt netg985 g985_0 g985_2 gnd
C1  g985_0 gnd 2.080806f
C2  g985_2 gnd 2.080806f
R1 g985_0 g985_2 2.224404
.ends

.subckt netg1259 g1259_0 g1259_1 gnd
C1  g1259_0 gnd 2.080806f
C2  g1259_1 gnd 2.080806f
R1 g1259_0 g1259_1 2.224404
.ends

.subckt netg3046 g3046_1 g3046_0 gnd
C1  g3046_1 gnd 2.080806f
C2  g3046_0 gnd 2.080806f
R1 g3046_1 g3046_0 2.224404
.ends

.subckt netg7389 g7389_0 g7389_1 gnd
C1  g7389_0 gnd 2.080806f
C2  g7389_1 gnd 2.080806f
R1 g7389_0 g7389_1 2.224404
.ends

.subckt netg1516 g1516_0 g1516_1 gnd
C1  g1516_0 gnd 2.080806f
C2  g1516_1 gnd 2.080806f
R1 g1516_1 g1516_0 2.224404
.ends

.subckt netg5367 g5367_0 g5367_1 gnd
C1  g5367_0 gnd 2.080806f
C2  g5367_1 gnd 2.080806f
R1 g5367_1 g5367_0 2.224404
.ends

.subckt netg7026 g7026_1 g7026_0 gnd
C1  g7026_1 gnd 2.080806f
C2  g7026_0 gnd 2.080806f
R1 g7026_1 g7026_0 2.224404
.ends

.subckt netg6579 g6579_1 g6579_0 gnd
C1  g6579_1 gnd 2.080806f
C2  g6579_0 gnd 2.080806f
R1 g6579_0 g6579_1 2.224404
.ends

.subckt netg5360 g5360_0 g5360_1 gnd
C1  g5360_0 gnd 2.080806f
C2  g5360_1 gnd 2.080806f
R1 g5360_0 g5360_1 2.224404
.ends

.subckt netg2477 g2477_2 g2477_1 gnd
C1  g2477_2 gnd 2.080806f
C2  g2477_1 gnd 2.080806f
R1 g2477_2 g2477_1 2.224404
.ends

.subckt netg7168 g7168_0 g7168_1 gnd
C1  g7168_0 gnd 2.080806f
C2  g7168_1 gnd 2.080806f
R1 g7168_1 g7168_0 2.224404
.ends

.subckt netg3892 g3892_1 g3892_0 gnd
C1  g3892_1 gnd 2.080806f
C2  g3892_0 gnd 2.080806f
R1 g3892_0 g3892_1 2.224404
.ends

.subckt netg4295 g4295_1 g4295_0 gnd
C1  g4295_1 gnd 2.080806f
C2  g4295_0 gnd 2.080806f
R1 g4295_0 g4295_1 2.224404
.ends

.subckt netg6365 g6365_1 g6365_0 gnd
C1  g6365_1 gnd 2.080806f
C2  g6365_0 gnd 2.080806f
R1 g6365_0 g6365_1 2.224404
.ends

.subckt netg6819 g6819_1 g6819_0 gnd
C1  g6819_1 gnd 2.080806f
C2  g6819_0 gnd 2.080806f
R1 g6819_0 g6819_1 2.224404
.ends

.subckt netg560 g560_1 g560_0 gnd
C1  g560_1 gnd 2.080806f
C2  g560_0 gnd 2.080806f
R1 g560_1 g560_0 2.224404
.ends

.subckt netg2783 g2783_0 g2783_1 gnd
C1  g2783_0 gnd 2.080806f
C2  g2783_1 gnd 2.080806f
R1 g2783_1 g2783_0 2.224404
.ends

.subckt netg5605 g5605_0 g5605_1 gnd
C1  g5605_0 gnd 2.080806f
C2  g5605_1 gnd 2.080806f
R1 g5605_1 g5605_0 2.224404
.ends

.subckt netg3412 g3412_0 g3412_1 gnd
C1  g3412_0 gnd 2.080806f
C2  g3412_1 gnd 2.080806f
R1 g3412_1 g3412_0 2.224404
.ends

.subckt netg3085 g3085_1 g3085_0 gnd
C1  g3085_1 gnd 2.080806f
C2  g3085_0 gnd 2.080806f
R1 g3085_1 g3085_0 2.224404
.ends

.subckt netg5961 g5961_0 g5961_1 gnd
C1  g5961_0 gnd 2.080806f
C2  g5961_1 gnd 2.080806f
R1 g5961_0 g5961_1 2.224404
.ends

.subckt netg1535 g1535_1 g1535_0 gnd
C1  g1535_1 gnd 2.080806f
C2  g1535_0 gnd 2.080806f
R1 g1535_1 g1535_0 2.224404
.ends

.subckt netg6967 g6967_2 g6967_1 gnd
C1  g6967_2 gnd 2.080806f
C2  g6967_1 gnd 2.080806f
R1 g6967_2 g6967_1 2.224404
.ends

.subckt netx401 x401_1 x401_0 gnd
C1  x401_1 gnd 2.080806f
C2  x401_0 gnd 2.080806f
R1 x401_0 x401_1 2.224404
.ends

.subckt netg4182 g4182_1 g4182_0 gnd
C1  g4182_1 gnd 2.080806f
C2  g4182_0 gnd 2.080806f
R1 g4182_1 g4182_0 2.224404
.ends

.subckt netg6888 g6888_1 g6888_0 gnd
C1  g6888_1 gnd 2.080806f
C2  g6888_0 gnd 2.080806f
R1 g6888_0 g6888_1 2.224404
.ends

.subckt netg3982 g3982_0 g3982_1 gnd
C1  g3982_0 gnd 2.080806f
C2  g3982_1 gnd 2.080806f
R1 g3982_1 g3982_0 2.224404
.ends

.subckt netg6672 g6672_1 g6672_0 gnd
C1  g6672_1 gnd 2.080806f
C2  g6672_0 gnd 2.080806f
R1 g6672_0 g6672_1 2.224404
.ends

.subckt netg4112 g4112_0 g4112_1 gnd
C1  g4112_0 gnd 2.080806f
C2  g4112_1 gnd 2.080806f
R1 g4112_0 g4112_1 2.224404
.ends

.subckt netg5874 g5874_1 g5874_0 gnd
C1  g5874_1 gnd 2.080806f
C2  g5874_0 gnd 2.080806f
R1 g5874_1 g5874_0 2.224404
.ends

.subckt netg5317 g5317_0 g5317_1 gnd
C1  g5317_0 gnd 2.080806f
C2  g5317_1 gnd 2.080806f
R1 g5317_1 g5317_0 2.224404
.ends

.subckt netg5181 g5181_1 g5181_0 gnd
C1  g5181_1 gnd 2.080806f
C2  g5181_0 gnd 2.080806f
R1 g5181_1 g5181_0 2.224404
.ends

.subckt netg5890 g5890_1 g5890_0 gnd
C1  g5890_1 gnd 2.080806f
C2  g5890_0 gnd 2.080806f
R1 g5890_1 g5890_0 2.224404
.ends

.subckt netg2221 g2221_0 g2221_1 gnd
C1  g2221_0 gnd 2.080806f
C2  g2221_1 gnd 2.080806f
R1 g2221_1 g2221_0 2.224404
.ends

.subckt netg2810 g2810_1 g2810_0 gnd
C1  g2810_1 gnd 2.080806f
C2  g2810_0 gnd 2.080806f
R1 g2810_1 g2810_0 2.224404
.ends

.subckt netg7214 g7214_0 g7214_1 gnd
C1  g7214_0 gnd 2.080806f
C2  g7214_1 gnd 2.080806f
R1 g7214_0 g7214_1 2.224404
.ends

.subckt netg5200 g5200_0 g5200_1 gnd
C1  g5200_0 gnd 2.080806f
C2  g5200_1 gnd 2.080806f
R1 g5200_0 g5200_1 2.224404
.ends

.subckt netg4202 g4202_0 g4202_1 gnd
C1  g4202_0 gnd 2.080806f
C2  g4202_1 gnd 2.080806f
R1 g4202_1 g4202_0 2.224404
.ends

.subckt netg6516 g6516_1 g6516_0 gnd
C1  g6516_1 gnd 2.080806f
C2  g6516_0 gnd 2.080806f
R1 g6516_1 g6516_0 2.224404
.ends

.subckt netg7395 g7395_1 g7395_0 gnd
C1  g7395_1 gnd 2.080806f
C2  g7395_0 gnd 2.080806f
R1 g7395_0 g7395_1 2.224404
.ends

.subckt netg3410 g3410_0 g3410_1 gnd
C1  g3410_0 gnd 2.080806f
C2  g3410_1 gnd 2.080806f
R1 g3410_0 g3410_1 2.224404
.ends

.subckt netg6469 g6469_0 g6469_1 gnd
C1  g6469_0 gnd 2.080806f
C2  g6469_1 gnd 2.080806f
R1 g6469_0 g6469_1 2.224404
.ends

.subckt netg4278 g4278_0 g4278_1 gnd
C1  g4278_0 gnd 2.080806f
C2  g4278_1 gnd 2.080806f
R1 g4278_0 g4278_1 2.224404
.ends

.subckt netg3895 g3895_0 g3895_1 gnd
C1  g3895_0 gnd 2.080806f
C2  g3895_1 gnd 2.080806f
R1 g3895_0 g3895_1 2.224404
.ends

.subckt netg6405 g6405_1 g6405_0 gnd
C1  g6405_1 gnd 2.080806f
C2  g6405_0 gnd 2.080806f
R1 g6405_0 g6405_1 2.224404
.ends

.subckt netg7299 g7299_1 g7299_0 gnd
C1  g7299_1 gnd 2.080806f
C2  g7299_0 gnd 2.080806f
R1 g7299_0 g7299_1 2.224404
.ends

.subckt netg6606 g6606_0 g6606_1 gnd
C1  g6606_0 gnd 2.080806f
C2  g6606_1 gnd 2.080806f
R1 g6606_0 g6606_1 2.224404
.ends

.subckt netg6609 g6609_0 g6609_1 gnd
C1  g6609_0 gnd 2.080806f
C2  g6609_1 gnd 2.080806f
R1 g6609_0 g6609_1 2.224404
.ends

.subckt netg6015 g6015_1 g6015_0 gnd
C1  g6015_1 gnd 2.080806f
C2  g6015_0 gnd 2.080806f
R1 g6015_1 g6015_0 2.224404
.ends

.subckt netg6999 g6999_0 g6999_1 gnd
C1  g6999_0 gnd 2.080806f
C2  g6999_1 gnd 2.080806f
R1 g6999_1 g6999_0 2.224404
.ends

.subckt netg1009 g1009_1 g1009_2 gnd
C1  g1009_1 gnd 2.080806f
C2  g1009_2 gnd 2.080806f
R1 g1009_1 g1009_2 2.224404
.ends

.subckt netg7192 g7192_0 g7192_1 gnd
C1  g7192_0 gnd 2.080806f
C2  g7192_1 gnd 2.080806f
R1 g7192_0 g7192_1 2.224404
.ends

.subckt netg2921 g2921_0 g2921_1 gnd
C1  g2921_0 gnd 2.080806f
C2  g2921_1 gnd 2.080806f
R1 g2921_1 g2921_0 2.224404
.ends

.subckt netg1003 g1003_1 g1003_2 gnd
C1  g1003_1 gnd 2.080806f
C2  g1003_2 gnd 2.080806f
R1 g1003_1 g1003_2 2.224404
.ends

.subckt netg4229 g4229_0 g4229_1 gnd
C1  g4229_0 gnd 2.080806f
C2  g4229_1 gnd 2.080806f
R1 g4229_0 g4229_1 2.224404
.ends

.subckt netg4150 g4150_0 g4150_1 gnd
C1  g4150_0 gnd 2.080806f
C2  g4150_1 gnd 2.080806f
R1 g4150_0 g4150_1 2.224404
.ends

.subckt netg4042 g4042_1 g4042_0 gnd
C1  g4042_1 gnd 2.080806f
C2  g4042_0 gnd 2.080806f
R1 g4042_0 g4042_1 2.224404
.ends

.subckt netg7064 g7064_1 g7064_0 gnd
C1  g7064_1 gnd 2.080806f
C2  g7064_0 gnd 2.080806f
R1 g7064_1 g7064_0 2.224404
.ends

.subckt netg6170 g6170_0 g6170_1 gnd
C1  g6170_0 gnd 2.080806f
C2  g6170_1 gnd 2.080806f
R1 g6170_1 g6170_0 2.224404
.ends

.subckt netx292 x292_1 x292_0 gnd
C1  x292_1 gnd 2.080806f
C2  x292_0 gnd 2.080806f
R1 x292_1 x292_0 2.224404
.ends

.subckt netg6656 g6656_1 g6656_0 gnd
C1  g6656_1 gnd 2.080806f
C2  g6656_0 gnd 2.080806f
R1 g6656_1 g6656_0 2.224404
.ends

.subckt netg7407 g7407_1 g7407_0 gnd
C1  g7407_1 gnd 2.080806f
C2  g7407_0 gnd 2.080806f
R1 g7407_0 g7407_1 2.224404
.ends

.subckt netg4432 g4432_0 g4432_1 gnd
C1  g4432_0 gnd 2.080806f
C2  g4432_1 gnd 2.080806f
R1 g4432_1 g4432_0 2.224404
.ends

.subckt netg4072 g4072_1 g4072_0 gnd
C1  g4072_1 gnd 2.080806f
C2  g4072_0 gnd 2.080806f
R1 g4072_1 g4072_0 2.224404
.ends

.subckt netg2951 g2951_0 g2951_1 gnd
C1  g2951_0 gnd 2.080806f
C2  g2951_1 gnd 2.080806f
R1 g2951_0 g2951_1 2.224404
.ends

.subckt netg4136 g4136_1 g4136_0 gnd
C1  g4136_1 gnd 2.080806f
C2  g4136_0 gnd 2.080806f
R1 g4136_0 g4136_1 2.224404
.ends

.subckt netg4049 g4049_1 g4049_0 gnd
C1  g4049_1 gnd 2.080806f
C2  g4049_0 gnd 2.080806f
R1 g4049_0 g4049_1 2.224404
.ends

.subckt netg3423 g3423_1 g3423_2 gnd
C1  g3423_1 gnd 2.080806f
C2  g3423_2 gnd 2.080806f
R1 g3423_1 g3423_2 2.224404
.ends

.subckt netg4276 g4276_1 g4276_0 gnd
C1  g4276_1 gnd 2.080806f
C2  g4276_0 gnd 2.080806f
R1 g4276_1 g4276_0 2.224404
.ends

.subckt netg3471 g3471_1 g3471_0 gnd
C1  g3471_1 gnd 2.080806f
C2  g3471_0 gnd 2.080806f
R1 g3471_1 g3471_0 2.224404
.ends

.subckt netg5470 g5470_0 g5470_1 gnd
C1  g5470_0 gnd 2.080806f
C2  g5470_1 gnd 2.080806f
R1 g5470_1 g5470_0 2.224404
.ends

.subckt netg3469 g3469_0 g3469_1 gnd
C1  g3469_0 gnd 2.080806f
C2  g3469_1 gnd 2.080806f
R1 g3469_1 g3469_0 2.224404
.ends

.subckt netg4316 g4316_0 g4316_1 gnd
C1  g4316_0 gnd 2.080806f
C2  g4316_1 gnd 2.080806f
R1 g4316_0 g4316_1 2.224404
.ends

.subckt netg6532 g6532_0 g6532_1 gnd
C1  g6532_0 gnd 2.080806f
C2  g6532_1 gnd 2.080806f
R1 g6532_1 g6532_0 2.224404
.ends

.subckt netg2704 g2704_1 g2704_2 gnd
C1  g2704_1 gnd 2.080806f
C2  g2704_2 gnd 2.080806f
R1 g2704_2 g2704_1 2.224404
.ends

.subckt netg6522 g6522_0 g6522_1 gnd
C1  g6522_0 gnd 2.080806f
C2  g6522_1 gnd 2.080806f
R1 g6522_0 g6522_1 2.224404
.ends

.subckt netg7102 g7102_0 g7102_1 gnd
C1  g7102_0 gnd 2.080806f
C2  g7102_1 gnd 2.080806f
R1 g7102_0 g7102_1 2.224404
.ends

.subckt netg6358 g6358_1 g6358_0 gnd
C1  g6358_1 gnd 2.080806f
C2  g6358_0 gnd 2.080806f
R1 g6358_0 g6358_1 2.224404
.ends

.subckt netg6072 g6072_1 g6072_0 gnd
C1  g6072_1 gnd 2.080806f
C2  g6072_0 gnd 2.080806f
R1 g6072_1 g6072_0 2.224404
.ends

.subckt netg6651 g6651_1 g6651_0 gnd
C1  g6651_1 gnd 2.080806f
C2  g6651_0 gnd 2.080806f
R1 g6651_1 g6651_0 2.224404
.ends

.subckt netg3345 g3345_0 g3345_1 gnd
C1  g3345_0 gnd 2.080806f
C2  g3345_1 gnd 2.080806f
R1 g3345_0 g3345_1 2.224404
.ends

.subckt netg6083 g6083_0 g6083_1 gnd
C1  g6083_0 gnd 2.080806f
C2  g6083_1 gnd 2.080806f
R1 g6083_0 g6083_1 2.224404
.ends

.subckt netg4304 g4304_1 g4304_0 gnd
C1  g4304_1 gnd 2.080806f
C2  g4304_0 gnd 2.080806f
R1 g4304_1 g4304_0 2.224404
.ends

.subckt netg4236 g4236_0 g4236_1 gnd
C1  g4236_0 gnd 2.080806f
C2  g4236_1 gnd 2.080806f
R1 g4236_1 g4236_0 2.224404
.ends

.subckt netg3534 g3534_0 g3534_1 gnd
C1  g3534_0 gnd 2.080806f
C2  g3534_1 gnd 2.080806f
R1 g3534_1 g3534_0 2.224404
.ends

.subckt netg4051 g4051_1 g4051_0 gnd
C1  g4051_1 gnd 2.080806f
C2  g4051_0 gnd 2.080806f
R1 g4051_1 g4051_0 2.224404
.ends

.subckt netg4104 g4104_0 g4104_1 gnd
C1  g4104_0 gnd 2.080806f
C2  g4104_1 gnd 2.080806f
R1 g4104_0 g4104_1 2.224404
.ends

.subckt netg7074 g7074_0 g7074_1 gnd
C1  g7074_0 gnd 2.080806f
C2  g7074_1 gnd 2.080806f
R1 g7074_1 g7074_0 2.224404
.ends

.subckt netg6415 g6415_0 g6415_1 gnd
C1  g6415_0 gnd 2.080806f
C2  g6415_1 gnd 2.080806f
R1 g6415_0 g6415_1 2.224404
.ends

.subckt netg3575 g3575_1 g3575_0 gnd
C1  g3575_1 gnd 2.080806f
C2  g3575_0 gnd 2.080806f
R1 g3575_1 g3575_0 2.224404
.ends

.subckt netg5765 g5765_1 g5765_0 gnd
C1  g5765_1 gnd 2.080806f
C2  g5765_0 gnd 2.080806f
R1 g5765_1 g5765_0 2.224404
.ends

.subckt netg7210 g7210_1 g7210_0 gnd
C1  g7210_1 gnd 2.080806f
C2  g7210_0 gnd 2.080806f
R1 g7210_1 g7210_0 2.224404
.ends

.subckt netg6582 g6582_1 g6582_0 gnd
C1  g6582_1 gnd 2.080806f
C2  g6582_0 gnd 2.080806f
R1 g6582_1 g6582_0 2.224404
.ends

.subckt netg4133 g4133_1 g4133_0 gnd
C1  g4133_1 gnd 2.080806f
C2  g4133_0 gnd 2.080806f
R1 g4133_0 g4133_1 2.224404
.ends

.subckt netg7219 g7219_2 g7219_0 gnd
C1  g7219_2 gnd 2.080806f
C2  g7219_0 gnd 2.080806f
R1 g7219_0 g7219_2 2.224404
.ends

.subckt netg6409 g6409_0 g6409_1 gnd
C1  g6409_0 gnd 2.080806f
C2  g6409_1 gnd 2.080806f
R1 g6409_0 g6409_1 2.224404
.ends

.subckt netg7081 g7081_1 g7081_0 gnd
C1  g7081_1 gnd 2.080806f
C2  g7081_0 gnd 2.080806f
R1 g7081_1 g7081_0 2.224404
.ends

.subckt netg5018 g5018_1 g5018_2 gnd
C1  g5018_1 gnd 2.080806f
C2  g5018_2 gnd 2.080806f
R1 g5018_2 g5018_1 2.224404
.ends

.subckt netx482 x482_0 x482_1 gnd
C1  x482_0 gnd 2.080806f
C2  x482_1 gnd 2.080806f
R1 x482_1 x482_0 2.224404
.ends

.subckt netg7123 g7123_1 g7123_0 gnd
C1  g7123_1 gnd 2.080806f
C2  g7123_0 gnd 2.080806f
R1 g7123_0 g7123_1 2.224404
.ends

.subckt netg3063 g3063_1 g3063_0 gnd
C1  g3063_1 gnd 2.080806f
C2  g3063_0 gnd 2.080806f
R1 g3063_0 g3063_1 2.224404
.ends

.subckt netg5667 g5667_0 g5667_1 gnd
C1  g5667_0 gnd 2.080806f
C2  g5667_1 gnd 2.080806f
R1 g5667_1 g5667_0 2.224404
.ends

.subckt netg2820 g2820_0 g2820_1 gnd
C1  g2820_0 gnd 2.080806f
C2  g2820_1 gnd 2.080806f
R1 g2820_0 g2820_1 2.224404
.ends

.subckt netg5466 g5466_0 g5466_1 gnd
C1  g5466_0 gnd 2.080806f
C2  g5466_1 gnd 2.080806f
R1 g5466_1 g5466_0 2.224404
.ends

.subckt netg2634 g2634_1 g2634_0 gnd
C1  g2634_1 gnd 2.080806f
C2  g2634_0 gnd 2.080806f
R1 g2634_1 g2634_0 2.224404
.ends

.subckt netg7127 g7127_0 g7127_1 gnd
C1  g7127_0 gnd 2.080806f
C2  g7127_1 gnd 2.080806f
R1 g7127_0 g7127_1 2.224404
.ends

.subckt netg4209 g4209_1 g4209_0 gnd
C1  g4209_1 gnd 2.080806f
C2  g4209_0 gnd 2.080806f
R1 g4209_0 g4209_1 2.224404
.ends

.subckt netg3898 g3898_1 g3898_0 gnd
C1  g3898_1 gnd 2.080806f
C2  g3898_0 gnd 2.080806f
R1 g3898_0 g3898_1 2.224404
.ends

.subckt netg5991 g5991_1 g5991_0 gnd
C1  g5991_1 gnd 2.080806f
C2  g5991_0 gnd 2.080806f
R1 g5991_0 g5991_1 2.224404
.ends

.subckt netg4277 g4277_1 g4277_0 gnd
C1  g4277_1 gnd 2.080806f
C2  g4277_0 gnd 2.080806f
R1 g4277_0 g4277_1 2.224404
.ends

.subckt netg4019 g4019_0 g4019_1 gnd
C1  g4019_0 gnd 2.080806f
C2  g4019_1 gnd 2.080806f
R1 g4019_1 g4019_0 2.224404
.ends

.subckt netg5525 g5525_1 g5525_0 gnd
C1  g5525_1 gnd 2.080806f
C2  g5525_0 gnd 2.080806f
R1 g5525_0 g5525_1 2.224404
.ends

.subckt netg4059 g4059_0 g4059_1 gnd
C1  g4059_0 gnd 2.080806f
C2  g4059_1 gnd 2.080806f
R1 g4059_0 g4059_1 2.224404
.ends

.subckt netg2765 g2765_0 g2765_1 gnd
C1  g2765_0 gnd 2.080806f
C2  g2765_1 gnd 2.080806f
R1 g2765_0 g2765_1 2.224404
.ends

.subckt netg6926 g6926_1 g6926_0 gnd
C1  g6926_1 gnd 2.080806f
C2  g6926_0 gnd 2.080806f
R1 g6926_0 g6926_1 2.224404
.ends

.subckt netg4038 g4038_1 g4038_0 gnd
C1  g4038_1 gnd 2.080806f
C2  g4038_0 gnd 2.080806f
R1 g4038_0 g4038_1 2.224404
.ends

.subckt netg6536 g6536_0 g6536_1 gnd
C1  g6536_0 gnd 2.080806f
C2  g6536_1 gnd 2.080806f
R1 g6536_0 g6536_1 2.224404
.ends

.subckt netg1509 g1509_1 g1509_0 gnd
C1  g1509_1 gnd 2.080806f
C2  g1509_0 gnd 2.080806f
R1 g1509_1 g1509_0 2.224404
.ends

.subckt netg6055 g6055_0 g6055_1 gnd
C1  g6055_0 gnd 2.080806f
C2  g6055_1 gnd 2.080806f
R1 g6055_1 g6055_0 2.224404
.ends

.subckt netg3492 g3492_0 g3492_1 gnd
C1  g3492_0 gnd 2.080806f
C2  g3492_1 gnd 2.080806f
R1 g3492_1 g3492_0 2.224404
.ends

.subckt netg2915 g2915_1 g2915_0 gnd
C1  g2915_1 gnd 2.080806f
C2  g2915_0 gnd 2.080806f
R1 g2915_0 g2915_1 2.224404
.ends

.subckt netg6115 g6115_1 g6115_0 gnd
C1  g6115_1 gnd 2.080806f
C2  g6115_0 gnd 2.080806f
R1 g6115_0 g6115_1 2.224404
.ends

.subckt netg2830 g2830_1 g2830_0 gnd
C1  g2830_1 gnd 2.080806f
C2  g2830_0 gnd 2.080806f
R1 g2830_1 g2830_0 2.224404
.ends

.subckt netg6211 g6211_1 g6211_0 gnd
C1  g6211_1 gnd 2.080806f
C2  g6211_0 gnd 2.080806f
R1 g6211_0 g6211_1 2.224404
.ends

.subckt netg5428 g5428_1 g5428_0 gnd
C1  g5428_1 gnd 2.080806f
C2  g5428_0 gnd 2.080806f
R1 g5428_0 g5428_1 2.224404
.ends

.subckt netg6165 g6165_1 g6165_0 gnd
C1  g6165_1 gnd 2.080806f
C2  g6165_0 gnd 2.080806f
R1 g6165_0 g6165_1 2.224404
.ends

.subckt netg1477 g1477_1 g1477_0 gnd
C1  g1477_1 gnd 2.080806f
C2  g1477_0 gnd 2.080806f
R1 g1477_0 g1477_1 2.224404
.ends

.subckt netg7211 g7211_1 g7211_0 gnd
C1  g7211_1 gnd 2.080806f
C2  g7211_0 gnd 2.080806f
R1 g7211_0 g7211_1 2.224404
.ends

.subckt netg6316 g6316_0 g6316_1 gnd
C1  g6316_0 gnd 2.080806f
C2  g6316_1 gnd 2.080806f
R1 g6316_0 g6316_1 2.224404
.ends

.subckt netg4052 g4052_1 g4052_0 gnd
C1  g4052_1 gnd 2.080806f
C2  g4052_0 gnd 2.080806f
R1 g4052_0 g4052_1 2.224404
.ends

.subckt netg4176 g4176_0 g4176_1 gnd
C1  g4176_0 gnd 2.080806f
C2  g4176_1 gnd 2.080806f
R1 g4176_0 g4176_1 2.224404
.ends

.subckt netg2225 g2225_0 g2225_1 gnd
C1  g2225_0 gnd 2.080806f
C2  g2225_1 gnd 2.080806f
R1 g2225_1 g2225_0 2.224404
.ends

.subckt netg7241 g7241_1 g7241_0 gnd
C1  g7241_1 gnd 2.080806f
C2  g7241_0 gnd 2.080806f
R1 g7241_0 g7241_1 2.224404
.ends

.subckt netg6185 g6185_0 g6185_1 gnd
C1  g6185_0 gnd 2.080806f
C2  g6185_1 gnd 2.080806f
R1 g6185_1 g6185_0 2.224404
.ends

.subckt netg6718 g6718_0 g6718_1 gnd
C1  g6718_0 gnd 2.080806f
C2  g6718_1 gnd 2.080806f
R1 g6718_0 g6718_1 2.224404
.ends

.subckt netg2504 g2504_0 g2504_2 gnd
C1  g2504_0 gnd 2.080806f
C2  g2504_2 gnd 2.080806f
R1 g2504_2 g2504_0 2.224404
.ends

.subckt netg4071 g4071_0 g4071_1 gnd
C1  g4071_0 gnd 2.080806f
C2  g4071_1 gnd 2.080806f
R1 g4071_1 g4071_0 2.224404
.ends

.subckt netg7101 g7101_0 g7101_1 gnd
C1  g7101_0 gnd 2.080806f
C2  g7101_1 gnd 2.080806f
R1 g7101_0 g7101_1 2.224404
.ends

.subckt netg6935 g6935_0 g6935_1 gnd
C1  g6935_0 gnd 2.080806f
C2  g6935_1 gnd 2.080806f
R1 g6935_0 g6935_1 2.224404
.ends

.subckt netg6875 g6875_0 g6875_1 gnd
C1  g6875_0 gnd 2.080806f
C2  g6875_1 gnd 2.080806f
R1 g6875_1 g6875_0 2.224404
.ends

.subckt netg5972 g5972_0 g5972_1 gnd
C1  g5972_0 gnd 2.080806f
C2  g5972_1 gnd 2.080806f
R1 g5972_0 g5972_1 2.224404
.ends

.subckt netg5142 g5142_1 g5142_0 gnd
C1  g5142_1 gnd 2.080806f
C2  g5142_0 gnd 2.080806f
R1 g5142_1 g5142_0 2.224404
.ends

.subckt netg4333 g4333_0 g4333_1 gnd
C1  g4333_0 gnd 2.080806f
C2  g4333_1 gnd 2.080806f
R1 g4333_1 g4333_0 2.224404
.ends

.subckt netg4128 g4128_0 g4128_1 gnd
C1  g4128_0 gnd 2.080806f
C2  g4128_1 gnd 2.080806f
R1 g4128_1 g4128_0 2.224404
.ends

.subckt netg2534 g2534_2 g2534_1 gnd
C1  g2534_2 gnd 2.080806f
C2  g2534_1 gnd 2.080806f
R1 g2534_1 g2534_2 2.224404
.ends

.subckt netg6245 g6245_0 g6245_1 gnd
C1  g6245_0 gnd 2.080806f
C2  g6245_1 gnd 2.080806f
R1 g6245_1 g6245_0 2.224404
.ends

.subckt netg4418 g4418_1 g4418_0 gnd
C1  g4418_1 gnd 2.080806f
C2  g4418_0 gnd 2.080806f
R1 g4418_0 g4418_1 2.224404
.ends

.subckt netg5619 g5619_2 g5619_1 gnd
C1  g5619_2 gnd 2.080806f
C2  g5619_1 gnd 2.080806f
R1 g5619_2 g5619_1 2.224404
.ends

.subckt netg5794 g5794_1 g5794_0 gnd
C1  g5794_1 gnd 2.080806f
C2  g5794_0 gnd 2.080806f
R1 g5794_1 g5794_0 2.224404
.ends

.subckt netg1923 g1923_1 g1923_0 gnd
C1  g1923_1 gnd 2.080806f
C2  g1923_0 gnd 2.080806f
R1 g1923_0 g1923_1 2.224404
.ends

.subckt netg7263 g7263_0 g7263_1 gnd
C1  g7263_0 gnd 2.080806f
C2  g7263_1 gnd 2.080806f
R1 g7263_1 g7263_0 2.224404
.ends

.subckt netg5279 g5279_1 g5279_0 gnd
C1  g5279_1 gnd 2.080806f
C2  g5279_0 gnd 2.080806f
R1 g5279_1 g5279_0 2.224404
.ends

.subckt netg3913 g3913_0 g3913_1 gnd
C1  g3913_0 gnd 2.080806f
C2  g3913_1 gnd 2.080806f
R1 g3913_1 g3913_0 2.224404
.ends

.subckt netg5740 g5740_0 g5740_2 gnd
C1  g5740_0 gnd 2.080806f
C2  g5740_2 gnd 2.080806f
R1 g5740_2 g5740_0 2.224404
.ends

.subckt netg6171 g6171_0 g6171_1 gnd
C1  g6171_0 gnd 2.080806f
C2  g6171_1 gnd 2.080806f
R1 g6171_0 g6171_1 2.224404
.ends

.subckt netg5430 g5430_0 g5430_1 gnd
C1  g5430_0 gnd 2.080806f
C2  g5430_1 gnd 2.080806f
R1 g5430_0 g5430_1 2.224404
.ends

.subckt netg1393 g1393_1 g1393_0 gnd
C1  g1393_1 gnd 2.080806f
C2  g1393_0 gnd 2.080806f
R1 g1393_1 g1393_0 2.224404
.ends

.subckt netg2359 g2359_2 g2359_1 gnd
C1  g2359_2 gnd 2.080806f
C2  g2359_1 gnd 2.080806f
R1 g2359_1 g2359_2 2.224404
.ends

.subckt netg892 g892_1 g892_2 gnd
C1  g892_1 gnd 2.080806f
C2  g892_2 gnd 2.080806f
R1 g892_2 g892_1 2.224404
.ends

.subckt netg3003 g3003_0 g3003_1 gnd
C1  g3003_0 gnd 2.080806f
C2  g3003_1 gnd 2.080806f
R1 g3003_1 g3003_0 2.224404
.ends

.subckt netg5993 g5993_1 g5993_0 gnd
C1  g5993_1 gnd 2.080806f
C2  g5993_0 gnd 2.080806f
R1 g5993_0 g5993_1 2.224404
.ends

.subckt netg7218 g7218_1 g7218_0 gnd
C1  g7218_1 gnd 2.080806f
C2  g7218_0 gnd 2.080806f
R1 g7218_0 g7218_1 2.224404
.ends

.subckt netg1405 g1405_0 g1405_1 gnd
C1  g1405_0 gnd 2.080806f
C2  g1405_1 gnd 2.080806f
R1 g1405_0 g1405_1 2.224404
.ends

.subckt netg5916 g5916_1 g5916_0 gnd
C1  g5916_1 gnd 2.080806f
C2  g5916_0 gnd 2.080806f
R1 g5916_0 g5916_1 2.224404
.ends

.subckt netg6312 g6312_1 g6312_0 gnd
C1  g6312_1 gnd 2.080806f
C2  g6312_0 gnd 2.080806f
R1 g6312_0 g6312_1 2.224404
.ends

.subckt netg4665 g4665_1 g4665_0 gnd
C1  g4665_1 gnd 2.080806f
C2  g4665_0 gnd 2.080806f
R1 g4665_0 g4665_1 2.224404
.ends

.subckt netg3702 g3702_2 g3702_1 gnd
C1  g3702_2 gnd 2.080806f
C2  g3702_1 gnd 2.080806f
R1 g3702_1 g3702_2 2.224404
.ends

.subckt netg4141 g4141_0 g4141_1 gnd
C1  g4141_0 gnd 2.080806f
C2  g4141_1 gnd 2.080806f
R1 g4141_1 g4141_0 2.224404
.ends

.subckt netg6190 g6190_1 g6190_0 gnd
C1  g6190_1 gnd 2.080806f
C2  g6190_0 gnd 2.080806f
R1 g6190_1 g6190_0 2.224404
.ends

.subckt netg2796 g2796_0 g2796_1 gnd
C1  g2796_0 gnd 2.080806f
C2  g2796_1 gnd 2.080806f
R1 g2796_0 g2796_1 2.224404
.ends

.subckt netg1358 g1358_0 g1358_1 gnd
C1  g1358_0 gnd 2.080806f
C2  g1358_1 gnd 2.080806f
R1 g1358_1 g1358_0 2.224404
.ends

.subckt netg6974 g6974_1 g6974_0 gnd
C1  g6974_1 gnd 2.080806f
C2  g6974_0 gnd 2.080806f
R1 g6974_0 g6974_1 2.224404
.ends

.subckt netg3051 g3051_1 g3051_0 gnd
C1  g3051_1 gnd 2.080806f
C2  g3051_0 gnd 2.080806f
R1 g3051_1 g3051_0 2.224404
.ends

.subckt netg6889 g6889_1 g6889_0 gnd
C1  g6889_1 gnd 2.080806f
C2  g6889_0 gnd 2.080806f
R1 g6889_0 g6889_1 2.224404
.ends

.subckt netg4253 g4253_1 g4253_0 gnd
C1  g4253_1 gnd 2.080806f
C2  g4253_0 gnd 2.080806f
R1 g4253_1 g4253_0 2.224404
.ends

.subckt netg3981 g3981_0 g3981_1 gnd
C1  g3981_0 gnd 2.080806f
C2  g3981_1 gnd 2.080806f
R1 g3981_1 g3981_0 2.224404
.ends

.subckt netg2710 g2710_2 g2710_0 gnd
C1  g2710_2 gnd 2.080806f
C2  g2710_0 gnd 2.080806f
R1 g2710_0 g2710_2 2.224404
.ends

.subckt netg6972 g6972_1 g6972_0 gnd
C1  g6972_1 gnd 2.080806f
C2  g6972_0 gnd 2.080806f
R1 g6972_1 g6972_0 2.224404
.ends

.subckt netg6158 g6158_0 g6158_2 gnd
C1  g6158_0 gnd 2.080806f
C2  g6158_2 gnd 2.080806f
R1 g6158_0 g6158_2 2.224404
.ends

.subckt netg1894 g1894_1 g1894_0 gnd
C1  g1894_1 gnd 2.080806f
C2  g1894_0 gnd 2.080806f
R1 g1894_0 g1894_1 2.224404
.ends

.subckt netg1960 g1960_0 g1960_1 gnd
C1  g1960_0 gnd 2.080806f
C2  g1960_1 gnd 2.080806f
R1 g1960_0 g1960_1 2.224404
.ends

.subckt netg1176 g1176_1 g1176_0 gnd
C1  g1176_1 gnd 2.080806f
C2  g1176_0 gnd 2.080806f
R1 g1176_0 g1176_1 2.224404
.ends

.subckt netg6065 g6065_1 g6065_0 gnd
C1  g6065_1 gnd 2.080806f
C2  g6065_0 gnd 2.080806f
R1 g6065_1 g6065_0 2.224404
.ends

.subckt netg6963 g6963_1 g6963_0 gnd
C1  g6963_1 gnd 2.080806f
C2  g6963_0 gnd 2.080806f
R1 g6963_0 g6963_1 2.224404
.ends

.subckt netg7023 g7023_0 g7023_1 gnd
C1  g7023_0 gnd 2.080806f
C2  g7023_1 gnd 2.080806f
R1 g7023_1 g7023_0 2.224404
.ends

.subckt netx391 x391_0 x391_1 gnd
C1  x391_0 gnd 2.080806f
C2  x391_1 gnd 2.080806f
R1 x391_1 x391_0 2.224404
.ends

.subckt netg2356 g2356_2 g2356_1 gnd
C1  g2356_2 gnd 2.080806f
C2  g2356_1 gnd 2.080806f
R1 g2356_2 g2356_1 2.224404
.ends

.subckt netg1129 g1129_1 g1129_0 gnd
C1  g1129_1 gnd 2.080806f
C2  g1129_0 gnd 2.080806f
R1 g1129_0 g1129_1 2.224404
.ends

.subckt netg6383 g6383_1 g6383_0 gnd
C1  g6383_1 gnd 2.080806f
C2  g6383_0 gnd 2.080806f
R1 g6383_1 g6383_0 2.224404
.ends

.subckt netg2932 g2932_0 g2932_1 gnd
C1  g2932_0 gnd 2.080806f
C2  g2932_1 gnd 2.080806f
R1 g2932_0 g2932_1 2.224404
.ends

.subckt netg7334 g7334_1 g7334_0 gnd
C1  g7334_1 gnd 2.080806f
C2  g7334_0 gnd 2.080806f
R1 g7334_0 g7334_1 2.224404
.ends

.subckt netg6277 g6277_1 g6277_0 gnd
C1  g6277_1 gnd 2.080806f
C2  g6277_0 gnd 2.080806f
R1 g6277_0 g6277_1 2.224404
.ends

.subckt netg3533 g3533_1 g3533_0 gnd
C1  g3533_1 gnd 2.080806f
C2  g3533_0 gnd 2.080806f
R1 g3533_0 g3533_1 2.224404
.ends

.subckt netg5482 g5482_1 g5482_0 gnd
C1  g5482_1 gnd 2.080806f
C2  g5482_0 gnd 2.080806f
R1 g5482_0 g5482_1 2.224404
.ends

.subckt netg3973 g3973_0 g3973_1 gnd
C1  g3973_0 gnd 2.080806f
C2  g3973_1 gnd 2.080806f
R1 g3973_0 g3973_1 2.224404
.ends

.subckt netg7438 g7438_0 g7438_1 gnd
C1  g7438_0 gnd 2.080806f
C2  g7438_1 gnd 2.080806f
R1 g7438_0 g7438_1 2.224404
.ends

.subckt netg6418 g6418_1 g6418_0 gnd
C1  g6418_1 gnd 2.080806f
C2  g6418_0 gnd 2.080806f
R1 g6418_0 g6418_1 2.224404
.ends

.subckt netg7427 g7427_1 g7427_0 gnd
C1  g7427_1 gnd 2.080806f
C2  g7427_0 gnd 2.080806f
R1 g7427_0 g7427_1 2.224404
.ends

.subckt netg7410 g7410_0 g7410_1 gnd
C1  g7410_0 gnd 2.080806f
C2  g7410_1 gnd 2.080806f
R1 g7410_1 g7410_0 2.224404
.ends

.subckt netg4317 g4317_0 g4317_1 gnd
C1  g4317_0 gnd 2.080806f
C2  g4317_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4317_0 1 2.224404
R2 1 g4317_1 2.224404
.ends

.subckt netg3499 g3499_1 g3499_0 gnd
C1  g3499_1 gnd 2.080806f
C2  g3499_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3499_0 2.224404
R2 g3499_1 1 2.224404
.ends

.subckt netg6519 g6519_0 g6519_1 gnd
C1  g6519_0 gnd 2.080806f
C2  g6519_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6519_0 1 2.224404
R2 1 g6519_1 2.224404
.ends

.subckt netg2770 g2770_1 g2770_0 gnd
C1  g2770_1 gnd 2.080806f
C2  g2770_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2770_0 2.224404
R2 g2770_1 1 2.224404
.ends

.subckt netg3896 g3896_1 g3896_0 gnd
C1  g3896_1 gnd 2.080806f
C2  g3896_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3896_0 1 2.224404
R2 1 g3896_1 2.224404
.ends

.subckt netg1385 g1385_1 g1385_0 gnd
C1  g1385_1 gnd 2.080806f
C2  g1385_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1385_0 1 2.224404
R2 g1385_1 1 2.224404
.ends

.subckt netg4175 g4175_1 g4175_0 gnd
C1  g4175_1 gnd 2.080806f
C2  g4175_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4175_0 2.224404
R2 g4175_1 1 2.224404
.ends

.subckt netg7116 g7116_2 g7116_1 g7116_0 gnd
C1  g7116_2 gnd 2.080806f
C2  g7116_1 gnd 2.080806f
C3  g7116_0 gnd 2.080806f
R1 g7116_0 g7116_2 2.224404
R2 g7116_2 g7116_1 2.224404
.ends

.subckt netg3916 g3916_1 g3916_0 gnd
C1  g3916_1 gnd 2.080806f
C2  g3916_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3916_0 2.224404
R2 g3916_1 1 2.224404
.ends

.subckt netg3572 g3572_1 g3572_0 gnd
C1  g3572_1 gnd 2.080806f
C2  g3572_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3572_0 1 2.224404
R2 1 g3572_1 2.224404
.ends

.subckt netg6100 g6100_1 g6100_0 gnd
C1  g6100_1 gnd 2.080806f
C2  g6100_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6100_0 2.224404
R2 g6100_1 1 2.224404
.ends

.subckt netg5361 g5361_1 g5361_0 gnd
C1  g5361_1 gnd 2.080806f
C2  g5361_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5361_0 2.224404
R2 g5361_1 1 2.224404
.ends

.subckt netg5347 g5347_1 g5347_0 gnd
C1  g5347_1 gnd 2.080806f
C2  g5347_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5347_0 1 2.224404
R2 1 g5347_1 2.224404
.ends

.subckt netg2229 g2229_1 g2229_0 gnd
C1  g2229_1 gnd 2.080806f
C2  g2229_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2229_0 1 2.224404
R2 g2229_1 1 2.224404
.ends

.subckt netx452 x452_0 x452_1 gnd
C1  x452_0 gnd 2.080806f
C2  x452_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x452_0 1 2.224404
R2 1 x452_1 2.224404
.ends

.subckt netg6330 g6330_1 g6330_0 gnd
C1  g6330_1 gnd 2.080806f
C2  g6330_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6330_0 2.224404
R2 g6330_1 1 2.224404
.ends

.subckt netg5128 g5128_2 g5128_1 g5128_0 gnd
C1  g5128_2 gnd 2.080806f
C2  g5128_1 gnd 2.080806f
C3  g5128_0 gnd 2.080806f
R1 g5128_0 g5128_1 2.224404
R2 g5128_2 g5128_1 2.224404
.ends

.subckt netg7294 g7294_1 g7294_0 gnd
C1  g7294_1 gnd 2.080806f
C2  g7294_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7294_0 1 2.224404
R2 1 g7294_1 2.224404
.ends

.subckt netg5349 g5349_1 g5349_0 gnd
C1  g5349_1 gnd 2.080806f
C2  g5349_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5349_0 1 2.224404
R2 g5349_1 1 2.224404
.ends

.subckt netg1436 g1436_0 g1436_1 gnd
C1  g1436_0 gnd 2.080806f
C2  g1436_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1436_0 1 2.224404
R2 1 g1436_1 2.224404
.ends

.subckt netg6436 g6436_1 g6436_0 gnd
C1  g6436_1 gnd 2.080806f
C2  g6436_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6436_0 1 2.224404
R2 1 g6436_1 2.224404
.ends

.subckt netg3117 g3117_0 g3117_1 g3117_2 gnd
C1  g3117_0 gnd 2.080806f
C2  g3117_1 gnd 2.080806f
C3  g3117_2 gnd 2.080806f
R1 g3117_0 g3117_1 2.224404
R2 g3117_2 g3117_1 2.224404
.ends

.subckt netg6513 g6513_1 g6513_0 gnd
C1  g6513_1 gnd 2.080806f
C2  g6513_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6513_0 1 2.224404
R2 1 g6513_1 2.224404
.ends

.subckt netg5483 g5483_0 g5483_1 gnd
C1  g5483_0 gnd 2.080806f
C2  g5483_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5483_0 1 2.224404
R2 1 g5483_1 2.224404
.ends

.subckt netg6604 g6604_1 g6604_0 gnd
C1  g6604_1 gnd 2.080806f
C2  g6604_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6604_0 2.224404
R2 1 g6604_1 2.224404
.ends

.subckt netg7217 g7217_1 g7217_0 gnd
C1  g7217_1 gnd 2.080806f
C2  g7217_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7217_0 1 2.224404
R2 1 g7217_1 2.224404
.ends

.subckt netg3413 g3413_0 g3413_1 gnd
C1  g3413_0 gnd 2.080806f
C2  g3413_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3413_0 1 2.224404
R2 1 g3413_1 2.224404
.ends

.subckt netg5320 g5320_1 g5320_0 gnd
C1  g5320_1 gnd 2.080806f
C2  g5320_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5320_0 1 2.224404
R2 1 g5320_1 2.224404
.ends

.subckt netg6173 g6173_1 g6173_0 gnd
C1  g6173_1 gnd 2.080806f
C2  g6173_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6173_0 2.224404
R2 g6173_1 1 2.224404
.ends

.subckt netg4354 g4354_0 g4354_1 gnd
C1  g4354_0 gnd 2.080806f
C2  g4354_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4354_0 2.224404
R2 g4354_1 1 2.224404
.ends

.subckt netg5786 g5786_1 g5786_0 gnd
C1  g5786_1 gnd 2.080806f
C2  g5786_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5786_0 2.224404
R2 g5786_1 1 2.224404
.ends

.subckt netg1453 g1453_1 g1453_0 gnd
C1  g1453_1 gnd 2.080806f
C2  g1453_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1453_0 1 2.224404
R2 1 g1453_1 2.224404
.ends

.subckt netg6736 g6736_0 g6736_1 gnd
C1  g6736_0 gnd 2.080806f
C2  g6736_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6736_0 2.224404
R2 g6736_1 1 2.224404
.ends

.subckt netg7103 g7103_0 g7103_1 gnd
C1  g7103_0 gnd 2.080806f
C2  g7103_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7103_0 1 2.224404
R2 1 g7103_1 2.224404
.ends

.subckt netg4438 g4438_0 g4438_1 gnd
C1  g4438_0 gnd 2.080806f
C2  g4438_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4438_0 1 2.224404
R2 g4438_1 1 2.224404
.ends

.subckt netg3977 g3977_1 g3977_0 gnd
C1  g3977_1 gnd 2.080806f
C2  g3977_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3977_0 1 2.224404
R2 1 g3977_1 2.224404
.ends

.subckt netg6329 g6329_0 g6329_1 gnd
C1  g6329_0 gnd 2.080806f
C2  g6329_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6329_0 1 2.224404
R2 g6329_1 1 2.224404
.ends

.subckt netg3324 g3324_1 g3324_2 g3324_0 gnd
C1  g3324_1 gnd 2.080806f
C2  g3324_2 gnd 2.080806f
C3  g3324_0 gnd 2.080806f
R1 g3324_1 g3324_0 2.224404
R2 g3324_2 g3324_1 2.224404
.ends

.subckt netg6805 g6805_0 g6805_1 g6805_2 gnd
C1  g6805_0 gnd 2.080806f
C2  g6805_1 gnd 2.080806f
C3  g6805_2 gnd 2.080806f
R1 g6805_2 g6805_0 2.224404
R2 g6805_1 g6805_2 2.224404
.ends

.subckt netg6823 g6823_1 g6823_0 gnd
C1  g6823_1 gnd 2.080806f
C2  g6823_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6823_0 1 2.224404
R2 1 g6823_1 2.224404
.ends

.subckt netg4244 g4244_1 g4244_0 gnd
C1  g4244_1 gnd 2.080806f
C2  g4244_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4244_0 1 2.224404
R2 1 g4244_1 2.224404
.ends

.subckt netg1490 g1490_1 g1490_0 gnd
C1  g1490_1 gnd 2.080806f
C2  g1490_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1490_0 1 2.224404
R2 1 g1490_1 2.224404
.ends

.subckt netg5328 g5328_0 g5328_1 gnd
C1  g5328_0 gnd 2.080806f
C2  g5328_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5328_0 1 2.224404
R2 1 g5328_1 2.224404
.ends

.subckt netg2543 g2543_0 g2543_1 g2543_2 gnd
C1  g2543_0 gnd 2.080806f
C2  g2543_1 gnd 2.080806f
C3  g2543_2 gnd 2.080806f
R1 g2543_0 g2543_2 2.224404
R2 g2543_2 g2543_1 2.224404
.ends

.subckt netg6255 g6255_1 g6255_0 g6255_2 gnd
C1  g6255_1 gnd 2.080806f
C2  g6255_0 gnd 2.080806f
C3  g6255_2 gnd 2.080806f
R1 g6255_0 g6255_2 2.224404
R2 g6255_1 g6255_2 2.224404
.ends

.subckt netg6195 g6195_1 g6195_0 gnd
C1  g6195_1 gnd 2.080806f
C2  g6195_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6195_0 2.224404
R2 1 g6195_1 2.224404
.ends

.subckt netg3481 g3481_0 g3481_1 gnd
C1  g3481_0 gnd 2.080806f
C2  g3481_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3481_0 1 2.224404
R2 g3481_1 1 2.224404
.ends

.subckt netg5970 g5970_1 g5970_0 gnd
C1  g5970_1 gnd 2.080806f
C2  g5970_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5970_0 1 2.224404
R2 1 g5970_1 2.224404
.ends

.subckt netg6033 g6033_1 g6033_0 gnd
C1  g6033_1 gnd 2.080806f
C2  g6033_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6033_0 1 2.224404
R2 1 g6033_1 2.224404
.ends

.subckt netg5030 g5030_2 g5030_1 g5030_0 gnd
C1  g5030_2 gnd 2.080806f
C2  g5030_1 gnd 2.080806f
C3  g5030_0 gnd 2.080806f
R1 g5030_1 g5030_0 2.224404
R2 g5030_0 g5030_2 2.224404
.ends

.subckt netg5167 g5167_2 g5167_0 gnd
C1  g5167_2 gnd 2.080806f
C2  g5167_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5167_0 2.224404
R2 g5167_2 1 2.224404
.ends

.subckt netg6903 g6903_1 g6903_0 gnd
C1  g6903_1 gnd 2.080806f
C2  g6903_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6903_0 1 2.224404
R2 1 g6903_1 2.224404
.ends

.subckt netg4273 g4273_0 g4273_1 gnd
C1  g4273_0 gnd 2.080806f
C2  g4273_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4273_0 1 2.224404
R2 1 g4273_1 2.224404
.ends

.subckt netg6037 g6037_0 g6037_1 gnd
C1  g6037_0 gnd 2.080806f
C2  g6037_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6037_0 2.224404
R2 g6037_1 1 2.224404
.ends

.subckt netg6659 g6659_0 g6659_1 gnd
C1  g6659_0 gnd 2.080806f
C2  g6659_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6659_0 1 2.224404
R2 1 g6659_1 2.224404
.ends

.subckt netg4629 g4629_1 g4629_0 gnd
C1  g4629_1 gnd 2.080806f
C2  g4629_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4629_0 2.224404
R2 1 g4629_1 2.224404
.ends

.subckt netg7342 g7342_1 g7342_0 gnd
C1  g7342_1 gnd 2.080806f
C2  g7342_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7342_0 1 2.224404
R2 1 g7342_1 2.224404
.ends

.subckt netg1225 g1225_0 g1225_1 gnd
C1  g1225_0 gnd 2.080806f
C2  g1225_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1225_0 2.224404
R2 g1225_1 1 2.224404
.ends

.subckt netg5583 g5583_0 g5583_1 gnd
C1  g5583_0 gnd 2.080806f
C2  g5583_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5583_0 2.224404
R2 1 g5583_1 2.224404
.ends

.subckt netg1045 g1045_0 g1045_2 gnd
C1  g1045_0 gnd 2.080806f
C2  g1045_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1045_0 1 2.224404
R2 1 g1045_2 2.224404
.ends

.subckt netg6725 g6725_2 g6725_0 gnd
C1  g6725_2 gnd 2.080806f
C2  g6725_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6725_0 1 2.224404
R2 1 g6725_2 2.224404
.ends

.subckt netg6886 g6886_0 g6886_1 gnd
C1  g6886_0 gnd 2.080806f
C2  g6886_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6886_0 2.224404
R2 g6886_1 1 2.224404
.ends

.subckt netg7020 g7020_0 g7020_1 gnd
C1  g7020_0 gnd 2.080806f
C2  g7020_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7020_0 2.224404
R2 g7020_1 1 2.224404
.ends

.subckt netg6634 g6634_2 g6634_1 g6634_0 gnd
C1  g6634_2 gnd 2.080806f
C2  g6634_1 gnd 2.080806f
C3  g6634_0 gnd 2.080806f
R1 g6634_0 g6634_1 2.224404
R2 g6634_0 g6634_2 2.224404
.ends

.subckt netg4227 g4227_1 g4227_0 gnd
C1  g4227_1 gnd 2.080806f
C2  g4227_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4227_0 2.224404
R2 g4227_1 1 2.224404
.ends

.subckt netg1039 g1039_1 g1039_2 gnd
C1  g1039_1 gnd 2.080806f
C2  g1039_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1039_1 1 2.224404
R2 1 g1039_2 2.224404
.ends

.subckt netg1166 g1166_0 g1166_1 gnd
C1  g1166_0 gnd 2.080806f
C2  g1166_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1166_0 1 2.224404
R2 1 g1166_1 2.224404
.ends

.subckt netg2513 g2513_1 g2513_2 g2513_0 gnd
C1  g2513_1 gnd 2.080806f
C2  g2513_2 gnd 2.080806f
C3  g2513_0 gnd 2.080806f
R1 g2513_1 g2513_0 2.224404
R2 g2513_2 g2513_1 2.224404
.ends

.subckt netg566 g566_0 g566_1 gnd
C1  g566_0 gnd 2.080806f
C2  g566_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g566_0 1 2.224404
R2 1 g566_1 2.224404
.ends

.subckt netg5963 g5963_1 g5963_0 gnd
C1  g5963_1 gnd 2.080806f
C2  g5963_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5963_0 1 2.224404
R2 1 g5963_1 2.224404
.ends

.subckt netg2519 g2519_1 g2519_2 gnd
C1  g2519_1 gnd 2.080806f
C2  g2519_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2519_2 1 2.224404
R2 g2519_1 1 2.224404
.ends

.subckt netg6538 g6538_1 g6538_0 gnd
C1  g6538_1 gnd 2.080806f
C2  g6538_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6538_0 1 2.224404
R2 1 g6538_1 2.224404
.ends

.subckt netg7350 g7350_1 g7350_0 gnd
C1  g7350_1 gnd 2.080806f
C2  g7350_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7350_0 1 2.224404
R2 g7350_1 1 2.224404
.ends

.subckt netg6043 g6043_1 g6043_0 gnd
C1  g6043_1 gnd 2.080806f
C2  g6043_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6043_0 2.224404
R2 1 g6043_1 2.224404
.ends

.subckt netg1305 g1305_0 g1305_1 gnd
C1  g1305_0 gnd 2.080806f
C2  g1305_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1305_0 2.224404
R2 g1305_1 1 2.224404
.ends

.subckt netg7209 g7209_0 g7209_1 gnd
C1  g7209_0 gnd 2.080806f
C2  g7209_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7209_0 2.224404
R2 1 g7209_1 2.224404
.ends

.subckt netg5691 g5691_0 g5691_2 gnd
C1  g5691_0 gnd 2.080806f
C2  g5691_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5691_0 1 2.224404
R2 1 g5691_2 2.224404
.ends

.subckt netg7068 g7068_1 g7068_0 g7068_2 gnd
C1  g7068_1 gnd 2.080806f
C2  g7068_0 gnd 2.080806f
C3  g7068_2 gnd 2.080806f
R1 g7068_1 g7068_0 2.224404
R2 g7068_0 g7068_2 2.224404
.ends

.subckt netg3478 g3478_1 g3478_0 gnd
C1  g3478_1 gnd 2.080806f
C2  g3478_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3478_0 2.224404
R2 g3478_1 1 2.224404
.ends

.subckt netg1130 g1130_1 g1130_0 gnd
C1  g1130_1 gnd 2.080806f
C2  g1130_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1130_0 2.224404
R2 g1130_1 1 2.224404
.ends

.subckt netg6053 g6053_0 g6053_1 gnd
C1  g6053_0 gnd 2.080806f
C2  g6053_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6053_0 1 2.224404
R2 1 g6053_1 2.224404
.ends

.subckt netg6328 g6328_1 g6328_0 gnd
C1  g6328_1 gnd 2.080806f
C2  g6328_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6328_0 1 2.224404
R2 1 g6328_1 2.224404
.ends

.subckt netg1475 g1475_0 g1475_1 gnd
C1  g1475_0 gnd 2.080806f
C2  g1475_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1475_0 2.224404
R2 g1475_1 1 2.224404
.ends

.subckt netg4437 g4437_1 g4437_0 gnd
C1  g4437_1 gnd 2.080806f
C2  g4437_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4437_0 2.224404
R2 g4437_1 1 2.224404
.ends

.subckt netg4241 g4241_1 g4241_0 gnd
C1  g4241_1 gnd 2.080806f
C2  g4241_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4241_0 1 2.224404
R2 g4241_1 1 2.224404
.ends

.subckt netg6921 g6921_1 g6921_2 g6921_0 gnd
C1  g6921_1 gnd 2.080806f
C2  g6921_2 gnd 2.080806f
C3  g6921_0 gnd 2.080806f
R1 g6921_1 g6921_0 2.224404
R2 g6921_2 g6921_1 2.224404
.ends

.subckt netg1384 g1384_1 g1384_0 gnd
C1  g1384_1 gnd 2.080806f
C2  g1384_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1384_0 1 2.224404
R2 1 g1384_1 2.224404
.ends

.subckt netg5355 g5355_0 g5355_1 gnd
C1  g5355_0 gnd 2.080806f
C2  g5355_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5355_0 2.224404
R2 g5355_1 1 2.224404
.ends

.subckt netg5488 g5488_1 g5488_0 gnd
C1  g5488_1 gnd 2.080806f
C2  g5488_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5488_0 2.224404
R2 g5488_1 1 2.224404
.ends

.subckt netx422 x422_1 x422_0 gnd
C1  x422_1 gnd 2.080806f
C2  x422_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x422_0 2.224404
R2 x422_1 1 2.224404
.ends

.subckt netg4938 g4938_0 g4938_1 gnd
C1  g4938_0 gnd 2.080806f
C2  g4938_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4938_0 1 2.224404
R2 1 g4938_1 2.224404
.ends

.subckt netg3495 g3495_0 g3495_1 gnd
C1  g3495_0 gnd 2.080806f
C2  g3495_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3495_0 2.224404
R2 g3495_1 1 2.224404
.ends

.subckt netg6001 g6001_0 g6001_1 gnd
C1  g6001_0 gnd 2.080806f
C2  g6001_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6001_0 1 2.224404
R2 1 g6001_1 2.224404
.ends

.subckt netg4279 g4279_0 g4279_1 gnd
C1  g4279_0 gnd 2.080806f
C2  g4279_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4279_0 2.224404
R2 g4279_1 1 2.224404
.ends

.subckt netg6622 g6622_1 g6622_0 gnd
C1  g6622_1 gnd 2.080806f
C2  g6622_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6622_0 2.224404
R2 g6622_1 1 2.224404
.ends

.subckt netg922 g922_2 g922_0 gnd
C1  g922_2 gnd 2.080806f
C2  g922_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g922_0 1 2.224404
R2 1 g922_2 2.224404
.ends

.subckt netx381 x381_1 x381_0 gnd
C1  x381_1 gnd 2.080806f
C2  x381_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x381_0 1 2.224404
R2 1 x381_1 2.224404
.ends

.subckt netg6948 g6948_1 g6948_2 gnd
C1  g6948_1 gnd 2.080806f
C2  g6948_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6948_2 2.224404
R2 g6948_1 1 2.224404
.ends

.subckt netx361 x361_0 x361_1 gnd
C1  x361_0 gnd 2.080806f
C2  x361_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x361_0 2.224404
R2 x361_1 1 2.224404
.ends

.subckt netg5424 g5424_0 g5424_1 gnd
C1  g5424_0 gnd 2.080806f
C2  g5424_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5424_0 1 2.224404
R2 1 g5424_1 2.224404
.ends

.subckt netg4056 g4056_1 g4056_0 gnd
C1  g4056_1 gnd 2.080806f
C2  g4056_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4056_0 1 2.224404
R2 1 g4056_1 2.224404
.ends

.subckt netg2828 g2828_0 g2828_1 gnd
C1  g2828_0 gnd 2.080806f
C2  g2828_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2828_0 2.224404
R2 g2828_1 1 2.224404
.ends

.subckt netg1000 g1000_1 g1000_2 gnd
C1  g1000_1 gnd 2.080806f
C2  g1000_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1000_1 1 2.224404
R2 g1000_2 1 2.224404
.ends

.subckt netg5059 g5059_2 g5059_0 g5059_1 gnd
C1  g5059_2 gnd 2.080806f
C2  g5059_0 gnd 2.080806f
C3  g5059_1 gnd 2.080806f
R1 g5059_0 g5059_1 2.224404
R2 g5059_1 g5059_2 2.224404
.ends

.subckt netg6168 g6168_1 g6168_0 gnd
C1  g6168_1 gnd 2.080806f
C2  g6168_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6168_0 1 2.224404
R2 1 g6168_1 2.224404
.ends

.subckt netg4331 g4331_0 g4331_1 gnd
C1  g4331_0 gnd 2.080806f
C2  g4331_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4331_0 2.224404
R2 1 g4331_1 2.224404
.ends

.subckt netg6484 g6484_0 g6484_1 g6484_2 gnd
C1  g6484_0 gnd 2.080806f
C2  g6484_1 gnd 2.080806f
C3  g6484_2 gnd 2.080806f
R1 g6484_0 g6484_2 2.224404
R2 g6484_2 g6484_1 2.224404
.ends

.subckt netg3488 g3488_1 g3488_0 gnd
C1  g3488_1 gnd 2.080806f
C2  g3488_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3488_0 2.224404
R2 g3488_1 1 2.224404
.ends

.subckt netg1390 g1390_2 g1390_0 g1390_1 gnd
C1  g1390_2 gnd 2.080806f
C2  g1390_0 gnd 2.080806f
C3  g1390_1 gnd 2.080806f
R1 g1390_0 g1390_1 2.224404
R2 g1390_1 g1390_2 2.224404
.ends

.subckt netg3456 g3456_1 g3456_2 g3456_0 gnd
C1  g3456_1 gnd 2.080806f
C2  g3456_2 gnd 2.080806f
C3  g3456_0 gnd 2.080806f
R1 g3456_1 g3456_0 2.224404
R2 g3456_2 g3456_1 2.224404
.ends

.subckt netg5429 g5429_0 g5429_1 gnd
C1  g5429_0 gnd 2.080806f
C2  g5429_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5429_0 1 2.224404
R2 1 g5429_1 2.224404
.ends

.subckt netg1386 g1386_0 g1386_1 gnd
C1  g1386_0 gnd 2.080806f
C2  g1386_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1386_0 2.224404
R2 g1386_1 1 2.224404
.ends

.subckt netg6220 g6220_0 g6220_2 gnd
C1  g6220_0 gnd 2.080806f
C2  g6220_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6220_0 1 2.224404
R2 g6220_2 1 2.224404
.ends

.subckt netg3288 g3288_2 g3288_1 gnd
C1  g3288_2 gnd 2.080806f
C2  g3288_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3288_2 1 2.224404
R2 g3288_1 1 2.224404
.ends

.subckt netg6533 g6533_1 g6533_0 gnd
C1  g6533_1 gnd 2.080806f
C2  g6533_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6533_0 2.224404
R2 g6533_1 1 2.224404
.ends

.subckt netg5113 g5113_1 g5113_0 gnd
C1  g5113_1 gnd 2.080806f
C2  g5113_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5113_0 2.224404
R2 1 g5113_1 2.224404
.ends

.subckt netg2949 g2949_0 g2949_1 gnd
C1  g2949_0 gnd 2.080806f
C2  g2949_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2949_0 1 2.224404
R2 1 g2949_1 2.224404
.ends

.subckt netg6489 g6489_0 g6489_1 gnd
C1  g6489_0 gnd 2.080806f
C2  g6489_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6489_0 1 2.224404
R2 1 g6489_1 2.224404
.ends

.subckt netg6655 g6655_1 g6655_0 gnd
C1  g6655_1 gnd 2.080806f
C2  g6655_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6655_0 2.224404
R2 g6655_1 1 2.224404
.ends

.subckt netg3099 g3099_1 g3099_0 gnd
C1  g3099_1 gnd 2.080806f
C2  g3099_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3099_0 1 2.224404
R2 1 g3099_1 2.224404
.ends

.subckt netg7383 g7383_1 g7383_0 gnd
C1  g7383_1 gnd 2.080806f
C2  g7383_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7383_0 1 2.224404
R2 1 g7383_1 2.224404
.ends

.subckt netg7208 g7208_0 g7208_1 gnd
C1  g7208_0 gnd 2.080806f
C2  g7208_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7208_0 1 2.224404
R2 1 g7208_1 2.224404
.ends

.subckt netg3000 g3000_1 g3000_0 gnd
C1  g3000_1 gnd 2.080806f
C2  g3000_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3000_0 1 2.224404
R2 g3000_1 1 2.224404
.ends

.subckt netg6089 g6089_0 g6089_1 gnd
C1  g6089_0 gnd 2.080806f
C2  g6089_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6089_0 1 2.224404
R2 1 g6089_1 2.224404
.ends

.subckt netg4293 g4293_1 g4293_0 gnd
C1  g4293_1 gnd 2.080806f
C2  g4293_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4293_0 2.224404
R2 g4293_1 1 2.224404
.ends

.subckt netg6918 g6918_0 g6918_1 gnd
C1  g6918_0 gnd 2.080806f
C2  g6918_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6918_0 1 2.224404
R2 1 g6918_1 2.224404
.ends

.subckt netg7388 g7388_1 g7388_0 gnd
C1  g7388_1 gnd 2.080806f
C2  g7388_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7388_0 2.224404
R2 g7388_1 1 2.224404
.ends

.subckt netg4069 g4069_0 g4069_1 gnd
C1  g4069_0 gnd 2.080806f
C2  g4069_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4069_0 1 2.224404
R2 1 g4069_1 2.224404
.ends

.subckt netx101 x101_1 x101_0 gnd
C1  x101_1 gnd 2.080806f
C2  x101_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x101_0 2.224404
R2 x101_1 1 2.224404
.ends

.subckt netg6119 g6119_0 g6119_1 gnd
C1  g6119_0 gnd 2.080806f
C2  g6119_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6119_0 1 2.224404
R2 g6119_1 1 2.224404
.ends

.subckt netg5267 g5267_1 g5267_0 gnd
C1  g5267_1 gnd 2.080806f
C2  g5267_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5267_0 1 2.224404
R2 1 g5267_1 2.224404
.ends

.subckt netg2576 g2576_2 g2576_0 g2576_1 gnd
C1  g2576_2 gnd 2.080806f
C2  g2576_0 gnd 2.080806f
C3  g2576_1 gnd 2.080806f
R1 g2576_1 g2576_0 2.224404
R2 g2576_0 g2576_2 2.224404
.ends

.subckt netg6660 g6660_0 g6660_1 gnd
C1  g6660_0 gnd 2.080806f
C2  g6660_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6660_0 1 2.224404
R2 1 g6660_1 2.224404
.ends

.subckt netg4442 g4442_1 g4442_0 gnd
C1  g4442_1 gnd 2.080806f
C2  g4442_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4442_0 2.224404
R2 g4442_1 1 2.224404
.ends

.subckt netg6266 g6266_2 g6266_0 g6266_1 gnd
C1  g6266_2 gnd 2.080806f
C2  g6266_0 gnd 2.080806f
C3  g6266_1 gnd 2.080806f
R1 g6266_0 g6266_1 2.224404
R2 g6266_1 g6266_2 2.224404
.ends

.subckt netg2740 g2740_2 g2740_0 g2740_1 gnd
C1  g2740_2 gnd 2.080806f
C2  g2740_0 gnd 2.080806f
C3  g2740_1 gnd 2.080806f
R1 g2740_0 g2740_1 2.224404
R2 g2740_2 g2740_0 2.224404
.ends

.subckt netg7165 g7165_0 g7165_1 gnd
C1  g7165_0 gnd 2.080806f
C2  g7165_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7165_0 2.224404
R2 g7165_1 1 2.224404
.ends

.subckt netg2492 g2492_2 g2492_1 gnd
C1  g2492_2 gnd 2.080806f
C2  g2492_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2492_2 2.224404
R2 g2492_1 1 2.224404
.ends

.subckt netg7406 g7406_1 g7406_0 gnd
C1  g7406_1 gnd 2.080806f
C2  g7406_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7406_0 1 2.224404
R2 1 g7406_1 2.224404
.ends

.subckt netg6901 g6901_0 g6901_1 gnd
C1  g6901_0 gnd 2.080806f
C2  g6901_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6901_0 1 2.224404
R2 1 g6901_1 2.224404
.ends

.subckt netg5444 g5444_0 g5444_1 gnd
C1  g5444_0 gnd 2.080806f
C2  g5444_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5444_0 1 2.224404
R2 1 g5444_1 2.224404
.ends

.subckt netg3544 g3544_0 g3544_1 gnd
C1  g3544_0 gnd 2.080806f
C2  g3544_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3544_0 2.224404
R2 g3544_1 1 2.224404
.ends

.subckt netg5050 g5050_1 g5050_0 g5050_2 gnd
C1  g5050_1 gnd 2.080806f
C2  g5050_0 gnd 2.080806f
C3  g5050_2 gnd 2.080806f
R1 g5050_0 g5050_1 2.224404
R2 g5050_1 g5050_2 2.224404
.ends

.subckt netg7206 g7206_1 g7206_0 gnd
C1  g7206_1 gnd 2.080806f
C2  g7206_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7206_0 2.224404
R2 g7206_1 1 2.224404
.ends

.subckt netg2838 g2838_1 g2838_0 gnd
C1  g2838_1 gnd 2.080806f
C2  g2838_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2838_0 2.224404
R2 g2838_1 1 2.224404
.ends

.subckt netg1223 g1223_1 g1223_0 gnd
C1  g1223_1 gnd 2.080806f
C2  g1223_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1223_0 2.224404
R2 g1223_1 1 2.224404
.ends

.subckt netg1557 g1557_1 g1557_0 gnd
C1  g1557_1 gnd 2.080806f
C2  g1557_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1557_0 2.224404
R2 g1557_1 1 2.224404
.ends

.subckt netg6790 g6790_2 g6790_1 g6790_0 gnd
C1  g6790_2 gnd 2.080806f
C2  g6790_1 gnd 2.080806f
C3  g6790_0 gnd 2.080806f
R1 g6790_1 g6790_0 2.224404
R2 g6790_2 g6790_1 2.224404
.ends

.subckt netg4204 g4204_0 g4204_1 gnd
C1  g4204_0 gnd 2.080806f
C2  g4204_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4204_0 1 2.224404
R2 g4204_1 1 2.224404
.ends

.subckt netg6048 g6048_1 g6048_0 gnd
C1  g6048_1 gnd 2.080806f
C2  g6048_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6048_0 1 2.224404
R2 g6048_1 1 2.224404
.ends

.subckt netg6613 g6613_1 g6613_0 gnd
C1  g6613_1 gnd 2.080806f
C2  g6613_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6613_0 1 2.224404
R2 1 g6613_1 2.224404
.ends

.subckt netg5357 g5357_0 g5357_1 gnd
C1  g5357_0 gnd 2.080806f
C2  g5357_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5357_0 2.224404
R2 g5357_1 1 2.224404
.ends

.subckt netg2483 g2483_2 g2483_1 gnd
C1  g2483_2 gnd 2.080806f
C2  g2483_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2483_2 1 2.224404
R2 1 g2483_1 2.224404
.ends

.subckt netg4275 g4275_0 g4275_1 gnd
C1  g4275_0 gnd 2.080806f
C2  g4275_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4275_0 1 2.224404
R2 g4275_1 1 2.224404
.ends

.subckt netg979 g979_0 g979_1 g979_2 gnd
C1  g979_0 gnd 2.080806f
C2  g979_1 gnd 2.080806f
C3  g979_2 gnd 2.080806f
R1 g979_0 g979_1 2.224404
R2 g979_1 g979_2 2.224404
.ends

.subckt netg4228 g4228_1 g4228_0 gnd
C1  g4228_1 gnd 2.080806f
C2  g4228_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4228_0 1 2.224404
R2 1 g4228_1 2.224404
.ends

.subckt netg3531 g3531_0 g3531_1 gnd
C1  g3531_0 gnd 2.080806f
C2  g3531_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3531_0 2.224404
R2 1 g3531_1 2.224404
.ends

.subckt netg5024 g5024_2 g5024_0 gnd
C1  g5024_2 gnd 2.080806f
C2  g5024_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5024_0 2.224404
R2 g5024_2 1 2.224404
.ends

.subckt netg4450 g4450_0 g4450_1 gnd
C1  g4450_0 gnd 2.080806f
C2  g4450_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4450_0 2.224404
R2 g4450_1 1 2.224404
.ends

.subckt netg2759 g2759_1 g2759_0 gnd
C1  g2759_1 gnd 2.080806f
C2  g2759_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2759_0 1 2.224404
R2 1 g2759_1 2.224404
.ends

.subckt netg5885 g5885_0 g5885_1 gnd
C1  g5885_0 gnd 2.080806f
C2  g5885_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5885_0 2.224404
R2 g5885_1 1 2.224404
.ends

.subckt netg3062 g3062_1 g3062_0 gnd
C1  g3062_1 gnd 2.080806f
C2  g3062_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3062_0 2.224404
R2 g3062_1 1 2.224404
.ends

.subckt netg6381 g6381_0 g6381_1 gnd
C1  g6381_0 gnd 2.080806f
C2  g6381_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6381_0 2.224404
R2 g6381_1 1 2.224404
.ends

.subckt netg7349 g7349_1 g7349_0 gnd
C1  g7349_1 gnd 2.080806f
C2  g7349_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7349_0 1 2.224404
R2 1 g7349_1 2.224404
.ends

.subckt netg6511 g6511_0 g6511_1 gnd
C1  g6511_0 gnd 2.080806f
C2  g6511_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6511_0 1 2.224404
R2 1 g6511_1 2.224404
.ends

.subckt netg4976 g4976_2 g4976_1 g4976_0 gnd
C1  g4976_2 gnd 2.080806f
C2  g4976_1 gnd 2.080806f
C3  g4976_0 gnd 2.080806f
R1 g4976_1 g4976_0 2.224404
R2 g4976_2 g4976_1 2.224404
.ends

.subckt netg4007 g4007_1 g4007_0 gnd
C1  g4007_1 gnd 2.080806f
C2  g4007_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4007_0 1 2.224404
R2 1 g4007_1 2.224404
.ends

.subckt netx421 x421_1 x421_0 gnd
C1  x421_1 gnd 2.080806f
C2  x421_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x421_0 1 2.224404
R2 1 x421_1 2.224404
.ends

.subckt netg5325 g5325_1 g5325_0 gnd
C1  g5325_1 gnd 2.080806f
C2  g5325_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5325_0 2.224404
R2 g5325_1 1 2.224404
.ends

.subckt netg6433 g6433_2 g6433_0 g6433_1 gnd
C1  g6433_2 gnd 2.080806f
C2  g6433_0 gnd 2.080806f
C3  g6433_1 gnd 2.080806f
R1 g6433_0 g6433_1 2.224404
R2 g6433_1 g6433_2 2.224404
.ends

.subckt netg7079 g7079_1 g7079_0 gnd
C1  g7079_1 gnd 2.080806f
C2  g7079_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7079_0 2.224404
R2 g7079_1 1 2.224404
.ends

.subckt netg6692 g6692_0 g6692_1 gnd
C1  g6692_0 gnd 2.080806f
C2  g6692_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6692_0 1 2.224404
R2 1 g6692_1 2.224404
.ends

.subckt netg3102 g3102_1 g3102_0 gnd
C1  g3102_1 gnd 2.080806f
C2  g3102_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3102_0 1 2.224404
R2 1 g3102_1 2.224404
.ends

.subckt netg1161 g1161_0 g1161_1 gnd
C1  g1161_0 gnd 2.080806f
C2  g1161_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1161_0 2.224404
R2 g1161_1 1 2.224404
.ends

.subckt netg6462 g6462_1 g6462_0 gnd
C1  g6462_1 gnd 2.080806f
C2  g6462_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6462_0 2.224404
R2 g6462_1 1 2.224404
.ends

.subckt netg970 g970_0 g970_1 g970_2 gnd
C1  g970_0 gnd 2.080806f
C2  g970_1 gnd 2.080806f
C3  g970_2 gnd 2.080806f
R1 g970_2 g970_0 2.224404
R2 g970_1 g970_2 2.224404
.ends

.subckt netg5245 g5245_0 g5245_1 gnd
C1  g5245_0 gnd 2.080806f
C2  g5245_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5245_0 1 2.224404
R2 g5245_1 1 2.224404
.ends

.subckt netg3919 g3919_0 g3919_1 gnd
C1  g3919_0 gnd 2.080806f
C2  g3919_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3919_0 1 2.224404
R2 1 g3919_1 2.224404
.ends

.subckt netg1154 g1154_0 g1154_1 gnd
C1  g1154_0 gnd 2.080806f
C2  g1154_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1154_0 1 2.224404
R2 1 g1154_1 2.224404
.ends

.subckt netg1407 g1407_1 g1407_0 gnd
C1  g1407_1 gnd 2.080806f
C2  g1407_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1407_0 1 2.224404
R2 1 g1407_1 2.224404
.ends

.subckt netg6980 g6980_0 g6980_2 g6980_1 gnd
C1  g6980_0 gnd 2.080806f
C2  g6980_2 gnd 2.080806f
C3  g6980_1 gnd 2.080806f
R1 g6980_0 g6980_2 2.224404
R2 g6980_2 g6980_1 2.224404
.ends

.subckt netg4024 g4024_1 g4024_0 gnd
C1  g4024_1 gnd 2.080806f
C2  g4024_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4024_0 2.224404
R2 g4024_1 1 2.224404
.ends

.subckt netg3466 g3466_0 g3466_1 gnd
C1  g3466_0 gnd 2.080806f
C2  g3466_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3466_0 1 2.224404
R2 1 g3466_1 2.224404
.ends

.subckt netg7167 g7167_1 g7167_0 gnd
C1  g7167_1 gnd 2.080806f
C2  g7167_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7167_0 1 2.224404
R2 1 g7167_1 2.224404
.ends

.subckt netg4083 g4083_1 g4083_0 gnd
C1  g4083_1 gnd 2.080806f
C2  g4083_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4083_0 2.224404
R2 g4083_1 1 2.224404
.ends

.subckt netg5990 g5990_1 g5990_0 gnd
C1  g5990_1 gnd 2.080806f
C2  g5990_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5990_0 2.224404
R2 g5990_1 1 2.224404
.ends

.subckt netg7254 g7254_1 g7254_0 gnd
C1  g7254_1 gnd 2.080806f
C2  g7254_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7254_0 2.224404
R2 g7254_1 1 2.224404
.ends

.subckt netg7432 g7432_0 g7432_1 gnd
C1  g7432_0 gnd 2.080806f
C2  g7432_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7432_0 2.224404
R2 g7432_1 1 2.224404
.ends

.subckt netg7161 g7161_2 g7161_0 g7161_1 gnd
C1  g7161_2 gnd 2.080806f
C2  g7161_0 gnd 2.080806f
C3  g7161_1 gnd 2.080806f
R1 g7161_1 g7161_0 2.224404
R2 g7161_2 g7161_1 2.224404
.ends

.subckt netg2999 g2999_0 g2999_1 gnd
C1  g2999_0 gnd 2.080806f
C2  g2999_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2999_0 2.224404
R2 g2999_1 1 2.224404
.ends

.subckt netg2447 g2447_0 g2447_1 g2447_2 gnd
C1  g2447_0 gnd 2.080806f
C2  g2447_1 gnd 2.080806f
C3  g2447_2 gnd 2.080806f
R1 g2447_0 g2447_2 2.224404
R2 g2447_2 g2447_1 2.224404
.ends

.subckt netg7413 g7413_1 g7413_0 gnd
C1  g7413_1 gnd 2.080806f
C2  g7413_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7413_0 2.224404
R2 g7413_1 1 2.224404
.ends

.subckt netg2936 g2936_0 g2936_1 gnd
C1  g2936_0 gnd 2.080806f
C2  g2936_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2936_0 2.224404
R2 g2936_1 1 2.224404
.ends

.subckt netx62 x62_1 x62_0 gnd
C1  x62_1 gnd 2.080806f
C2  x62_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x62_0 1 2.224404
R2 x62_1 1 2.224404
.ends

.subckt netg4433 g4433_0 g4433_1 gnd
C1  g4433_0 gnd 2.080806f
C2  g4433_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4433_0 1 2.224404
R2 1 g4433_1 2.224404
.ends

.subckt netg1082 g1082_2 g1082_1 gnd
C1  g1082_2 gnd 2.080806f
C2  g1082_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1082_1 1 2.224404
R2 1 g1082_2 2.224404
.ends

.subckt netg6388 g6388_1 g6388_0 gnd
C1  g6388_1 gnd 2.080806f
C2  g6388_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6388_0 2.224404
R2 g6388_1 1 2.224404
.ends

.subckt netg4335 g4335_1 g4335_0 gnd
C1  g4335_1 gnd 2.080806f
C2  g4335_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4335_0 2.224404
R2 g4335_1 1 2.224404
.ends

.subckt netg3985 g3985_0 g3985_1 gnd
C1  g3985_0 gnd 2.080806f
C2  g3985_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3985_0 2.224404
R2 g3985_1 1 2.224404
.ends

.subckt netg7016 g7016_0 g7016_1 gnd
C1  g7016_0 gnd 2.080806f
C2  g7016_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7016_0 2.224404
R2 1 g7016_1 2.224404
.ends

.subckt netg5296 g5296_1 g5296_0 gnd
C1  g5296_1 gnd 2.080806f
C2  g5296_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5296_0 2.224404
R2 g5296_1 1 2.224404
.ends

.subckt netg5348 g5348_1 g5348_0 gnd
C1  g5348_1 gnd 2.080806f
C2  g5348_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5348_0 1 2.224404
R2 g5348_1 1 2.224404
.ends

.subckt netg4037 g4037_1 g4037_0 gnd
C1  g4037_1 gnd 2.080806f
C2  g4037_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4037_0 2.224404
R2 g4037_1 1 2.224404
.ends

.subckt netg4330 g4330_1 g4330_0 gnd
C1  g4330_1 gnd 2.080806f
C2  g4330_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4330_0 2.224404
R2 g4330_1 1 2.224404
.ends

.subckt netg2441 g2441_1 g2441_0 g2441_2 gnd
C1  g2441_1 gnd 2.080806f
C2  g2441_0 gnd 2.080806f
C3  g2441_2 gnd 2.080806f
R1 g2441_0 g2441_1 2.224404
R2 g2441_0 g2441_2 2.224404
.ends

.subckt netx172 x172_1 x172_0 gnd
C1  x172_1 gnd 2.080806f
C2  x172_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x172_0 2.224404
R2 1 x172_1 2.224404
.ends

.subckt netg5625 g5625_1 g5625_2 gnd
C1  g5625_1 gnd 2.080806f
C2  g5625_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5625_2 1 2.224404
R2 1 g5625_1 2.224404
.ends

.subckt netg5104 g5104_2 g5104_0 g5104_1 gnd
C1  g5104_2 gnd 2.080806f
C2  g5104_0 gnd 2.080806f
C3  g5104_1 gnd 2.080806f
R1 g5104_2 g5104_0 2.224404
R2 g5104_1 g5104_2 2.224404
.ends

.subckt netg5528 g5528_1 g5528_0 gnd
C1  g5528_1 gnd 2.080806f
C2  g5528_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5528_0 2.224404
R2 g5528_1 1 2.224404
.ends

.subckt netg931 g931_2 g931_1 g931_0 gnd
C1  g931_2 gnd 2.080806f
C2  g931_1 gnd 2.080806f
C3  g931_0 gnd 2.080806f
R1 g931_0 g931_1 2.224404
R2 g931_2 g931_0 2.224404
.ends

.subckt netg7345 g7345_1 g7345_0 gnd
C1  g7345_1 gnd 2.080806f
C2  g7345_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7345_0 1 2.224404
R2 1 g7345_1 2.224404
.ends

.subckt netg5120 g5120_0 g5120_1 gnd
C1  g5120_0 gnd 2.080806f
C2  g5120_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5120_0 2.224404
R2 g5120_1 1 2.224404
.ends

.subckt netg6971 g6971_1 g6971_0 gnd
C1  g6971_1 gnd 2.080806f
C2  g6971_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6971_0 1 2.224404
R2 1 g6971_1 2.224404
.ends

.subckt netg5131 g5131_0 g5131_2 gnd
C1  g5131_0 gnd 2.080806f
C2  g5131_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5131_0 1 2.224404
R2 1 g5131_2 2.224404
.ends

.subckt netg5273 g5273_0 g5273_1 gnd
C1  g5273_0 gnd 2.080806f
C2  g5273_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5273_0 2.224404
R2 g5273_1 1 2.224404
.ends

.subckt netg5184 g5184_1 g5184_0 gnd
C1  g5184_1 gnd 2.080806f
C2  g5184_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5184_0 2.224404
R2 g5184_1 1 2.224404
.ends

.subckt netg6526 g6526_0 g6526_1 gnd
C1  g6526_0 gnd 2.080806f
C2  g6526_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6526_0 2.224404
R2 1 g6526_1 2.224404
.ends

.subckt netg6983 g6983_0 g6983_1 gnd
C1  g6983_0 gnd 2.080806f
C2  g6983_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6983_0 1 2.224404
R2 1 g6983_1 2.224404
.ends

.subckt netg6735 g6735_0 g6735_1 gnd
C1  g6735_0 gnd 2.080806f
C2  g6735_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6735_0 2.224404
R2 g6735_1 1 2.224404
.ends

.subckt netg1428 g1428_1 g1428_0 gnd
C1  g1428_1 gnd 2.080806f
C2  g1428_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1428_0 2.224404
R2 1 g1428_1 2.224404
.ends

.subckt netg2224 g2224_1 g2224_0 gnd
C1  g2224_1 gnd 2.080806f
C2  g2224_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2224_0 2.224404
R2 g2224_1 1 2.224404
.ends

.subckt netx92 x92_0 x92_1 gnd
C1  x92_0 gnd 2.080806f
C2  x92_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x92_0 2.224404
R2 x92_1 1 2.224404
.ends

.subckt netg7371 g7371_0 g7371_1 gnd
C1  g7371_0 gnd 2.080806f
C2  g7371_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7371_0 1 2.224404
R2 1 g7371_1 2.224404
.ends

.subckt netg7077 g7077_0 g7077_1 gnd
C1  g7077_0 gnd 2.080806f
C2  g7077_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7077_0 1 2.224404
R2 1 g7077_1 2.224404
.ends

.subckt netg7296 g7296_0 g7296_1 gnd
C1  g7296_0 gnd 2.080806f
C2  g7296_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7296_0 2.224404
R2 g7296_1 1 2.224404
.ends

.subckt netx501 x501_0 x501_1 gnd
C1  x501_0 gnd 2.080806f
C2  x501_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x501_0 2.224404
R2 x501_1 1 2.224404
.ends

.subckt netg880 g880_2 g880_0 gnd
C1  g880_2 gnd 2.080806f
C2  g880_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g880_0 1 2.224404
R2 1 g880_2 2.224404
.ends

.subckt netg6130 g6130_1 g6130_0 gnd
C1  g6130_1 gnd 2.080806f
C2  g6130_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6130_0 2.224404
R2 1 g6130_1 2.224404
.ends

.subckt netg83 g83_0 g83_1 gnd
C1  g83_0 gnd 2.080806f
C2  g83_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g83_0 2.224404
R2 1 g83_1 2.224404
.ends

.subckt netg7278 g7278_1 g7278_0 gnd
C1  g7278_1 gnd 2.080806f
C2  g7278_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7278_0 2.224404
R2 g7278_1 1 2.224404
.ends

.subckt netg1531 g1531_1 g1531_0 gnd
C1  g1531_1 gnd 2.080806f
C2  g1531_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1531_0 2.224404
R2 g1531_1 1 2.224404
.ends

.subckt netg2489 g2489_2 g2489_1 g2489_0 gnd
C1  g2489_2 gnd 2.080806f
C2  g2489_1 gnd 2.080806f
C3  g2489_0 gnd 2.080806f
R1 g2489_0 g2489_1 2.224404
R2 g2489_2 g2489_0 2.224404
.ends

.subckt netg6307 g6307_1 g6307_0 gnd
C1  g6307_1 gnd 2.080806f
C2  g6307_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6307_0 1 2.224404
R2 g6307_1 1 2.224404
.ends

.subckt netg6505 g6505_1 g6505_0 gnd
C1  g6505_1 gnd 2.080806f
C2  g6505_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6505_0 2.224404
R2 g6505_1 1 2.224404
.ends

.subckt netg5767 g5767_1 g5767_0 gnd
C1  g5767_1 gnd 2.080806f
C2  g5767_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5767_0 1 2.224404
R2 1 g5767_1 2.224404
.ends

.subckt netg6652 g6652_0 g6652_1 gnd
C1  g6652_0 gnd 2.080806f
C2  g6652_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6652_0 2.224404
R2 g6652_1 1 2.224404
.ends

.subckt netg6291 g6291_1 g6291_0 gnd
C1  g6291_1 gnd 2.080806f
C2  g6291_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6291_0 1 2.224404
R2 g6291_1 1 2.224404
.ends

.subckt netg5505 g5505_1 g5505_2 gnd
C1  g5505_1 gnd 2.080806f
C2  g5505_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5505_1 1 2.224404
R2 1 g5505_2 2.224404
.ends

.subckt netx261 x261_0 x261_1 gnd
C1  x261_0 gnd 2.080806f
C2  x261_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x261_0 1 2.224404
R2 1 x261_1 2.224404
.ends

.subckt netg6172 g6172_0 g6172_1 gnd
C1  g6172_0 gnd 2.080806f
C2  g6172_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6172_0 2.224404
R2 g6172_1 1 2.224404
.ends

.subckt netg5300 g5300_1 g5300_0 gnd
C1  g5300_1 gnd 2.080806f
C2  g5300_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5300_0 2.224404
R2 1 g5300_1 2.224404
.ends

.subckt netg5833 g5833_1 g5833_0 gnd
C1  g5833_1 gnd 2.080806f
C2  g5833_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5833_0 1 2.224404
R2 1 g5833_1 2.224404
.ends

.subckt netg6612 g6612_0 g6612_1 gnd
C1  g6612_0 gnd 2.080806f
C2  g6612_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6612_0 2.224404
R2 g6612_1 1 2.224404
.ends

.subckt netg4416 g4416_1 g4416_0 gnd
C1  g4416_1 gnd 2.080806f
C2  g4416_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4416_0 1 2.224404
R2 1 g4416_1 2.224404
.ends

.subckt netg4073 g4073_1 g4073_0 gnd
C1  g4073_1 gnd 2.080806f
C2  g4073_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4073_0 1 2.224404
R2 1 g4073_1 2.224404
.ends

.subckt netg946 g946_2 g946_1 gnd
C1  g946_2 gnd 2.080806f
C2  g946_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g946_2 2.224404
R2 g946_1 1 2.224404
.ends

.subckt netg7124 g7124_0 g7124_1 gnd
C1  g7124_0 gnd 2.080806f
C2  g7124_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7124_0 1 2.224404
R2 1 g7124_1 2.224404
.ends

.subckt netg3336 g3336_0 g3336_1 g3336_2 gnd
C1  g3336_0 gnd 2.080806f
C2  g3336_1 gnd 2.080806f
C3  g3336_2 gnd 2.080806f
R1 g3336_2 g3336_0 2.224404
R2 g3336_1 g3336_2 2.224404
.ends

.subckt netg871 g871_1 g871_2 gnd
C1  g871_1 gnd 2.080806f
C2  g871_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g871_2 2.224404
R2 g871_1 1 2.224404
.ends

.subckt netg3216 g3216_0 g3216_2 g3216_1 gnd
C1  g3216_0 gnd 2.080806f
C2  g3216_2 gnd 2.080806f
C3  g3216_1 gnd 2.080806f
R1 g3216_1 g3216_0 2.224404
R2 g3216_0 g3216_2 2.224404
.ends

.subckt netg2516 g2516_2 g2516_1 gnd
C1  g2516_2 gnd 2.080806f
C2  g2516_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2516_1 2.224404
R2 g2516_2 1 2.224404
.ends

.subckt netg4011 g4011_1 g4011_0 gnd
C1  g4011_1 gnd 2.080806f
C2  g4011_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4011_0 2.224404
R2 g4011_1 1 2.224404
.ends

.subckt netg3532 g3532_1 g3532_0 gnd
C1  g3532_1 gnd 2.080806f
C2  g3532_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3532_0 2.224404
R2 1 g3532_1 2.224404
.ends

.subckt netg4186 g4186_1 g4186_0 gnd
C1  g4186_1 gnd 2.080806f
C2  g4186_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4186_0 2.224404
R2 g4186_1 1 2.224404
.ends

.subckt netg4274 g4274_1 g4274_0 gnd
C1  g4274_1 gnd 2.080806f
C2  g4274_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4274_0 1 2.224404
R2 1 g4274_1 2.224404
.ends

.subckt netg2674 g2674_1 g2674_2 g2674_0 gnd
C1  g2674_1 gnd 2.080806f
C2  g2674_2 gnd 2.080806f
C3  g2674_0 gnd 2.080806f
R1 g2674_1 g2674_0 2.224404
R2 g2674_2 g2674_1 2.224404
.ends

.subckt netg4269 g4269_1 g4269_0 gnd
C1  g4269_1 gnd 2.080806f
C2  g4269_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4269_0 2.224404
R2 1 g4269_1 2.224404
.ends

.subckt netg5229 g5229_2 g5229_1 g5229_0 gnd
C1  g5229_2 gnd 2.080806f
C2  g5229_1 gnd 2.080806f
C3  g5229_0 gnd 2.080806f
R1 g5229_2 g5229_0 2.224404
R2 g5229_1 g5229_2 2.224404
.ends

.subckt netg7130 g7130_0 g7130_1 gnd
C1  g7130_0 gnd 2.080806f
C2  g7130_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7130_0 1 2.224404
R2 1 g7130_1 2.224404
.ends

.subckt netg5223 g5223_2 g5223_1 g5223_0 gnd
C1  g5223_2 gnd 2.080806f
C2  g5223_1 gnd 2.080806f
C3  g5223_0 gnd 2.080806f
R1 g5223_0 g5223_1 2.224404
R2 g5223_2 g5223_0 2.224404
.ends

.subckt netg3574 g3574_0 g3574_1 gnd
C1  g3574_0 gnd 2.080806f
C2  g3574_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3574_0 2.224404
R2 g3574_1 1 2.224404
.ends

.subckt netg3525 g3525_0 g3525_1 gnd
C1  g3525_0 gnd 2.080806f
C2  g3525_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3525_0 2.224404
R2 g3525_1 1 2.224404
.ends

.subckt netg5467 g5467_1 g5467_0 gnd
C1  g5467_1 gnd 2.080806f
C2  g5467_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5467_0 2.224404
R2 1 g5467_1 2.224404
.ends

.subckt netg682 g682_1 g682_0 gnd
C1  g682_1 gnd 2.080806f
C2  g682_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g682_0 2.224404
R2 g682_1 1 2.224404
.ends

.subckt netg1132 g1132_0 g1132_1 gnd
C1  g1132_0 gnd 2.080806f
C2  g1132_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1132_0 2.224404
R2 g1132_1 1 2.224404
.ends

.subckt netg856 g856_2 g856_1 g856_0 gnd
C1  g856_2 gnd 2.080806f
C2  g856_1 gnd 2.080806f
C3  g856_0 gnd 2.080806f
R1 g856_0 g856_1 2.224404
R2 g856_2 g856_0 2.224404
.ends

.subckt netg3890 g3890_0 g3890_1 gnd
C1  g3890_0 gnd 2.080806f
C2  g3890_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3890_0 1 2.224404
R2 1 g3890_1 2.224404
.ends

.subckt netg1256 g1256_0 g1256_1 gnd
C1  g1256_0 gnd 2.080806f
C2  g1256_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1256_0 2.224404
R2 g1256_1 1 2.224404
.ends

.subckt netg4235 g4235_1 g4235_0 gnd
C1  g4235_1 gnd 2.080806f
C2  g4235_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4235_0 1 2.224404
R2 g4235_1 1 2.224404
.ends

.subckt netg3512 g3512_0 g3512_1 gnd
C1  g3512_0 gnd 2.080806f
C2  g3512_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3512_0 1 2.224404
R2 g3512_1 1 2.224404
.ends

.subckt netg5077 g5077_0 g5077_2 gnd
C1  g5077_0 gnd 2.080806f
C2  g5077_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5077_0 2.224404
R2 g5077_2 1 2.224404
.ends

.subckt netg868 g868_2 g868_0 g868_1 gnd
C1  g868_2 gnd 2.080806f
C2  g868_0 gnd 2.080806f
C3  g868_1 gnd 2.080806f
R1 g868_0 g868_1 2.224404
R2 g868_1 g868_2 2.224404
.ends

.subckt netg1410 g1410_0 g1410_1 gnd
C1  g1410_0 gnd 2.080806f
C2  g1410_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1410_0 2.224404
R2 g1410_1 1 2.224404
.ends

.subckt netg2633 g2633_1 g2633_0 gnd
C1  g2633_1 gnd 2.080806f
C2  g2633_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2633_0 2.224404
R2 g2633_1 1 2.224404
.ends

.subckt netg5000 g5000_0 g5000_2 gnd
C1  g5000_0 gnd 2.080806f
C2  g5000_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5000_0 1 2.224404
R2 1 g5000_2 2.224404
.ends

.subckt netg6621 g6621_0 g6621_1 gnd
C1  g6621_0 gnd 2.080806f
C2  g6621_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6621_0 1 2.224404
R2 1 g6621_1 2.224404
.ends

.subckt netg1888 g1888_0 g1888_1 gnd
C1  g1888_0 gnd 2.080806f
C2  g1888_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1888_0 1 2.224404
R2 1 g1888_1 2.224404
.ends

.subckt netg6650 g6650_0 g6650_1 gnd
C1  g6650_0 gnd 2.080806f
C2  g6650_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6650_0 2.224404
R2 g6650_1 1 2.224404
.ends

.subckt netg7113 g7113_0 g7113_1 gnd
C1  g7113_0 gnd 2.080806f
C2  g7113_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7113_0 1 2.224404
R2 1 g7113_1 2.224404
.ends

.subckt netg5519 g5519_1 g5519_0 gnd
C1  g5519_1 gnd 2.080806f
C2  g5519_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5519_0 1 2.224404
R2 1 g5519_1 2.224404
.ends

.subckt netg5920 g5920_1 g5920_2 gnd
C1  g5920_1 gnd 2.080806f
C2  g5920_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5920_2 2.224404
R2 1 g5920_1 2.224404
.ends

.subckt netg886 g886_0 g886_2 gnd
C1  g886_0 gnd 2.080806f
C2  g886_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g886_0 1 2.224404
R2 1 g886_2 2.224404
.ends

.subckt netg3364 g3364_1 g3364_0 gnd
C1  g3364_1 gnd 2.080806f
C2  g3364_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3364_0 2.224404
R2 g3364_1 1 2.224404
.ends

.subckt netg7271 g7271_1 g7271_0 gnd
C1  g7271_1 gnd 2.080806f
C2  g7271_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7271_0 1 2.224404
R2 1 g7271_1 2.224404
.ends

.subckt netg5386 g5386_0 g5386_1 gnd
C1  g5386_0 gnd 2.080806f
C2  g5386_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5386_0 1 2.224404
R2 1 g5386_1 2.224404
.ends

.subckt netg7426 g7426_0 g7426_1 gnd
C1  g7426_0 gnd 2.080806f
C2  g7426_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7426_0 2.224404
R2 g7426_1 1 2.224404
.ends

.subckt netg5469 g5469_1 g5469_0 gnd
C1  g5469_1 gnd 2.080806f
C2  g5469_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5469_0 2.224404
R2 g5469_1 1 2.224404
.ends

.subckt netg6878 g6878_0 g6878_1 gnd
C1  g6878_0 gnd 2.080806f
C2  g6878_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6878_0 1 2.224404
R2 1 g6878_1 2.224404
.ends

.subckt netg4320 g4320_0 g4320_1 gnd
C1  g4320_0 gnd 2.080806f
C2  g4320_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4320_0 2.224404
R2 g4320_1 1 2.224404
.ends

.subckt netg7140 g7140_0 g7140_1 gnd
C1  g7140_0 gnd 2.080806f
C2  g7140_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7140_0 2.224404
R2 g7140_1 1 2.224404
.ends

.subckt netg1901 g1901_1 g1901_0 gnd
C1  g1901_1 gnd 2.080806f
C2  g1901_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1901_0 1 2.224404
R2 1 g1901_1 2.224404
.ends

.subckt netg3065 g3065_1 g3065_0 gnd
C1  g3065_1 gnd 2.080806f
C2  g3065_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3065_0 2.224404
R2 g3065_1 1 2.224404
.ends

.subckt netg5513 g5513_1 g5513_0 gnd
C1  g5513_1 gnd 2.080806f
C2  g5513_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5513_0 2.224404
R2 g5513_1 1 2.224404
.ends

.subckt netg4946 g4946_2 g4946_0 g4946_1 gnd
C1  g4946_2 gnd 2.080806f
C2  g4946_0 gnd 2.080806f
C3  g4946_1 gnd 2.080806f
R1 g4946_0 g4946_2 2.224404
R2 g4946_2 g4946_1 2.224404
.ends

.subckt netg7080 g7080_0 g7080_1 gnd
C1  g7080_0 gnd 2.080806f
C2  g7080_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7080_0 2.224404
R2 1 g7080_1 2.224404
.ends

.subckt netg4439 g4439_0 g4439_1 gnd
C1  g4439_0 gnd 2.080806f
C2  g4439_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4439_0 1 2.224404
R2 1 g4439_1 2.224404
.ends

.subckt netg3498 g3498_1 g3498_0 gnd
C1  g3498_1 gnd 2.080806f
C2  g3498_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3498_0 1 2.224404
R2 1 g3498_1 2.224404
.ends

.subckt netg3078 g3078_0 g3078_1 gnd
C1  g3078_0 gnd 2.080806f
C2  g3078_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3078_0 1 2.224404
R2 g3078_1 1 2.224404
.ends

.subckt netg5658 g5658_1 g5658_2 gnd
C1  g5658_1 gnd 2.080806f
C2  g5658_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5658_1 2.224404
R2 g5658_2 1 2.224404
.ends

.subckt netg2609 g2609_2 g2609_1 gnd
C1  g2609_2 gnd 2.080806f
C2  g2609_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2609_1 1 2.224404
R2 g2609_2 1 2.224404
.ends

.subckt netg3969 g3969_0 g3969_1 gnd
C1  g3969_0 gnd 2.080806f
C2  g3969_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3969_0 1 2.224404
R2 g3969_1 1 2.224404
.ends

.subckt netg6699 g6699_0 g6699_1 gnd
C1  g6699_0 gnd 2.080806f
C2  g6699_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6699_0 2.224404
R2 g6699_1 1 2.224404
.ends

.subckt netg1309 g1309_1 g1309_0 gnd
C1  g1309_1 gnd 2.080806f
C2  g1309_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1309_0 2.224404
R2 g1309_1 1 2.224404
.ends

.subckt netg5640 g5640_0 g5640_2 gnd
C1  g5640_0 gnd 2.080806f
C2  g5640_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5640_0 1 2.224404
R2 1 g5640_2 2.224404
.ends

.subckt netg5056 g5056_1 g5056_2 gnd
C1  g5056_1 gnd 2.080806f
C2  g5056_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5056_1 1 2.224404
R2 g5056_2 1 2.224404
.ends

.subckt netg3339 g3339_2 g3339_1 gnd
C1  g3339_2 gnd 2.080806f
C2  g3339_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3339_1 1 2.224404
R2 1 g3339_2 2.224404
.ends

.subckt netg6517 g6517_1 g6517_0 gnd
C1  g6517_1 gnd 2.080806f
C2  g6517_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6517_0 1 2.224404
R2 g6517_1 1 2.224404
.ends

.subckt netg1257 g1257_1 g1257_0 gnd
C1  g1257_1 gnd 2.080806f
C2  g1257_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1257_0 1 2.224404
R2 g1257_1 1 2.224404
.ends

.subckt netg5468 g5468_0 g5468_1 gnd
C1  g5468_0 gnd 2.080806f
C2  g5468_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5468_0 2.224404
R2 g5468_1 1 2.224404
.ends

.subckt netg5331 g5331_1 g5331_0 gnd
C1  g5331_1 gnd 2.080806f
C2  g5331_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5331_0 2.224404
R2 g5331_1 1 2.224404
.ends

.subckt netg5768 g5768_1 g5768_0 gnd
C1  g5768_1 gnd 2.080806f
C2  g5768_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5768_0 2.224404
R2 g5768_1 1 2.224404
.ends

.subckt netg5543 g5543_1 g5543_0 g5543_2 gnd
C1  g5543_1 gnd 2.080806f
C2  g5543_0 gnd 2.080806f
C3  g5543_2 gnd 2.080806f
R1 g5543_0 g5543_1 2.224404
R2 g5543_2 g5543_1 2.224404
.ends

.subckt netg3156 g3156_0 g3156_1 g3156_2 gnd
C1  g3156_0 gnd 2.080806f
C2  g3156_1 gnd 2.080806f
C3  g3156_2 gnd 2.080806f
R1 g3156_2 g3156_0 2.224404
R2 g3156_1 g3156_2 2.224404
.ends

.subckt netg3905 g3905_0 g3905_1 gnd
C1  g3905_0 gnd 2.080806f
C2  g3905_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3905_0 2.224404
R2 g3905_1 1 2.224404
.ends

.subckt netg3306 g3306_1 g3306_2 gnd
C1  g3306_1 gnd 2.080806f
C2  g3306_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3306_1 1 2.224404
R2 1 g3306_2 2.224404
.ends

.subckt netg6506 g6506_0 g6506_1 gnd
C1  g6506_0 gnd 2.080806f
C2  g6506_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6506_0 2.224404
R2 g6506_1 1 2.224404
.ends

.subckt netg5356 g5356_1 g5356_0 gnd
C1  g5356_1 gnd 2.080806f
C2  g5356_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5356_0 2.224404
R2 1 g5356_1 2.224404
.ends

.subckt netg916 g916_2 g916_1 gnd
C1  g916_2 gnd 2.080806f
C2  g916_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g916_2 2.224404
R2 1 g916_1 2.224404
.ends

.subckt netg6394 g6394_0 g6394_1 gnd
C1  g6394_0 gnd 2.080806f
C2  g6394_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6394_0 2.224404
R2 g6394_1 1 2.224404
.ends

.subckt netg5015 g5015_1 g5015_2 g5015_0 gnd
C1  g5015_1 gnd 2.080806f
C2  g5015_2 gnd 2.080806f
C3  g5015_0 gnd 2.080806f
R1 g5015_1 g5015_0 2.224404
R2 g5015_1 g5015_2 2.224404
.ends

.subckt netg6422 g6422_1 g6422_0 gnd
C1  g6422_1 gnd 2.080806f
C2  g6422_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6422_0 1 2.224404
R2 1 g6422_1 2.224404
.ends

.subckt netg3059 g3059_0 g3059_1 gnd
C1  g3059_0 gnd 2.080806f
C2  g3059_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3059_0 2.224404
R2 g3059_1 1 2.224404
.ends

.subckt netg2811 g2811_1 g2811_0 gnd
C1  g2811_1 gnd 2.080806f
C2  g2811_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2811_0 1 2.224404
R2 1 g2811_1 2.224404
.ends

.subckt netg3926 g3926_0 g3926_1 gnd
C1  g3926_0 gnd 2.080806f
C2  g3926_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3926_0 2.224404
R2 g3926_1 1 2.224404
.ends

.subckt netg3110 g3110_0 g3110_2 g3110_1 gnd
C1  g3110_0 gnd 2.080806f
C2  g3110_2 gnd 2.080806f
C3  g3110_1 gnd 2.080806f
R1 g3110_2 g3110_0 2.224404
R2 g3110_1 g3110_2 2.224404
.ends

.subckt netg1889 g1889_0 g1889_1 gnd
C1  g1889_0 gnd 2.080806f
C2  g1889_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1889_0 2.224404
R2 g1889_1 1 2.224404
.ends

.subckt netg6925 g6925_0 g6925_1 gnd
C1  g6925_0 gnd 2.080806f
C2  g6925_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6925_0 2.224404
R2 g6925_1 1 2.224404
.ends

.subckt netg6313 g6313_1 g6313_0 gnd
C1  g6313_1 gnd 2.080806f
C2  g6313_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6313_0 2.224404
R2 g6313_1 1 2.224404
.ends

.subckt netg3055 g3055_1 g3055_0 gnd
C1  g3055_1 gnd 2.080806f
C2  g3055_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3055_0 1 2.224404
R2 1 g3055_1 2.224404
.ends

.subckt netg4016 g4016_1 g4016_0 gnd
C1  g4016_1 gnd 2.080806f
C2  g4016_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4016_0 2.224404
R2 g4016_1 1 2.224404
.ends

.subckt netg2653 g2653_2 g2653_0 gnd
C1  g2653_2 gnd 2.080806f
C2  g2653_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2653_0 2.224404
R2 g2653_2 1 2.224404
.ends

.subckt netg6518 g6518_0 g6518_1 gnd
C1  g6518_0 gnd 2.080806f
C2  g6518_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6518_0 1 2.224404
R2 1 g6518_1 2.224404
.ends

.subckt netg6010 g6010_0 g6010_1 gnd
C1  g6010_0 gnd 2.080806f
C2  g6010_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6010_0 1 2.224404
R2 1 g6010_1 2.224404
.ends

.subckt netg3494 g3494_0 g3494_1 gnd
C1  g3494_0 gnd 2.080806f
C2  g3494_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3494_0 1 2.224404
R2 1 g3494_1 2.224404
.ends

.subckt netg2928 g2928_0 g2928_1 gnd
C1  g2928_0 gnd 2.080806f
C2  g2928_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2928_0 2.224404
R2 g2928_1 1 2.224404
.ends

.subckt netg4389 g4389_2 g4389_0 g4389_1 gnd
C1  g4389_2 gnd 2.080806f
C2  g4389_0 gnd 2.080806f
C3  g4389_1 gnd 2.080806f
R1 g4389_2 g4389_0 2.224404
R2 g4389_1 g4389_2 2.224404
.ends

.subckt netg5953 g5953_0 g5953_1 gnd
C1  g5953_0 gnd 2.080806f
C2  g5953_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5953_0 2.224404
R2 g5953_1 1 2.224404
.ends

.subckt netg2837 g2837_1 g2837_0 gnd
C1  g2837_1 gnd 2.080806f
C2  g2837_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2837_0 2.224404
R2 g2837_1 1 2.224404
.ends

.subckt netg6499 g6499_2 g6499_0 gnd
C1  g6499_2 gnd 2.080806f
C2  g6499_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6499_0 1 2.224404
R2 1 g6499_2 2.224404
.ends

.subckt netg6555 g6555_0 g6555_1 gnd
C1  g6555_0 gnd 2.080806f
C2  g6555_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6555_0 1 2.224404
R2 1 g6555_1 2.224404
.ends

.subckt netg4341 g4341_0 g4341_1 gnd
C1  g4341_0 gnd 2.080806f
C2  g4341_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4341_0 2.224404
R2 g4341_1 1 2.224404
.ends

.subckt netg3300 g3300_1 g3300_2 g3300_0 gnd
C1  g3300_1 gnd 2.080806f
C2  g3300_2 gnd 2.080806f
C3  g3300_0 gnd 2.080806f
R1 g3300_2 g3300_0 2.224404
R2 g3300_1 g3300_2 2.224404
.ends

.subckt netg7072 g7072_0 g7072_1 gnd
C1  g7072_0 gnd 2.080806f
C2  g7072_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7072_0 2.224404
R2 g7072_1 1 2.224404
.ends

.subckt netg5646 g5646_2 g5646_1 gnd
C1  g5646_2 gnd 2.080806f
C2  g5646_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5646_1 1 2.224404
R2 1 g5646_2 2.224404
.ends

.subckt netg3312 g3312_1 g3312_2 gnd
C1  g3312_1 gnd 2.080806f
C2  g3312_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3312_2 1 2.224404
R2 1 g3312_1 2.224404
.ends

.subckt netg4420 g4420_0 g4420_1 gnd
C1  g4420_0 gnd 2.080806f
C2  g4420_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4420_0 1 2.224404
R2 1 g4420_1 2.224404
.ends

.subckt netg7253 g7253_0 g7253_1 gnd
C1  g7253_0 gnd 2.080806f
C2  g7253_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7253_0 2.224404
R2 1 g7253_1 2.224404
.ends

.subckt netg6410 g6410_1 g6410_0 gnd
C1  g6410_1 gnd 2.080806f
C2  g6410_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6410_0 2.224404
R2 g6410_1 1 2.224404
.ends

.subckt netg1018 g1018_1 g1018_2 g1018_0 gnd
C1  g1018_1 gnd 2.080806f
C2  g1018_2 gnd 2.080806f
C3  g1018_0 gnd 2.080806f
R1 g1018_1 g1018_0 2.224404
R2 g1018_2 g1018_1 2.224404
.ends

.subckt netg5813 g5813_1 g5813_0 g5813_2 gnd
C1  g5813_1 gnd 2.080806f
C2  g5813_0 gnd 2.080806f
C3  g5813_2 gnd 2.080806f
R1 g5813_2 g5813_0 2.224404
R2 g5813_1 g5813_2 2.224404
.ends

.subckt netg4890 g4890_2 g4890_1 g4890_0 gnd
C1  g4890_2 gnd 2.080806f
C2  g4890_1 gnd 2.080806f
C3  g4890_0 gnd 2.080806f
R1 g4890_2 g4890_0 2.224404
R2 g4890_1 g4890_2 2.224404
.ends

.subckt netg1288 g1288_1 g1288_0 gnd
C1  g1288_1 gnd 2.080806f
C2  g1288_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1288_0 1 2.224404
R2 1 g1288_1 2.224404
.ends

.subckt netg4310 g4310_0 g4310_1 gnd
C1  g4310_0 gnd 2.080806f
C2  g4310_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4310_0 1 2.224404
R2 1 g4310_1 2.224404
.ends

.subckt netg5774 g5774_0 g5774_1 gnd
C1  g5774_0 gnd 2.080806f
C2  g5774_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5774_0 2.224404
R2 g5774_1 1 2.224404
.ends

.subckt netg3168 g3168_0 g3168_1 g3168_2 gnd
C1  g3168_0 gnd 2.080806f
C2  g3168_1 gnd 2.080806f
C3  g3168_2 gnd 2.080806f
R1 g3168_0 g3168_2 2.224404
R2 g3168_1 g3168_2 2.224404
.ends

.subckt netg1951 g1951_2 g1951_1 g1951_0 gnd
C1  g1951_2 gnd 2.080806f
C2  g1951_1 gnd 2.080806f
C3  g1951_0 gnd 2.080806f
R1 g1951_0 g1951_2 2.224404
R2 g1951_2 g1951_1 2.224404
.ends

.subckt netg2817 g2817_1 g2817_0 gnd
C1  g2817_1 gnd 2.080806f
C2  g2817_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2817_0 2.224404
R2 g2817_1 1 2.224404
.ends

.subckt netg5790 g5790_1 g5790_0 gnd
C1  g5790_1 gnd 2.080806f
C2  g5790_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5790_0 2.224404
R2 g5790_1 1 2.224404
.ends

.subckt netg3159 g3159_1 g3159_2 gnd
C1  g3159_1 gnd 2.080806f
C2  g3159_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3159_2 2.224404
R2 g3159_1 1 2.224404
.ends

.subckt netg3101 g3101_0 g3101_1 gnd
C1  g3101_0 gnd 2.080806f
C2  g3101_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3101_0 1 2.224404
R2 1 g3101_1 2.224404
.ends

.subckt netg4142 g4142_0 g4142_1 gnd
C1  g4142_0 gnd 2.080806f
C2  g4142_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4142_0 1 2.224404
R2 1 g4142_1 2.224404
.ends

.subckt netg5359 g5359_1 g5359_0 gnd
C1  g5359_1 gnd 2.080806f
C2  g5359_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5359_0 2.224404
R2 g5359_1 1 2.224404
.ends

.subckt netg4417 g4417_0 g4417_1 gnd
C1  g4417_0 gnd 2.080806f
C2  g4417_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4417_0 2.224404
R2 g4417_1 1 2.224404
.ends

.subckt netg7054 g7054_0 g7054_2 g7054_1 gnd
C1  g7054_0 gnd 2.080806f
C2  g7054_2 gnd 2.080806f
C3  g7054_1 gnd 2.080806f
R1 g7054_1 g7054_0 2.224404
R2 g7054_0 g7054_2 2.224404
.ends

.subckt netg6508 g6508_0 g6508_1 gnd
C1  g6508_0 gnd 2.080806f
C2  g6508_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6508_0 1 2.224404
R2 1 g6508_1 2.224404
.ends

.subckt netg6558 g6558_0 g6558_1 gnd
C1  g6558_0 gnd 2.080806f
C2  g6558_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6558_0 2.224404
R2 g6558_1 1 2.224404
.ends

.subckt netg6344 g6344_1 g6344_0 gnd
C1  g6344_1 gnd 2.080806f
C2  g6344_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6344_0 1 2.224404
R2 1 g6344_1 2.224404
.ends

.subckt netg6615 g6615_1 g6615_2 gnd
C1  g6615_1 gnd 2.080806f
C2  g6615_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6615_1 1 2.224404
R2 g6615_2 1 2.224404
.ends

.subckt netg7351 g7351_0 g7351_1 gnd
C1  g7351_0 gnd 2.080806f
C2  g7351_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7351_0 2.224404
R2 g7351_1 1 2.224404
.ends

.subckt netg6645 g6645_0 g6645_2 g6645_1 gnd
C1  g6645_0 gnd 2.080806f
C2  g6645_2 gnd 2.080806f
C3  g6645_1 gnd 2.080806f
R1 g6645_2 g6645_0 2.224404
R2 g6645_1 g6645_2 2.224404
.ends

.subckt netg6984 g6984_1 g6984_0 gnd
C1  g6984_1 gnd 2.080806f
C2  g6984_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6984_0 2.224404
R2 g6984_1 1 2.224404
.ends

.subckt netg2591 g2591_0 g2591_1 g2591_2 gnd
C1  g2591_0 gnd 2.080806f
C2  g2591_1 gnd 2.080806f
C3  g2591_2 gnd 2.080806f
R1 g2591_2 g2591_0 2.224404
R2 g2591_1 g2591_2 2.224404
.ends

.subckt netg1312 g1312_1 g1312_0 gnd
C1  g1312_1 gnd 2.080806f
C2  g1312_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1312_0 1 2.224404
R2 1 g1312_1 2.224404
.ends

.subckt netg1070 g1070_2 g1070_0 g1070_1 gnd
C1  g1070_2 gnd 2.080806f
C2  g1070_0 gnd 2.080806f
C3  g1070_1 gnd 2.080806f
R1 g1070_0 g1070_2 2.224404
R2 g1070_2 g1070_1 2.224404
.ends

.subckt netg5409 g5409_1 g5409_0 gnd
C1  g5409_1 gnd 2.080806f
C2  g5409_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5409_0 1 2.224404
R2 1 g5409_1 2.224404
.ends

.subckt netg4258 g4258_1 g4258_0 gnd
C1  g4258_1 gnd 2.080806f
C2  g4258_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4258_0 1 2.224404
R2 1 g4258_1 2.224404
.ends

.subckt netg7170 g7170_0 g7170_1 gnd
C1  g7170_0 gnd 2.080806f
C2  g7170_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7170_0 1 2.224404
R2 1 g7170_1 2.224404
.ends

.subckt netg7391 g7391_1 g7391_2 gnd
C1  g7391_1 gnd 2.080806f
C2  g7391_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7391_2 2.224404
R2 g7391_1 1 2.224404
.ends

.subckt netg5147 g5147_2 g5147_0 gnd
C1  g5147_2 gnd 2.080806f
C2  g5147_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5147_0 1 2.224404
R2 1 g5147_2 2.224404
.ends

.subckt netg5585 g5585_0 g5585_1 gnd
C1  g5585_0 gnd 2.080806f
C2  g5585_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5585_0 1 2.224404
R2 g5585_1 1 2.224404
.ends

.subckt netg7280 g7280_0 g7280_1 gnd
C1  g7280_0 gnd 2.080806f
C2  g7280_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7280_0 2.224404
R2 g7280_1 1 2.224404
.ends

.subckt netg5552 g5552_1 g5552_0 gnd
C1  g5552_1 gnd 2.080806f
C2  g5552_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5552_0 2.224404
R2 1 g5552_1 2.224404
.ends

.subckt netg6534 g6534_1 g6534_0 gnd
C1  g6534_1 gnd 2.080806f
C2  g6534_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6534_0 1 2.224404
R2 1 g6534_1 2.224404
.ends

.subckt netg6589 g6589_0 g6589_1 gnd
C1  g6589_0 gnd 2.080806f
C2  g6589_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6589_0 2.224404
R2 g6589_1 1 2.224404
.ends

.subckt netg3975 g3975_0 g3975_1 gnd
C1  g3975_0 gnd 2.080806f
C2  g3975_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3975_0 1 2.224404
R2 g3975_1 1 2.224404
.ends

.subckt netg7234 g7234_2 g7234_1 g7234_0 gnd
C1  g7234_2 gnd 2.080806f
C2  g7234_1 gnd 2.080806f
C3  g7234_0 gnd 2.080806f
R1 g7234_0 g7234_1 2.224404
R2 g7234_1 g7234_2 2.224404
.ends

.subckt netg4252 g4252_1 g4252_0 gnd
C1  g4252_1 gnd 2.080806f
C2  g4252_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4252_0 1 2.224404
R2 1 g4252_1 2.224404
.ends

.subckt netg2713 g2713_1 g2713_0 g2713_2 gnd
C1  g2713_1 gnd 2.080806f
C2  g2713_0 gnd 2.080806f
C3  g2713_2 gnd 2.080806f
R1 g2713_1 g2713_0 2.224404
R2 g2713_0 g2713_2 2.224404
.ends

.subckt netg5966 g5966_1 g5966_0 gnd
C1  g5966_1 gnd 2.080806f
C2  g5966_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5966_0 1 2.224404
R2 1 g5966_1 2.224404
.ends

.subckt netg7295 g7295_1 g7295_0 gnd
C1  g7295_1 gnd 2.080806f
C2  g7295_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7295_0 2.224404
R2 1 g7295_1 2.224404
.ends

.subckt netg6104 g6104_0 g6104_1 gnd
C1  g6104_0 gnd 2.080806f
C2  g6104_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6104_0 2.224404
R2 1 g6104_1 2.224404
.ends

.subckt netg4371 g4371_0 g4371_2 g4371_1 gnd
C1  g4371_0 gnd 2.080806f
C2  g4371_2 gnd 2.080806f
C3  g4371_1 gnd 2.080806f
R1 g4371_0 g4371_2 2.224404
R2 g4371_2 g4371_1 2.224404
.ends

.subckt netg6151 g6151_1 g6151_0 gnd
C1  g6151_1 gnd 2.080806f
C2  g6151_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6151_0 1 2.224404
R2 g6151_1 1 2.224404
.ends

.subckt netg3562 g3562_0 g3562_1 gnd
C1  g3562_0 gnd 2.080806f
C2  g3562_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3562_0 2.224404
R2 1 g3562_1 2.224404
.ends

.subckt netg1372 g1372_1 g1372_2 gnd
C1  g1372_1 gnd 2.080806f
C2  g1372_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1372_2 1 2.224404
R2 1 g1372_1 2.224404
.ends

.subckt netg5276 g5276_0 g5276_1 gnd
C1  g5276_0 gnd 2.080806f
C2  g5276_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5276_0 1 2.224404
R2 1 g5276_1 2.224404
.ends

.subckt netg6877 g6877_0 g6877_1 gnd
C1  g6877_0 gnd 2.080806f
C2  g6877_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6877_0 2.224404
R2 1 g6877_1 2.224404
.ends

.subckt netg3001 g3001_1 g3001_0 gnd
C1  g3001_1 gnd 2.080806f
C2  g3001_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3001_0 2.224404
R2 1 g3001_1 2.224404
.ends

.subckt netg6335 g6335_0 g6335_1 gnd
C1  g6335_0 gnd 2.080806f
C2  g6335_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6335_0 2.224404
R2 g6335_1 1 2.224404
.ends

.subckt netg3505 g3505_1 g3505_0 gnd
C1  g3505_1 gnd 2.080806f
C2  g3505_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3505_0 2.224404
R2 g3505_1 1 2.224404
.ends

.subckt netg4753 g4753_1 g4753_2 g4753_0 gnd
C1  g4753_1 gnd 2.080806f
C2  g4753_2 gnd 2.080806f
C3  g4753_0 gnd 2.080806f
R1 g4753_0 g4753_2 2.224404
R2 g4753_2 g4753_1 2.224404
.ends

.subckt netg5188 g5188_2 g5188_1 gnd
C1  g5188_2 gnd 2.080806f
C2  g5188_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5188_2 2.224404
R2 g5188_1 1 2.224404
.ends

.subckt netg2840 g2840_1 g2840_0 gnd
C1  g2840_1 gnd 2.080806f
C2  g2840_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2840_0 1 2.224404
R2 1 g2840_1 2.224404
.ends

.subckt netg4187 g4187_1 g4187_0 gnd
C1  g4187_1 gnd 2.080806f
C2  g4187_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4187_0 1 2.224404
R2 1 g4187_1 2.224404
.ends

.subckt netg3348 g3348_1 g3348_0 gnd
C1  g3348_1 gnd 2.080806f
C2  g3348_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3348_0 2.224404
R2 1 g3348_1 2.224404
.ends

.subckt netg1556 g1556_0 g1556_1 gnd
C1  g1556_0 gnd 2.080806f
C2  g1556_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1556_0 1 2.224404
R2 1 g1556_1 2.224404
.ends

.subckt netg7422 g7422_0 g7422_1 gnd
C1  g7422_0 gnd 2.080806f
C2  g7422_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7422_0 1 2.224404
R2 1 g7422_1 2.224404
.ends

.subckt netg6212 g6212_1 g6212_0 gnd
C1  g6212_1 gnd 2.080806f
C2  g6212_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6212_0 2.224404
R2 1 g6212_1 2.224404
.ends

.subckt netg4205 g4205_1 g4205_0 gnd
C1  g4205_1 gnd 2.080806f
C2  g4205_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4205_0 1 2.224404
R2 1 g4205_1 2.224404
.ends

.subckt netg3426 g3426_2 g3426_1 gnd
C1  g3426_2 gnd 2.080806f
C2  g3426_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3426_1 2.224404
R2 g3426_2 1 2.224404
.ends

.subckt netg4231 g4231_0 g4231_1 gnd
C1  g4231_0 gnd 2.080806f
C2  g4231_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4231_0 1 2.224404
R2 1 g4231_1 2.224404
.ends

.subckt netg4970 g4970_0 g4970_2 g4970_1 gnd
C1  g4970_0 gnd 2.080806f
C2  g4970_2 gnd 2.080806f
C3  g4970_1 gnd 2.080806f
R1 g4970_1 g4970_0 2.224404
R2 g4970_1 g4970_2 2.224404
.ends

.subckt netg6700 g6700_1 g6700_2 gnd
C1  g6700_1 gnd 2.080806f
C2  g6700_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6700_1 2.224404
R2 g6700_2 1 2.224404
.ends

.subckt netg4337 g4337_0 g4337_1 gnd
C1  g4337_0 gnd 2.080806f
C2  g4337_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4337_0 2.224404
R2 g4337_1 1 2.224404
.ends

.subckt netg2943 g2943_0 g2943_1 gnd
C1  g2943_0 gnd 2.080806f
C2  g2943_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2943_0 1 2.224404
R2 1 g2943_1 2.224404
.ends

.subckt netg6230 g6230_0 g6230_1 g6230_2 gnd
C1  g6230_0 gnd 2.080806f
C2  g6230_1 gnd 2.080806f
C3  g6230_2 gnd 2.080806f
R1 g6230_2 g6230_0 2.224404
R2 g6230_1 g6230_2 2.224404
.ends

.subckt netg4902 g4902_2 g4902_0 gnd
C1  g4902_2 gnd 2.080806f
C2  g4902_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4902_0 2.224404
R2 g4902_2 1 2.224404
.ends

.subckt netx251 x251_0 x251_1 gnd
C1  x251_0 gnd 2.080806f
C2  x251_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x251_0 1 2.224404
R2 1 x251_1 2.224404
.ends

.subckt netg5301 g5301_0 g5301_1 gnd
C1  g5301_0 gnd 2.080806f
C2  g5301_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5301_0 2.224404
R2 g5301_1 1 2.224404
.ends

.subckt netg7369 g7369_1 g7369_0 gnd
C1  g7369_1 gnd 2.080806f
C2  g7369_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7369_0 1 2.224404
R2 1 g7369_1 2.224404
.ends

.subckt netg2976 g2976_1 g2976_0 gnd
C1  g2976_1 gnd 2.080806f
C2  g2976_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2976_0 2.224404
R2 g2976_1 1 2.224404
.ends

.subckt netg2621 g2621_2 g2621_0 g2621_1 gnd
C1  g2621_2 gnd 2.080806f
C2  g2621_0 gnd 2.080806f
C3  g2621_1 gnd 2.080806f
R1 g2621_0 g2621_2 2.224404
R2 g2621_1 g2621_2 2.224404
.ends

.subckt netg6821 g6821_1 g6821_0 gnd
C1  g6821_1 gnd 2.080806f
C2  g6821_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6821_0 1 2.224404
R2 1 g6821_1 2.224404
.ends

.subckt netg6808 g6808_2 g6808_1 g6808_0 gnd
C1  g6808_2 gnd 2.080806f
C2  g6808_1 gnd 2.080806f
C3  g6808_0 gnd 2.080806f
R1 g6808_1 g6808_0 2.224404
R2 g6808_2 g6808_1 2.224404
.ends

.subckt netg6993 g6993_0 g6993_1 gnd
C1  g6993_0 gnd 2.080806f
C2  g6993_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6993_0 1 2.224404
R2 1 g6993_1 2.224404
.ends

.subckt netg5393 g5393_1 g5393_0 gnd
C1  g5393_1 gnd 2.080806f
C2  g5393_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5393_0 1 2.224404
R2 1 g5393_1 2.224404
.ends

.subckt netg3566 g3566_1 g3566_0 gnd
C1  g3566_1 gnd 2.080806f
C2  g3566_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3566_0 2.224404
R2 1 g3566_1 2.224404
.ends

.subckt netg4441 g4441_1 g4441_0 gnd
C1  g4441_1 gnd 2.080806f
C2  g4441_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4441_0 2.224404
R2 1 g4441_1 2.224404
.ends

.subckt netg2827 g2827_0 g2827_1 gnd
C1  g2827_0 gnd 2.080806f
C2  g2827_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2827_0 1 2.224404
R2 1 g2827_1 2.224404
.ends

.subckt netg5021 g5021_2 g5021_0 gnd
C1  g5021_2 gnd 2.080806f
C2  g5021_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5021_0 2.224404
R2 g5021_2 1 2.224404
.ends

.subckt netg7010 g7010_0 g7010_1 gnd
C1  g7010_0 gnd 2.080806f
C2  g7010_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7010_0 1 2.224404
R2 1 g7010_1 2.224404
.ends

.subckt netx42 x42_1 x42_0 gnd
C1  x42_1 gnd 2.080806f
C2  x42_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x42_0 1 2.224404
R2 1 x42_1 2.224404
.ends

.subckt netg4109 g4109_0 g4109_1 gnd
C1  g4109_0 gnd 2.080806f
C2  g4109_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4109_0 2.224404
R2 1 g4109_1 2.224404
.ends

.subckt netg7387 g7387_0 g7387_1 gnd
C1  g7387_0 gnd 2.080806f
C2  g7387_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7387_0 1 2.224404
R2 1 g7387_1 2.224404
.ends

.subckt netg3561 g3561_0 g3561_1 gnd
C1  g3561_0 gnd 2.080806f
C2  g3561_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3561_0 2.224404
R2 g3561_1 1 2.224404
.ends

.subckt netg7355 g7355_1 g7355_0 gnd
C1  g7355_1 gnd 2.080806f
C2  g7355_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7355_0 2.224404
R2 g7355_1 1 2.224404
.ends

.subckt netg1514 g1514_1 g1514_0 gnd
C1  g1514_1 gnd 2.080806f
C2  g1514_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1514_0 2.224404
R2 g1514_1 1 2.224404
.ends

.subckt netg3970 g3970_0 g3970_1 gnd
C1  g3970_0 gnd 2.080806f
C2  g3970_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3970_0 2.224404
R2 1 g3970_1 2.224404
.ends

.subckt netg1512 g1512_0 g1512_1 gnd
C1  g1512_0 gnd 2.080806f
C2  g1512_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1512_0 1 2.224404
R2 g1512_1 1 2.224404
.ends

.subckt netg1379 g1379_1 g1379_0 gnd
C1  g1379_1 gnd 2.080806f
C2  g1379_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1379_0 2.224404
R2 g1379_1 1 2.224404
.ends

.subckt netg3050 g3050_0 g3050_1 gnd
C1  g3050_0 gnd 2.080806f
C2  g3050_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3050_0 2.224404
R2 g3050_1 1 2.224404
.ends

.subckt netg6661 g6661_0 g6661_1 gnd
C1  g6661_0 gnd 2.080806f
C2  g6661_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6661_0 2.224404
R2 g6661_1 1 2.224404
.ends

.subckt netg5535 g5535_2 g5535_1 g5535_0 gnd
C1  g5535_2 gnd 2.080806f
C2  g5535_1 gnd 2.080806f
C3  g5535_0 gnd 2.080806f
R1 g5535_0 g5535_1 2.224404
R2 g5535_1 g5535_2 2.224404
.ends

.subckt netg2689 g2689_0 g2689_1 g2689_2 gnd
C1  g2689_0 gnd 2.080806f
C2  g2689_1 gnd 2.080806f
C3  g2689_2 gnd 2.080806f
R1 g2689_0 g2689_1 2.224404
R2 g2689_2 g2689_1 2.224404
.ends

.subckt netg5237 g5237_1 g5237_0 gnd
C1  g5237_1 gnd 2.080806f
C2  g5237_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5237_0 1 2.224404
R2 1 g5237_1 2.224404
.ends

.subckt netg6676 g6676_1 g6676_0 gnd
C1  g6676_1 gnd 2.080806f
C2  g6676_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6676_0 2.224404
R2 g6676_1 1 2.224404
.ends

.subckt netg4224 g4224_0 g4224_1 gnd
C1  g4224_0 gnd 2.080806f
C2  g4224_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4224_0 1 2.224404
R2 g4224_1 1 2.224404
.ends

.subckt netg2841 g2841_1 g2841_0 gnd
C1  g2841_1 gnd 2.080806f
C2  g2841_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2841_0 1 2.224404
R2 1 g2841_1 2.224404
.ends

.subckt netg5426 g5426_0 g5426_1 gnd
C1  g5426_0 gnd 2.080806f
C2  g5426_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5426_0 1 2.224404
R2 g5426_1 1 2.224404
.ends

.subckt netg7292 g7292_1 g7292_0 gnd
C1  g7292_1 gnd 2.080806f
C2  g7292_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7292_0 2.224404
R2 1 g7292_1 2.224404
.ends

.subckt netg2831 g2831_0 g2831_1 gnd
C1  g2831_0 gnd 2.080806f
C2  g2831_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2831_0 2.224404
R2 g2831_1 1 2.224404
.ends

.subckt netg75 g75_1 g75_0 gnd
C1  g75_1 gnd 2.080806f
C2  g75_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g75_0 1 2.224404
R2 1 g75_1 2.224404
.ends

.subckt netg4427 g4427_0 g4427_1 gnd
C1  g4427_0 gnd 2.080806f
C2  g4427_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4427_0 1 2.224404
R2 g4427_1 1 2.224404
.ends

.subckt netg6209 g6209_0 g6209_1 gnd
C1  g6209_0 gnd 2.080806f
C2  g6209_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6209_0 2.224404
R2 g6209_1 1 2.224404
.ends

.subckt netg5962 g5962_0 g5962_1 gnd
C1  g5962_0 gnd 2.080806f
C2  g5962_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5962_0 1 2.224404
R2 1 g5962_1 2.224404
.ends

.subckt netx12 x12_1 x12_0 gnd
C1  x12_1 gnd 2.080806f
C2  x12_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x12_0 2.224404
R2 x12_1 1 2.224404
.ends

.subckt netg6666 g6666_1 g6666_0 gnd
C1  g6666_1 gnd 2.080806f
C2  g6666_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6666_0 1 2.224404
R2 1 g6666_1 2.224404
.ends

.subckt netg6133 g6133_0 g6133_1 gnd
C1  g6133_0 gnd 2.080806f
C2  g6133_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6133_0 2.224404
R2 g6133_1 1 2.224404
.ends

.subckt netg7187 g7187_0 g7187_1 gnd
C1  g7187_0 gnd 2.080806f
C2  g7187_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7187_0 1 2.224404
R2 1 g7187_1 2.224404
.ends

.subckt netg6892 g6892_1 g6892_0 gnd
C1  g6892_1 gnd 2.080806f
C2  g6892_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6892_0 2.224404
R2 g6892_1 1 2.224404
.ends

.subckt netg7078 g7078_0 g7078_1 gnd
C1  g7078_0 gnd 2.080806f
C2  g7078_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7078_0 1 2.224404
R2 1 g7078_1 2.224404
.ends

.subckt netg1549 g1549_1 g1549_0 gnd
C1  g1549_1 gnd 2.080806f
C2  g1549_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1549_0 1 2.224404
R2 1 g1549_1 2.224404
.ends

.subckt netg4453 g4453_1 g4453_0 gnd
C1  g4453_1 gnd 2.080806f
C2  g4453_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4453_0 1 2.224404
R2 1 g4453_1 2.224404
.ends

.subckt netg6734 g6734_1 g6734_0 gnd
C1  g6734_1 gnd 2.080806f
C2  g6734_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6734_0 2.224404
R2 g6734_1 1 2.224404
.ends

.subckt netg5457 g5457_1 g5457_0 gnd
C1  g5457_1 gnd 2.080806f
C2  g5457_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5457_0 1 2.224404
R2 g5457_1 1 2.224404
.ends

.subckt netg6411 g6411_1 g6411_0 gnd
C1  g6411_1 gnd 2.080806f
C2  g6411_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6411_0 2.224404
R2 g6411_1 1 2.224404
.ends

.subckt netg2453 g2453_0 g2453_2 g2453_1 gnd
C1  g2453_0 gnd 2.080806f
C2  g2453_2 gnd 2.080806f
C3  g2453_1 gnd 2.080806f
R1 g2453_0 g2453_1 2.224404
R2 g2453_2 g2453_0 2.224404
.ends

.subckt netg6468 g6468_0 g6468_1 gnd
C1  g6468_0 gnd 2.080806f
C2  g6468_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6468_0 1 2.224404
R2 1 g6468_1 2.224404
.ends

.subckt netg5265 g5265_0 g5265_1 gnd
C1  g5265_0 gnd 2.080806f
C2  g5265_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5265_0 2.224404
R2 g5265_1 1 2.224404
.ends

.subckt netg2803 g2803_1 g2803_0 gnd
C1  g2803_1 gnd 2.080806f
C2  g2803_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2803_0 2.224404
R2 1 g2803_1 2.224404
.ends

.subckt netg4668 g4668_1 g4668_0 gnd
C1  g4668_1 gnd 2.080806f
C2  g4668_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4668_0 2.224404
R2 1 g4668_1 2.224404
.ends

.subckt netg4305 g4305_1 g4305_0 gnd
C1  g4305_1 gnd 2.080806f
C2  g4305_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4305_0 2.224404
R2 g4305_1 1 2.224404
.ends

.subckt netg6036 g6036_1 g6036_0 gnd
C1  g6036_1 gnd 2.080806f
C2  g6036_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6036_0 2.224404
R2 g6036_1 1 2.224404
.ends

.subckt netg7402 g7402_0 g7402_1 gnd
C1  g7402_0 gnd 2.080806f
C2  g7402_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7402_0 2.224404
R2 g7402_1 1 2.224404
.ends

.subckt netg4246 g4246_1 g4246_0 gnd
C1  g4246_1 gnd 2.080806f
C2  g4246_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4246_0 1 2.224404
R2 1 g4246_1 2.224404
.ends

.subckt netg6273 g6273_0 g6273_1 gnd
C1  g6273_0 gnd 2.080806f
C2  g6273_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6273_0 1 2.224404
R2 g6273_1 1 2.224404
.ends

.subckt netg6449 g6449_0 g6449_1 gnd
C1  g6449_0 gnd 2.080806f
C2  g6449_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6449_0 2.224404
R2 g6449_1 1 2.224404
.ends

.subckt netg5602 g5602_0 g5602_1 gnd
C1  g5602_0 gnd 2.080806f
C2  g5602_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5602_0 1 2.224404
R2 1 g5602_1 2.224404
.ends

.subckt netg7417 g7417_2 g7417_1 g7417_0 gnd
C1  g7417_2 gnd 2.080806f
C2  g7417_1 gnd 2.080806f
C3  g7417_0 gnd 2.080806f
R1 g7417_0 g7417_1 2.224404
R2 g7417_1 g7417_2 2.224404
.ends

.subckt netg4362 g4362_2 g4362_1 gnd
C1  g4362_2 gnd 2.080806f
C2  g4362_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4362_2 1 2.224404
R2 1 g4362_1 2.224404
.ends

.subckt netg6155 g6155_1 g6155_2 g6155_0 gnd
C1  g6155_1 gnd 2.080806f
C2  g6155_2 gnd 2.080806f
C3  g6155_0 gnd 2.080806f
R1 g6155_0 g6155_1 2.224404
R2 g6155_2 g6155_0 2.224404
.ends

.subckt netg949 g949_0 g949_2 g949_1 gnd
C1  g949_0 gnd 2.080806f
C2  g949_2 gnd 2.080806f
C3  g949_1 gnd 2.080806f
R1 g949_1 g949_0 2.224404
R2 g949_0 g949_2 2.224404
.ends

.subckt netg7290 g7290_1 g7290_0 gnd
C1  g7290_1 gnd 2.080806f
C2  g7290_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7290_0 2.224404
R2 g7290_1 1 2.224404
.ends

.subckt netg7539 g7539_1 g7539_0 gnd
C1  g7539_1 gnd 2.080806f
C2  g7539_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7539_0 2.224404
R2 g7539_1 1 2.224404
.ends

.subckt netg5324 g5324_0 g5324_1 gnd
C1  g5324_0 gnd 2.080806f
C2  g5324_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5324_0 1 2.224404
R2 1 g5324_1 2.224404
.ends

.subckt netg6543 g6543_1 g6543_2 gnd
C1  g6543_1 gnd 2.080806f
C2  g6543_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6543_1 2.224404
R2 g6543_2 1 2.224404
.ends

.subckt netg3716 g3716_0 g3716_1 gnd
C1  g3716_0 gnd 2.080806f
C2  g3716_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3716_0 2.224404
R2 g3716_1 1 2.224404
.ends

.subckt netg6494 g6494_1 g6494_0 gnd
C1  g6494_1 gnd 2.080806f
C2  g6494_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6494_0 1 2.224404
R2 1 g6494_1 2.224404
.ends

.subckt netg6837 g6837_2 g6837_1 g6837_0 gnd
C1  g6837_2 gnd 2.080806f
C2  g6837_1 gnd 2.080806f
C3  g6837_0 gnd 2.080806f
R1 g6837_1 g6837_0 2.224404
R2 g6837_2 g6837_0 2.224404
.ends

.subckt netg6498 g6498_1 g6498_0 gnd
C1  g6498_1 gnd 2.080806f
C2  g6498_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6498_0 1 2.224404
R2 1 g6498_1 2.224404
.ends

.subckt netg4040 g4040_0 g4040_1 gnd
C1  g4040_0 gnd 2.080806f
C2  g4040_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4040_0 1 2.224404
R2 g4040_1 1 2.224404
.ends

.subckt netg5074 g5074_2 g5074_0 g5074_1 gnd
C1  g5074_2 gnd 2.080806f
C2  g5074_0 gnd 2.080806f
C3  g5074_1 gnd 2.080806f
R1 g5074_1 g5074_0 2.224404
R2 g5074_2 g5074_1 2.224404
.ends

.subckt netg6605 g6605_0 g6605_1 gnd
C1  g6605_0 gnd 2.080806f
C2  g6605_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6605_0 1 2.224404
R2 g6605_1 1 2.224404
.ends

.subckt netg6355 g6355_1 g6355_0 gnd
C1  g6355_1 gnd 2.080806f
C2  g6355_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6355_0 2.224404
R2 g6355_1 1 2.224404
.ends

.subckt netg3048 g3048_0 g3048_1 gnd
C1  g3048_0 gnd 2.080806f
C2  g3048_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3048_0 2.224404
R2 1 g3048_1 2.224404
.ends

.subckt netg6738 g6738_2 g6738_1 gnd
C1  g6738_2 gnd 2.080806f
C2  g6738_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6738_2 2.224404
R2 g6738_1 1 2.224404
.ends

.subckt netg7137 g7137_1 g7137_0 gnd
C1  g7137_1 gnd 2.080806f
C2  g7137_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7137_0 2.224404
R2 1 g7137_1 2.224404
.ends

.subckt netg6197 g6197_0 g6197_1 gnd
C1  g6197_0 gnd 2.080806f
C2  g6197_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6197_0 2.224404
R2 g6197_1 1 2.224404
.ends

.subckt netg4291 g4291_0 g4291_1 gnd
C1  g4291_0 gnd 2.080806f
C2  g4291_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4291_0 1 2.224404
R2 1 g4291_1 2.224404
.ends

.subckt netg4266 g4266_0 g4266_1 gnd
C1  g4266_0 gnd 2.080806f
C2  g4266_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4266_0 1 2.224404
R2 1 g4266_1 2.224404
.ends

.subckt netg777 g777_0 g777_2 g777_1 gnd
C1  g777_0 gnd 2.080806f
C2  g777_2 gnd 2.080806f
C3  g777_1 gnd 2.080806f
R1 g777_1 g777_0 2.224404
R2 g777_0 g777_2 2.224404
.ends

.subckt netg5427 g5427_1 g5427_0 gnd
C1  g5427_1 gnd 2.080806f
C2  g5427_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5427_0 1 2.224404
R2 1 g5427_1 2.224404
.ends

.subckt netg3503 g3503_0 g3503_1 gnd
C1  g3503_0 gnd 2.080806f
C2  g3503_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3503_0 1 2.224404
R2 1 g3503_1 2.224404
.ends

.subckt netg7199 g7199_1 g7199_0 gnd
C1  g7199_1 gnd 2.080806f
C2  g7199_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7199_0 2.224404
R2 g7199_1 1 2.224404
.ends

.subckt netg6251 g6251_1 g6251_2 gnd
C1  g6251_1 gnd 2.080806f
C2  g6251_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6251_2 1 2.224404
R2 g6251_1 1 2.224404
.ends

.subckt netg4064 g4064_0 g4064_1 gnd
C1  g4064_0 gnd 2.080806f
C2  g4064_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4064_0 2.224404
R2 1 g4064_1 2.224404
.ends

.subckt netg3520 g3520_0 g3520_1 gnd
C1  g3520_0 gnd 2.080806f
C2  g3520_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3520_0 1 2.224404
R2 1 g3520_1 2.224404
.ends

.subckt netg1937 g1937_0 g1937_1 gnd
C1  g1937_0 gnd 2.080806f
C2  g1937_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1937_0 2.224404
R2 1 g1937_1 2.224404
.ends

.subckt netg1362 g1362_1 g1362_0 gnd
C1  g1362_1 gnd 2.080806f
C2  g1362_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1362_0 1 2.224404
R2 1 g1362_1 2.224404
.ends

.subckt netg6487 g6487_1 g6487_0 gnd
C1  g6487_1 gnd 2.080806f
C2  g6487_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6487_0 2.224404
R2 g6487_1 1 2.224404
.ends

.subckt netg5481 g5481_1 g5481_0 gnd
C1  g5481_1 gnd 2.080806f
C2  g5481_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5481_0 2.224404
R2 g5481_1 1 2.224404
.ends

.subckt netg4218 g4218_1 g4218_0 gnd
C1  g4218_1 gnd 2.080806f
C2  g4218_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4218_0 2.224404
R2 g4218_1 1 2.224404
.ends

.subckt netg6108 g6108_1 g6108_0 gnd
C1  g6108_1 gnd 2.080806f
C2  g6108_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6108_0 1 2.224404
R2 1 g6108_1 2.224404
.ends

.subckt netg1429 g1429_1 g1429_0 gnd
C1  g1429_1 gnd 2.080806f
C2  g1429_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1429_0 1 2.224404
R2 1 g1429_1 2.224404
.ends

.subckt netg3404 g3404_2 g3404_1 g3404_0 gnd
C1  g3404_2 gnd 2.080806f
C2  g3404_1 gnd 2.080806f
C3  g3404_0 gnd 2.080806f
R1 g3404_1 g3404_0 2.224404
R2 g3404_0 g3404_2 2.224404
.ends

.subckt netg3906 g3906_1 g3906_0 gnd
C1  g3906_1 gnd 2.080806f
C2  g3906_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3906_0 1 2.224404
R2 1 g3906_1 2.224404
.ends

.subckt netg3435 g3435_1 g3435_0 g3435_2 gnd
C1  g3435_1 gnd 2.080806f
C2  g3435_0 gnd 2.080806f
C3  g3435_2 gnd 2.080806f
R1 g3435_0 g3435_1 2.224404
R2 g3435_2 g3435_0 2.224404
.ends

.subckt netg1258 g1258_1 g1258_0 gnd
C1  g1258_1 gnd 2.080806f
C2  g1258_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1258_0 2.224404
R2 1 g1258_1 2.224404
.ends

.subckt netg7169 g7169_1 g7169_0 gnd
C1  g7169_1 gnd 2.080806f
C2  g7169_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7169_0 1 2.224404
R2 g7169_1 1 2.224404
.ends

.subckt netg6308 g6308_1 g6308_0 gnd
C1  g6308_1 gnd 2.080806f
C2  g6308_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6308_0 2.224404
R2 g6308_1 1 2.224404
.ends

.subckt netg3383 g3383_0 g3383_2 g3383_1 gnd
C1  g3383_0 gnd 2.080806f
C2  g3383_2 gnd 2.080806f
C3  g3383_1 gnd 2.080806f
R1 g3383_0 g3383_1 2.224404
R2 g3383_1 g3383_2 2.224404
.ends

.subckt netg4426 g4426_0 g4426_1 gnd
C1  g4426_0 gnd 2.080806f
C2  g4426_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4426_0 1 2.224404
R2 1 g4426_1 2.224404
.ends

.subckt netg6512 g6512_0 g6512_1 gnd
C1  g6512_0 gnd 2.080806f
C2  g6512_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6512_0 1 2.224404
R2 1 g6512_1 2.224404
.ends

.subckt netg4207 g4207_0 g4207_1 gnd
C1  g4207_0 gnd 2.080806f
C2  g4207_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4207_0 1 2.224404
R2 1 g4207_1 2.224404
.ends

.subckt netg6847 g6847_0 g6847_1 g6847_2 gnd
C1  g6847_0 gnd 2.080806f
C2  g6847_1 gnd 2.080806f
C3  g6847_2 gnd 2.080806f
R1 g6847_0 g6847_1 2.224404
R2 g6847_1 g6847_2 2.224404
.ends

.subckt netg7390 g7390_0 g7390_1 gnd
C1  g7390_0 gnd 2.080806f
C2  g7390_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7390_0 2.224404
R2 g7390_1 1 2.224404
.ends

.subckt netg4454 g4454_1 g4454_0 gnd
C1  g4454_1 gnd 2.080806f
C2  g4454_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4454_0 1 2.224404
R2 1 g4454_1 2.224404
.ends

.subckt netg4221 g4221_0 g4221_1 gnd
C1  g4221_0 gnd 2.080806f
C2  g4221_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4221_0 1 2.224404
R2 g4221_1 1 2.224404
.ends

.subckt netg3972 g3972_1 g3972_0 gnd
C1  g3972_1 gnd 2.080806f
C2  g3972_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3972_0 1 2.224404
R2 g3972_1 1 2.224404
.ends

.subckt netg6463 g6463_0 g6463_1 gnd
C1  g6463_0 gnd 2.080806f
C2  g6463_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6463_0 1 2.224404
R2 1 g6463_1 2.224404
.ends

.subckt netg1356 g1356_1 g1356_0 gnd
C1  g1356_1 gnd 2.080806f
C2  g1356_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1356_0 1 2.224404
R2 1 g1356_1 2.224404
.ends

.subckt netg6675 g6675_0 g6675_1 gnd
C1  g6675_0 gnd 2.080806f
C2  g6675_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6675_0 2.224404
R2 g6675_1 1 2.224404
.ends

.subckt netg7215 g7215_1 g7215_0 gnd
C1  g7215_1 gnd 2.080806f
C2  g7215_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7215_0 1 2.224404
R2 g7215_1 1 2.224404
.ends

.subckt netg439 g439_2 g439_1 gnd
C1  g439_2 gnd 2.080806f
C2  g439_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g439_2 1 2.224404
R2 1 g439_1 2.224404
.ends

.subckt netg2462 g2462_2 g2462_1 gnd
C1  g2462_2 gnd 2.080806f
C2  g2462_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2462_1 2.224404
R2 g2462_2 1 2.224404
.ends

.subckt netg1136 g1136_1 g1136_0 gnd
C1  g1136_1 gnd 2.080806f
C2  g1136_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1136_0 2.224404
R2 g1136_1 1 2.224404
.ends

.subckt netg6196 g6196_0 g6196_1 gnd
C1  g6196_0 gnd 2.080806f
C2  g6196_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6196_0 1 2.224404
R2 1 g6196_1 2.224404
.ends

.subckt netg5294 g5294_0 g5294_1 gnd
C1  g5294_0 gnd 2.080806f
C2  g5294_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5294_0 2.224404
R2 g5294_1 1 2.224404
.ends

.subckt netg4339 g4339_1 g4339_0 gnd
C1  g4339_1 gnd 2.080806f
C2  g4339_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4339_0 2.224404
R2 g4339_1 1 2.224404
.ends

.subckt netg4425 g4425_1 g4425_0 gnd
C1  g4425_1 gnd 2.080806f
C2  g4425_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4425_0 1 2.224404
R2 1 g4425_1 2.224404
.ends

.subckt netg6728 g6728_1 g6728_0 gnd
C1  g6728_1 gnd 2.080806f
C2  g6728_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6728_0 1 2.224404
R2 1 g6728_1 2.224404
.ends

.subckt netg6890 g6890_0 g6890_1 gnd
C1  g6890_0 gnd 2.080806f
C2  g6890_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6890_0 1 2.224404
R2 1 g6890_1 2.224404
.ends

.subckt netg1589 g1589_0 g1589_1 gnd
C1  g1589_0 gnd 2.080806f
C2  g1589_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1589_0 2.224404
R2 g1589_1 1 2.224404
.ends

.subckt netg4248 g4248_1 g4248_0 gnd
C1  g4248_1 gnd 2.080806f
C2  g4248_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4248_0 2.224404
R2 g4248_1 1 2.224404
.ends

.subckt netg3231 g3231_1 g3231_2 g3231_0 gnd
C1  g3231_1 gnd 2.080806f
C2  g3231_2 gnd 2.080806f
C3  g3231_0 gnd 2.080806f
R1 g3231_0 g3231_2 2.224404
R2 g3231_2 g3231_1 2.224404
.ends

.subckt netg3228 g3228_2 g3228_1 g3228_0 gnd
C1  g3228_2 gnd 2.080806f
C2  g3228_1 gnd 2.080806f
C3  g3228_0 gnd 2.080806f
R1 g3228_0 g3228_1 2.224404
R2 g3228_1 g3228_2 2.224404
.ends

.subckt netg6872 g6872_0 g6872_1 gnd
C1  g6872_0 gnd 2.080806f
C2  g6872_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6872_0 2.224404
R2 g6872_1 1 2.224404
.ends

.subckt netg4991 g4991_0 g4991_2 g4991_1 gnd
C1  g4991_0 gnd 2.080806f
C2  g4991_2 gnd 2.080806f
C3  g4991_1 gnd 2.080806f
R1 g4991_0 g4991_1 2.224404
R2 g4991_2 g4991_0 2.224404
.ends

.subckt netg1924 g1924_1 g1924_0 gnd
C1  g1924_1 gnd 2.080806f
C2  g1924_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1924_0 1 2.224404
R2 g1924_1 1 2.224404
.ends

.subckt netg994 g994_1 g994_0 g994_2 gnd
C1  g994_1 gnd 2.080806f
C2  g994_0 gnd 2.080806f
C3  g994_2 gnd 2.080806f
R1 g994_0 g994_1 2.224404
R2 g994_2 g994_0 2.224404
.ends

.subckt netg988 g988_1 g988_2 gnd
C1  g988_1 gnd 2.080806f
C2  g988_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g988_2 2.224404
R2 1 g988_1 2.224404
.ends

.subckt netg6066 g6066_0 g6066_1 gnd
C1  g6066_0 gnd 2.080806f
C2  g6066_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6066_0 1 2.224404
R2 1 g6066_1 2.224404
.ends

.subckt netg1220 g1220_0 g1220_1 gnd
C1  g1220_0 gnd 2.080806f
C2  g1220_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1220_0 1 2.224404
R2 1 g1220_1 2.224404
.ends

.subckt netg5983 g5983_0 g5983_1 gnd
C1  g5983_0 gnd 2.080806f
C2  g5983_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5983_0 1 2.224404
R2 g5983_1 1 2.224404
.ends

.subckt netg6334 g6334_1 g6334_0 gnd
C1  g6334_1 gnd 2.080806f
C2  g6334_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6334_0 2.224404
R2 g6334_1 1 2.224404
.ends

.subckt netg7108 g7108_0 g7108_1 gnd
C1  g7108_0 gnd 2.080806f
C2  g7108_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7108_0 2.224404
R2 g7108_1 1 2.224404
.ends

.subckt netg1237 g1237_1 g1237_0 gnd
C1  g1237_1 gnd 2.080806f
C2  g1237_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1237_0 2.224404
R2 g1237_1 1 2.224404
.ends

.subckt netg620 g620_1 g620_0 gnd
C1  g620_1 gnd 2.080806f
C2  g620_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g620_0 1 2.224404
R2 g620_1 1 2.224404
.ends

.subckt netg4994 g4994_0 g4994_2 gnd
C1  g4994_0 gnd 2.080806f
C2  g4994_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4994_0 1 2.224404
R2 g4994_2 1 2.224404
.ends

.subckt netg6588 g6588_1 g6588_0 gnd
C1  g6588_1 gnd 2.080806f
C2  g6588_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6588_0 1 2.224404
R2 1 g6588_1 2.224404
.ends

.subckt netg5560 g5560_2 g5560_1 gnd
C1  g5560_2 gnd 2.080806f
C2  g5560_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5560_2 1 2.224404
R2 1 g5560_1 2.224404
.ends

.subckt netx411 x411_1 x411_0 gnd
C1  x411_1 gnd 2.080806f
C2  x411_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x411_0 2.224404
R2 1 x411_1 2.224404
.ends

.subckt netg4107 g4107_1 g4107_0 gnd
C1  g4107_1 gnd 2.080806f
C2  g4107_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4107_0 2.224404
R2 g4107_1 1 2.224404
.ends

.subckt netg5329 g5329_1 g5329_0 gnd
C1  g5329_1 gnd 2.080806f
C2  g5329_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5329_0 2.224404
R2 1 g5329_1 2.224404
.ends

.subckt netg5906 g5906_0 g5906_1 g5906_2 gnd
C1  g5906_0 gnd 2.080806f
C2  g5906_1 gnd 2.080806f
C3  g5906_2 gnd 2.080806f
R1 g5906_1 g5906_0 2.224404
R2 g5906_0 g5906_2 2.224404
.ends

.subckt netg2807 g2807_1 g2807_0 gnd
C1  g2807_1 gnd 2.080806f
C2  g2807_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2807_0 2.224404
R2 g2807_1 1 2.224404
.ends

.subckt netg7083 g7083_1 g7083_0 gnd
C1  g7083_1 gnd 2.080806f
C2  g7083_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7083_0 2.224404
R2 g7083_1 1 2.224404
.ends

.subckt netg3327 g3327_2 g3327_0 g3327_1 gnd
C1  g3327_2 gnd 2.080806f
C2  g3327_0 gnd 2.080806f
C3  g3327_1 gnd 2.080806f
R1 g3327_1 g3327_0 2.224404
R2 g3327_2 g3327_1 2.224404
.ends

.subckt netg4939 g4939_1 g4939_0 gnd
C1  g4939_1 gnd 2.080806f
C2  g4939_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4939_0 1 2.224404
R2 1 g4939_1 2.224404
.ends

.subckt netg997 g997_1 g997_2 g997_0 gnd
C1  g997_1 gnd 2.080806f
C2  g997_2 gnd 2.080806f
C3  g997_0 gnd 2.080806f
R1 g997_2 g997_0 2.224404
R2 g997_2 g997_1 2.224404
.ends

.subckt netg2465 g2465_1 g2465_2 gnd
C1  g2465_1 gnd 2.080806f
C2  g2465_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2465_2 1 2.224404
R2 1 g2465_1 2.224404
.ends

.subckt netg4446 g4446_0 g4446_1 gnd
C1  g4446_0 gnd 2.080806f
C2  g4446_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4446_0 1 2.224404
R2 1 g4446_1 2.224404
.ends

.subckt netg1304 g1304_1 g1304_0 gnd
C1  g1304_1 gnd 2.080806f
C2  g1304_0 gnd 2.080806f
.ends

.subckt netx252 x252_1 x252_0 gnd
C1  x252_1 gnd 2.080806f
C2  x252_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x252_0 1 2.224404
R2 1 x252_1 2.224404
.ends

.subckt netg7231 g7231_2 g7231_0 gnd
C1  g7231_2 gnd 2.080806f
C2  g7231_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7231_0 2.224404
R2 1 g7231_2 2.224404
.ends

.subckt netg6488 g6488_0 g6488_1 gnd
C1  g6488_0 gnd 2.080806f
C2  g6488_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6488_0 1 2.224404
R2 1 g6488_1 2.224404
.ends

.subckt netg3392 g3392_2 g3392_0 g3392_1 gnd
C1  g3392_2 gnd 2.080806f
C2  g3392_0 gnd 2.080806f
C3  g3392_1 gnd 2.080806f
R1 g3392_0 g3392_2 2.224404
R2 g3392_2 g3392_1 2.224404
.ends

.subckt netg485 g485_0 g485_1 gnd
C1  g485_0 gnd 2.080806f
C2  g485_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g485_0 2.224404
R2 g485_1 1 2.224404
.ends

.subckt netg3530 g3530_1 g3530_0 gnd
C1  g3530_1 gnd 2.080806f
C2  g3530_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3530_0 2.224404
R2 g3530_1 1 2.224404
.ends

.subckt netg4435 g4435_1 g4435_0 gnd
C1  g4435_1 gnd 2.080806f
C2  g4435_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4435_0 2.224404
R2 g4435_1 1 2.224404
.ends

.subckt netg3479 g3479_1 g3479_0 gnd
C1  g3479_1 gnd 2.080806f
C2  g3479_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3479_0 1 2.224404
R2 1 g3479_1 2.224404
.ends

.subckt netg5875 g5875_1 g5875_2 g5875_0 gnd
C1  g5875_1 gnd 2.080806f
C2  g5875_2 gnd 2.080806f
C3  g5875_0 gnd 2.080806f
R1 g5875_0 g5875_2 2.224404
R2 g5875_2 g5875_1 2.224404
.ends

.subckt netg3984 g3984_1 g3984_0 gnd
C1  g3984_1 gnd 2.080806f
C2  g3984_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3984_0 1 2.224404
R2 1 g3984_1 2.224404
.ends

.subckt netx532 x532_0 x532_1 gnd
C1  x532_0 gnd 2.080806f
C2  x532_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x532_0 2.224404
R2 x532_1 1 2.224404
.ends

.subckt netg6039 g6039_1 g6039_0 gnd
C1  g6039_1 gnd 2.080806f
C2  g6039_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6039_0 1 2.224404
R2 1 g6039_1 2.224404
.ends

.subckt netg6664 g6664_0 g6664_1 gnd
C1  g6664_0 gnd 2.080806f
C2  g6664_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6664_0 1 2.224404
R2 1 g6664_1 2.224404
.ends

.subckt netg7531 g7531_1 g7531_0 gnd
C1  g7531_1 gnd 2.080806f
C2  g7531_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7531_0 1 2.224404
R2 1 g7531_1 2.224404
.ends

.subckt netg7105 g7105_1 g7105_0 gnd
C1  g7105_1 gnd 2.080806f
C2  g7105_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7105_0 2.224404
R2 g7105_1 1 2.224404
.ends

.subckt netg2996 g2996_1 g2996_0 gnd
C1  g2996_1 gnd 2.080806f
C2  g2996_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2996_0 1 2.224404
R2 1 g2996_1 2.224404
.ends

.subckt netg1366 g1366_0 g1366_2 g1366_1 gnd
C1  g1366_0 gnd 2.080806f
C2  g1366_2 gnd 2.080806f
C3  g1366_1 gnd 2.080806f
R1 g1366_0 g1366_1 2.224404
R2 g1366_1 g1366_2 2.224404
.ends

.subckt netg4307 g4307_0 g4307_1 gnd
C1  g4307_0 gnd 2.080806f
C2  g4307_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4307_0 1 2.224404
R2 1 g4307_1 2.224404
.ends

.subckt netg3401 g3401_0 g3401_1 g3401_2 gnd
C1  g3401_0 gnd 2.080806f
C2  g3401_1 gnd 2.080806f
C3  g3401_2 gnd 2.080806f
R1 g3401_0 g3401_1 2.224404
R2 g3401_2 g3401_0 2.224404
.ends

.subckt netg1498 g1498_1 g1498_0 gnd
C1  g1498_1 gnd 2.080806f
C2  g1498_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1498_0 1 2.224404
R2 1 g1498_1 2.224404
.ends

.subckt netg7384 g7384_0 g7384_1 gnd
C1  g7384_0 gnd 2.080806f
C2  g7384_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7384_0 1 2.224404
R2 1 g7384_1 2.224404
.ends

.subckt netg5959 g5959_0 g5959_1 gnd
C1  g5959_0 gnd 2.080806f
C2  g5959_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5959_0 1 2.224404
R2 1 g5959_1 2.224404
.ends

.subckt netg3917 g3917_0 g3917_1 gnd
C1  g3917_0 gnd 2.080806f
C2  g3917_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3917_0 1 2.224404
R2 g3917_1 1 2.224404
.ends

.subckt netg2946 g2946_1 g2946_0 gnd
C1  g2946_1 gnd 2.080806f
C2  g2946_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2946_0 1 2.224404
R2 1 g2946_1 2.224404
.ends

.subckt netg2767 g2767_1 g2767_0 gnd
C1  g2767_1 gnd 2.080806f
C2  g2767_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2767_0 1 2.224404
R2 1 g2767_1 2.224404
.ends

.subckt netg407 g407_0 g407_1 g407_2 gnd
C1  g407_0 gnd 2.080806f
C2  g407_1 gnd 2.080806f
C3  g407_2 gnd 2.080806f
R1 g407_0 g407_1 2.224404
R2 g407_2 g407_0 2.224404
.ends

.subckt netg5608 g5608_0 g5608_1 gnd
C1  g5608_0 gnd 2.080806f
C2  g5608_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5608_0 1 2.224404
R2 1 g5608_1 2.224404
.ends

.subckt netg6822 g6822_0 g6822_1 gnd
C1  g6822_0 gnd 2.080806f
C2  g6822_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6822_0 2.224404
R2 g6822_1 1 2.224404
.ends

.subckt netg678 g678_0 g678_2 gnd
C1  g678_0 gnd 2.080806f
C2  g678_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g678_0 2.224404
R2 g678_2 1 2.224404
.ends

.subckt netg6614 g6614_0 g6614_1 gnd
C1  g6614_0 gnd 2.080806f
C2  g6614_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6614_0 2.224404
R2 g6614_1 1 2.224404
.ends

.subckt netx41 x41_1 x41_0 gnd
C1  x41_1 gnd 2.080806f
C2  x41_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x41_0 1 2.224404
R2 1 x41_1 2.224404
.ends

.subckt netg877 g877_1 g877_2 gnd
C1  g877_1 gnd 2.080806f
C2  g877_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g877_1 2.224404
R2 g877_2 1 2.224404
.ends

.subckt netg2814 g2814_1 g2814_0 gnd
C1  g2814_1 gnd 2.080806f
C2  g2814_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2814_0 1 2.224404
R2 1 g2814_1 2.224404
.ends

.subckt netg6009 g6009_0 g6009_1 gnd
C1  g6009_0 gnd 2.080806f
C2  g6009_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6009_0 1 2.224404
R2 1 g6009_1 2.224404
.ends

.subckt netg7251 g7251_0 g7251_1 gnd
C1  g7251_0 gnd 2.080806f
C2  g7251_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7251_0 2.224404
R2 g7251_1 1 2.224404
.ends

.subckt netg2746 g2746_1 g2746_0 gnd
C1  g2746_1 gnd 2.080806f
C2  g2746_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2746_0 1 2.224404
R2 1 g2746_1 2.224404
.ends

.subckt netg5566 g5566_1 g5566_0 g5566_2 gnd
C1  g5566_1 gnd 2.080806f
C2  g5566_0 gnd 2.080806f
C3  g5566_2 gnd 2.080806f
R1 g5566_0 g5566_1 2.224404
R2 g5566_2 g5566_0 2.224404
.ends

.subckt netg7177 g7177_1 g7177_2 gnd
C1  g7177_1 gnd 2.080806f
C2  g7177_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7177_2 1 2.224404
R2 g7177_1 1 2.224404
.ends

.subckt netg6311 g6311_1 g6311_0 gnd
C1  g6311_1 gnd 2.080806f
C2  g6311_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6311_0 2.224404
R2 1 g6311_1 2.224404
.ends

.subckt netg2926 g2926_0 g2926_1 gnd
C1  g2926_0 gnd 2.080806f
C2  g2926_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2926_0 2.224404
R2 1 g2926_1 2.224404
.ends

.subckt netx531 x531_0 x531_1 gnd
C1  x531_0 gnd 2.080806f
C2  x531_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x531_0 2.224404
R2 x531_1 1 2.224404
.ends

.subckt netg7401 g7401_1 g7401_0 gnd
C1  g7401_1 gnd 2.080806f
C2  g7401_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7401_0 2.224404
R2 g7401_1 1 2.224404
.ends

.subckt netg1233 g1233_1 g1233_0 gnd
C1  g1233_1 gnd 2.080806f
C2  g1233_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1233_0 2.224404
R2 g1233_1 1 2.224404
.ends

.subckt netg5777 g5777_0 g5777_1 gnd
C1  g5777_0 gnd 2.080806f
C2  g5777_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5777_0 1 2.224404
R2 g5777_1 1 2.224404
.ends

.subckt netg7398 g7398_1 g7398_0 gnd
C1  g7398_1 gnd 2.080806f
C2  g7398_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7398_0 1 2.224404
R2 g7398_1 1 2.224404
.ends

.subckt netg5887 g5887_1 g5887_2 gnd
C1  g5887_1 gnd 2.080806f
C2  g5887_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5887_2 1 2.224404
R2 1 g5887_1 2.224404
.ends

.subckt netg3450 g3450_1 g3450_2 gnd
C1  g3450_1 gnd 2.080806f
C2  g3450_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3450_2 1 2.224404
R2 1 g3450_1 2.224404
.ends

.subckt netg6364 g6364_1 g6364_0 gnd
C1  g6364_1 gnd 2.080806f
C2  g6364_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6364_0 2.224404
R2 g6364_1 1 2.224404
.ends

.subckt netg2954 g2954_1 g2954_0 gnd
C1  g2954_1 gnd 2.080806f
C2  g2954_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2954_0 1 2.224404
R2 1 g2954_1 2.224404
.ends

.subckt netg6691 g6691_1 g6691_0 gnd
C1  g6691_1 gnd 2.080806f
C2  g6691_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6691_0 2.224404
R2 g6691_1 1 2.224404
.ends

.subckt netg1303 g1303_0 g1303_1 gnd
C1  g1303_0 gnd 2.080806f
C2  g1303_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1303_0 2.224404
R2 g1303_1 1 2.224404
.ends

.subckt netg1155 g1155_1 g1155_0 gnd
C1  g1155_1 gnd 2.080806f
C2  g1155_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1155_0 2.224404
R2 g1155_1 1 2.224404
.ends

.subckt netg5532 g5532_2 g5532_1 g5532_0 gnd
C1  g5532_2 gnd 2.080806f
C2  g5532_1 gnd 2.080806f
C3  g5532_0 gnd 2.080806f
R1 g5532_2 g5532_0 2.224404
R2 g5532_1 g5532_2 2.224404
.ends

.subckt netg5006 g5006_1 g5006_2 gnd
C1  g5006_1 gnd 2.080806f
C2  g5006_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5006_1 2.224404
R2 g5006_2 1 2.224404
.ends

.subckt netg1994 g1994_1 g1994_0 gnd
C1  g1994_1 gnd 2.080806f
C2  g1994_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1994_0 1 2.224404
R2 g1994_1 1 2.224404
.ends

.subckt netg5363 g5363_0 g5363_1 gnd
C1  g5363_0 gnd 2.080806f
C2  g5363_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5363_0 1 2.224404
R2 1 g5363_1 2.224404
.ends

.subckt netg2028 g2028_1 g2028_0 gnd
C1  g2028_1 gnd 2.080806f
C2  g2028_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2028_0 1 2.224404
R2 g2028_1 1 2.224404
.ends

.subckt netg7090 g7090_0 g7090_1 gnd
C1  g7090_0 gnd 2.080806f
C2  g7090_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7090_0 2.224404
R2 g7090_1 1 2.224404
.ends

.subckt netg2222 g2222_1 g2222_0 gnd
C1  g2222_1 gnd 2.080806f
C2  g2222_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2222_0 1 2.224404
R2 1 g2222_1 2.224404
.ends

.subckt netg5931 g5931_1 g5931_0 gnd
C1  g5931_1 gnd 2.080806f
C2  g5931_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5931_0 2.224404
R2 g5931_1 1 2.224404
.ends

.subckt netg6973 g6973_0 g6973_1 gnd
C1  g6973_0 gnd 2.080806f
C2  g6973_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6973_0 2.224404
R2 g6973_1 1 2.224404
.ends

.subckt netg4179 g4179_1 g4179_2 gnd
C1  g4179_1 gnd 2.080806f
C2  g4179_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4179_2 1 2.224404
R2 1 g4179_1 2.224404
.ends

.subckt netg6933 g6933_0 g6933_1 gnd
C1  g6933_0 gnd 2.080806f
C2  g6933_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6933_0 1 2.224404
R2 g6933_1 1 2.224404
.ends

.subckt netg1383 g1383_0 g1383_1 gnd
C1  g1383_0 gnd 2.080806f
C2  g1383_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1383_0 2.224404
R2 1 g1383_1 2.224404
.ends

.subckt netx301 x301_0 x301_1 gnd
C1  x301_0 gnd 2.080806f
C2  x301_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x301_0 2.224404
R2 x301_1 1 2.224404
.ends

.subckt netg3420 g3420_1 g3420_2 gnd
C1  g3420_1 gnd 2.080806f
C2  g3420_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3420_1 1 2.224404
R2 1 g3420_2 2.224404
.ends

.subckt netg2771 g2771_1 g2771_0 gnd
C1  g2771_1 gnd 2.080806f
C2  g2771_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2771_0 2.224404
R2 g2771_1 1 2.224404
.ends

.subckt netg517 g517_1 g517_0 gnd
C1  g517_1 gnd 2.080806f
C2  g517_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g517_0 2.224404
R2 g517_1 1 2.224404
.ends

.subckt netg2438 g2438_1 g2438_0 g2438_2 gnd
C1  g2438_1 gnd 2.080806f
C2  g2438_0 gnd 2.080806f
C3  g2438_2 gnd 2.080806f
R1 g2438_0 g2438_2 2.224404
R2 g2438_2 g2438_1 2.224404
.ends

.subckt netg2233 g2233_1 g2233_0 gnd
C1  g2233_1 gnd 2.080806f
C2  g2233_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2233_0 1 2.224404
R2 g2233_1 1 2.224404
.ends

.subckt netg5463 g5463_1 g5463_0 gnd
C1  g5463_1 gnd 2.080806f
C2  g5463_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5463_0 1 2.224404
R2 1 g5463_1 2.224404
.ends

.subckt netg2925 g2925_1 g2925_0 gnd
C1  g2925_1 gnd 2.080806f
C2  g2925_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2925_0 2.224404
R2 g2925_1 1 2.224404
.ends

.subckt netg7126 g7126_1 g7126_0 gnd
C1  g7126_1 gnd 2.080806f
C2  g7126_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7126_0 2.224404
R2 g7126_1 1 2.224404
.ends

.subckt netg6391 g6391_1 g6391_0 gnd
C1  g6391_1 gnd 2.080806f
C2  g6391_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6391_0 2.224404
R2 g6391_1 1 2.224404
.ends

.subckt netg4356 g4356_0 g4356_1 gnd
C1  g4356_0 gnd 2.080806f
C2  g4356_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4356_0 2.224404
R2 g4356_1 1 2.224404
.ends

.subckt netg7537 g7537_1 g7537_0 gnd
C1  g7537_1 gnd 2.080806f
C2  g7537_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7537_0 1 2.224404
R2 1 g7537_1 2.224404
.ends

.subckt netx152 x152_0 x152_1 gnd
C1  x152_0 gnd 2.080806f
C2  x152_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x152_0 2.224404
R2 x152_1 1 2.224404
.ends

.subckt netg3558 g3558_1 g3558_0 gnd
C1  g3558_1 gnd 2.080806f
C2  g3558_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3558_0 2.224404
R2 g3558_1 1 2.224404
.ends

.subckt netg4270 g4270_0 g4270_1 gnd
C1  g4270_0 gnd 2.080806f
C2  g4270_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4270_0 2.224404
R2 g4270_1 1 2.224404
.ends

.subckt netg7011 g7011_1 g7011_0 gnd
C1  g7011_1 gnd 2.080806f
C2  g7011_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7011_0 1 2.224404
R2 1 g7011_1 2.224404
.ends

.subckt netg862 g862_2 g862_0 g862_1 gnd
C1  g862_2 gnd 2.080806f
C2  g862_0 gnd 2.080806f
C3  g862_1 gnd 2.080806f
R1 g862_1 g862_0 2.224404
R2 g862_0 g862_2 2.224404
.ends

.subckt netg7394 g7394_1 g7394_0 gnd
C1  g7394_1 gnd 2.080806f
C2  g7394_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7394_0 1 2.224404
R2 1 g7394_1 2.224404
.ends

.subckt netg4440 g4440_1 g4440_0 gnd
C1  g4440_1 gnd 2.080806f
C2  g4440_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4440_0 2.224404
R2 g4440_1 1 2.224404
.ends

.subckt netg6663 g6663_0 g6663_1 gnd
C1  g6663_0 gnd 2.080806f
C2  g6663_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6663_0 1 2.224404
R2 1 g6663_1 2.224404
.ends

.subckt netg5346 g5346_0 g5346_1 gnd
C1  g5346_0 gnd 2.080806f
C2  g5346_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5346_0 1 2.224404
R2 1 g5346_1 2.224404
.ends

.subckt netg7538 g7538_0 g7538_1 gnd
C1  g7538_0 gnd 2.080806f
C2  g7538_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7538_0 1 2.224404
R2 1 g7538_1 2.224404
.ends

.subckt netg2737 g2737_1 g2737_2 g2737_0 gnd
C1  g2737_1 gnd 2.080806f
C2  g2737_2 gnd 2.080806f
C3  g2737_0 gnd 2.080806f
R1 g2737_0 g2737_1 2.224404
R2 g2737_2 g2737_0 2.224404
.ends

.subckt netg3258 g3258_2 g3258_1 g3258_0 gnd
C1  g3258_2 gnd 2.080806f
C2  g3258_1 gnd 2.080806f
C3  g3258_0 gnd 2.080806f
R1 g3258_1 g3258_0 2.224404
R2 g3258_0 g3258_2 2.224404
.ends

.subckt netg6187 g6187_0 g6187_1 gnd
C1  g6187_0 gnd 2.080806f
C2  g6187_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6187_0 1 2.224404
R2 1 g6187_1 2.224404
.ends

.subckt netg1550 g1550_0 g1550_1 gnd
C1  g1550_0 gnd 2.080806f
C2  g1550_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1550_0 1 2.224404
R2 1 g1550_1 2.224404
.ends

.subckt netg2799 g2799_0 g2799_1 gnd
C1  g2799_0 gnd 2.080806f
C2  g2799_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2799_0 1 2.224404
R2 1 g2799_1 2.224404
.ends

.subckt netg5263 g5263_1 g5263_0 gnd
C1  g5263_1 gnd 2.080806f
C2  g5263_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5263_0 1 2.224404
R2 1 g5263_1 2.224404
.ends

.subckt netg7324 g7324_2 g7324_1 gnd
C1  g7324_2 gnd 2.080806f
C2  g7324_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7324_1 2.224404
R2 g7324_2 1 2.224404
.ends

.subckt netg4979 g4979_2 g4979_0 g4979_1 gnd
C1  g4979_2 gnd 2.080806f
C2  g4979_0 gnd 2.080806f
C3  g4979_1 gnd 2.080806f
R1 g4979_0 g4979_2 2.224404
R2 g4979_1 g4979_2 2.224404
.ends

.subckt netg3571 g3571_0 g3571_1 gnd
C1  g3571_0 gnd 2.080806f
C2  g3571_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3571_0 1 2.224404
R2 1 g3571_1 2.224404
.ends

.subckt netg4101 g4101_1 g4101_0 gnd
C1  g4101_1 gnd 2.080806f
C2  g4101_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4101_0 2.224404
R2 g4101_1 1 2.224404
.ends

.subckt netg5110 g5110_0 g5110_2 g5110_1 gnd
C1  g5110_0 gnd 2.080806f
C2  g5110_2 gnd 2.080806f
C3  g5110_1 gnd 2.080806f
R1 g5110_0 g5110_1 2.224404
R2 g5110_1 g5110_2 2.224404
.ends

.subckt netg4935 g4935_0 g4935_2 g4935_1 gnd
C1  g4935_0 gnd 2.080806f
C2  g4935_2 gnd 2.080806f
C3  g4935_1 gnd 2.080806f
R1 g4935_0 g4935_1 2.224404
R2 g4935_2 g4935_0 2.224404
.ends

.subckt netg7352 g7352_0 g7352_1 gnd
C1  g7352_0 gnd 2.080806f
C2  g7352_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7352_0 1 2.224404
R2 1 g7352_1 2.224404
.ends

.subckt netg6332 g6332_1 g6332_0 gnd
C1  g6332_1 gnd 2.080806f
C2  g6332_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6332_0 2.224404
R2 g6332_1 1 2.224404
.ends

.subckt netg3476 g3476_1 g3476_0 gnd
C1  g3476_1 gnd 2.080806f
C2  g3476_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3476_0 1 2.224404
R2 1 g3476_1 2.224404
.ends

.subckt netg3066 g3066_1 g3066_0 gnd
C1  g3066_1 gnd 2.080806f
C2  g3066_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3066_0 1 2.224404
R2 1 g3066_1 2.224404
.ends

.subckt netg3047 g3047_0 g3047_1 gnd
C1  g3047_0 gnd 2.080806f
C2  g3047_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3047_0 1 2.224404
R2 1 g3047_1 2.224404
.ends

.subckt netg4015 g4015_0 g4015_1 gnd
C1  g4015_0 gnd 2.080806f
C2  g4015_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4015_0 1 2.224404
R2 1 g4015_1 2.224404
.ends

.subckt netg2772 g2772_1 g2772_0 gnd
C1  g2772_1 gnd 2.080806f
C2  g2772_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2772_0 2.224404
R2 g2772_1 1 2.224404
.ends

.subckt netg2750 g2750_0 g2750_1 gnd
C1  g2750_0 gnd 2.080806f
C2  g2750_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2750_0 2.224404
R2 g2750_1 1 2.224404
.ends

.subckt netg5683 g5683_1 g5683_0 gnd
C1  g5683_1 gnd 2.080806f
C2  g5683_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5683_0 1 2.224404
R2 g5683_1 1 2.224404
.ends

.subckt netg2606 g2606_2 g2606_0 gnd
C1  g2606_2 gnd 2.080806f
C2  g2606_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2606_0 2.224404
R2 g2606_2 1 2.224404
.ends

.subckt netg4315 g4315_1 g4315_0 gnd
C1  g4315_1 gnd 2.080806f
C2  g4315_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4315_0 2.224404
R2 g4315_1 1 2.224404
.ends

.subckt netg7386 g7386_1 g7386_0 gnd
C1  g7386_1 gnd 2.080806f
C2  g7386_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7386_0 2.224404
R2 g7386_1 1 2.224404
.ends

.subckt netg6817 g6817_1 g6817_0 gnd
C1  g6817_1 gnd 2.080806f
C2  g6817_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6817_0 1 2.224404
R2 1 g6817_1 2.224404
.ends

.subckt netg6293 g6293_0 g6293_1 gnd
C1  g6293_0 gnd 2.080806f
C2  g6293_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6293_0 1 2.224404
R2 g6293_1 1 2.224404
.ends

.subckt netg967 g967_0 g967_2 g967_1 gnd
C1  g967_0 gnd 2.080806f
C2  g967_2 gnd 2.080806f
C3  g967_1 gnd 2.080806f
R1 g967_1 g967_0 2.224404
R2 g967_1 g967_2 2.224404
.ends

.subckt netg5985 g5985_1 g5985_0 gnd
C1  g5985_1 gnd 2.080806f
C2  g5985_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5985_0 2.224404
R2 g5985_1 1 2.224404
.ends

.subckt netg1883 g1883_2 g1883_1 gnd
C1  g1883_2 gnd 2.080806f
C2  g1883_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1883_1 1 2.224404
R2 g1883_2 1 2.224404
.ends

.subckt netg5445 g5445_0 g5445_2 g5445_1 gnd
C1  g5445_0 gnd 2.080806f
C2  g5445_2 gnd 2.080806f
C3  g5445_1 gnd 2.080806f
R1 g5445_0 g5445_1 2.224404
R2 g5445_2 g5445_0 2.224404
.ends

.subckt netg6456 g6456_2 g6456_1 g6456_0 gnd
C1  g6456_2 gnd 2.080806f
C2  g6456_1 gnd 2.080806f
C3  g6456_0 gnd 2.080806f
R1 g6456_1 g6456_0 2.224404
R2 g6456_2 g6456_1 2.224404
.ends

.subckt netg7252 g7252_1 g7252_0 gnd
C1  g7252_1 gnd 2.080806f
C2  g7252_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7252_0 2.224404
R2 1 g7252_1 2.224404
.ends

.subckt netg2836 g2836_0 g2836_1 gnd
C1  g2836_0 gnd 2.080806f
C2  g2836_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2836_0 2.224404
R2 g2836_1 1 2.224404
.ends

.subckt netg1226 g1226_0 g1226_1 gnd
C1  g1226_0 gnd 2.080806f
C2  g1226_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1226_0 1 2.224404
R2 1 g1226_1 2.224404
.ends

.subckt netg4225 g4225_0 g4225_1 gnd
C1  g4225_0 gnd 2.080806f
C2  g4225_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4225_0 1 2.224404
R2 1 g4225_1 2.224404
.ends

.subckt netg4050 g4050_1 g4050_0 gnd
C1  g4050_1 gnd 2.080806f
C2  g4050_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4050_0 1 2.224404
R2 1 g4050_1 2.224404
.ends

.subckt netg1357 g1357_0 g1357_1 gnd
C1  g1357_0 gnd 2.080806f
C2  g1357_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1357_0 2.224404
R2 g1357_1 1 2.224404
.ends

.subckt netg6430 g6430_2 g6430_0 gnd
C1  g6430_2 gnd 2.080806f
C2  g6430_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6430_0 2.224404
R2 g6430_2 1 2.224404
.ends

.subckt netg5009 g5009_1 g5009_2 gnd
C1  g5009_1 gnd 2.080806f
C2  g5009_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5009_1 2.224404
R2 g5009_2 1 2.224404
.ends

.subckt netg4289 g4289_0 g4289_1 gnd
C1  g4289_0 gnd 2.080806f
C2  g4289_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4289_0 2.224404
R2 g4289_1 1 2.224404
.ends

.subckt netg696 g696_0 g696_1 g696_2 gnd
C1  g696_0 gnd 2.080806f
C2  g696_1 gnd 2.080806f
C3  g696_2 gnd 2.080806f
R1 g696_0 g696_1 2.224404
R2 g696_0 g696_2 2.224404
.ends

.subckt netg2422 g2422_1 g2422_0 gnd
C1  g2422_1 gnd 2.080806f
C2  g2422_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2422_0 1 2.224404
R2 1 g2422_1 2.224404
.ends

.subckt netg5554 g5554_1 g5554_2 g5554_0 gnd
C1  g5554_1 gnd 2.080806f
C2  g5554_2 gnd 2.080806f
C3  g5554_0 gnd 2.080806f
R1 g5554_0 g5554_2 2.224404
R2 g5554_2 g5554_1 2.224404
.ends

.subckt netg7173 g7173_1 g7173_0 gnd
C1  g7173_1 gnd 2.080806f
C2  g7173_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7173_0 1 2.224404
R2 1 g7173_1 2.224404
.ends

.subckt netg6274 g6274_2 g6274_0 g6274_1 gnd
C1  g6274_2 gnd 2.080806f
C2  g6274_0 gnd 2.080806f
C3  g6274_1 gnd 2.080806f
R1 g6274_0 g6274_1 2.224404
R2 g6274_2 g6274_0 2.224404
.ends

.subckt netg3346 g3346_1 g3346_0 gnd
C1  g3346_1 gnd 2.080806f
C2  g3346_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3346_0 1 2.224404
R2 g3346_1 1 2.224404
.ends

.subckt netg5314 g5314_0 g5314_1 gnd
C1  g5314_0 gnd 2.080806f
C2  g5314_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5314_0 1 2.224404
R2 g5314_1 1 2.224404
.ends

.subckt netg5591 g5591_1 g5591_0 gnd
C1  g5591_1 gnd 2.080806f
C2  g5591_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5591_0 2.224404
R2 g5591_1 1 2.224404
.ends

.subckt netg7302 g7302_0 g7302_1 gnd
C1  g7302_0 gnd 2.080806f
C2  g7302_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7302_0 2.224404
R2 g7302_1 1 2.224404
.ends

.subckt netg5462 g5462_0 g5462_1 gnd
C1  g5462_0 gnd 2.080806f
C2  g5462_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5462_0 2.224404
R2 g5462_1 1 2.224404
.ends

.subckt netg4411 g4411_1 g4411_0 gnd
C1  g4411_1 gnd 2.080806f
C2  g4411_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4411_0 1 2.224404
R2 1 g4411_1 2.224404
.ends

.subckt netg4415 g4415_1 g4415_0 gnd
C1  g4415_1 gnd 2.080806f
C2  g4415_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4415_0 2.224404
R2 g4415_1 1 2.224404
.ends

.subckt netg7024 g7024_1 g7024_0 gnd
C1  g7024_1 gnd 2.080806f
C2  g7024_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7024_0 1 2.224404
R2 1 g7024_1 2.224404
.ends

.subckt netg4111 g4111_0 g4111_1 gnd
C1  g4111_0 gnd 2.080806f
C2  g4111_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4111_0 1 2.224404
R2 1 g4111_1 2.224404
.ends

.subckt netg7171 g7171_0 g7171_1 gnd
C1  g7171_0 gnd 2.080806f
C2  g7171_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7171_0 2.224404
R2 g7171_1 1 2.224404
.ends

.subckt netg4251 g4251_1 g4251_0 gnd
C1  g4251_1 gnd 2.080806f
C2  g4251_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4251_0 1 2.224404
R2 1 g4251_1 2.224404
.ends

.subckt netg4988 g4988_2 g4988_0 gnd
C1  g4988_2 gnd 2.080806f
C2  g4988_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4988_0 1 2.224404
R2 1 g4988_2 2.224404
.ends

.subckt netg883 g883_1 g883_0 g883_2 gnd
C1  g883_1 gnd 2.080806f
C2  g883_0 gnd 2.080806f
C3  g883_2 gnd 2.080806f
R1 g883_1 g883_0 2.224404
R2 g883_0 g883_2 2.224404
.ends

.subckt netg3077 g3077_0 g3077_1 gnd
C1  g3077_0 gnd 2.080806f
C2  g3077_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3077_0 1 2.224404
R2 1 g3077_1 2.224404
.ends

.subckt netg2582 g2582_0 g2582_1 g2582_2 gnd
C1  g2582_0 gnd 2.080806f
C2  g2582_1 gnd 2.080806f
C3  g2582_2 gnd 2.080806f
R1 g2582_2 g2582_0 2.224404
R2 g2582_1 g2582_2 2.224404
.ends

.subckt netx222 x222_1 x222_0 gnd
C1  x222_1 gnd 2.080806f
C2  x222_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x222_0 2.224404
R2 1 x222_1 2.224404
.ends

.subckt netg4021 g4021_0 g4021_1 gnd
C1  g4021_0 gnd 2.080806f
C2  g4021_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4021_0 2.224404
R2 g4021_1 1 2.224404
.ends

.subckt netg2843 g2843_0 g2843_1 gnd
C1  g2843_0 gnd 2.080806f
C2  g2843_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2843_0 1 2.224404
R2 1 g2843_1 2.224404
.ends

.subckt netg4355 g4355_1 g4355_0 gnd
C1  g4355_1 gnd 2.080806f
C2  g4355_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4355_0 2.224404
R2 g4355_1 1 2.224404
.ends

.subckt netg4267 g4267_1 g4267_0 gnd
C1  g4267_1 gnd 2.080806f
C2  g4267_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4267_0 2.224404
R2 1 g4267_1 2.224404
.ends

.subckt netg5299 g5299_1 g5299_0 gnd
C1  g5299_1 gnd 2.080806f
C2  g5299_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5299_0 1 2.224404
R2 1 g5299_1 2.224404
.ends

.subckt netg3398 g3398_0 g3398_1 g3398_2 gnd
C1  g3398_0 gnd 2.080806f
C2  g3398_1 gnd 2.080806f
C3  g3398_2 gnd 2.080806f
R1 g3398_0 g3398_2 2.224404
R2 g3398_2 g3398_1 2.224404
.ends

.subckt netg6954 g6954_2 g6954_0 gnd
C1  g6954_2 gnd 2.080806f
C2  g6954_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6954_0 2.224404
R2 g6954_2 1 2.224404
.ends

.subckt netg2171 g2171_2 g2171_3 g2171_0 gnd
C1  g2171_2 gnd 2.080806f
C2  g2171_3 gnd 2.080806f
C3  g2171_0 gnd 2.080806f
R1 g2171_2 g2171_0 2.224404
R2 g2171_3 g2171_2 2.224404
.ends

.subckt netg6402 g6402_1 g6402_0 gnd
C1  g6402_1 gnd 2.080806f
C2  g6402_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6402_0 2.224404
R2 g6402_1 1 2.224404
.ends

.subckt netg1765 g1765_1 g1765_0 gnd
C1  g1765_1 gnd 2.080806f
C2  g1765_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1765_0 2.224404
R2 g1765_1 1 2.224404
.ends

.subckt netg2444 g2444_2 g2444_1 g2444_0 gnd
C1  g2444_2 gnd 2.080806f
C2  g2444_1 gnd 2.080806f
C3  g2444_0 gnd 2.080806f
R1 g2444_0 g2444_1 2.224404
R2 g2444_0 g2444_2 2.224404
.ends

.subckt netg6608 g6608_1 g6608_0 gnd
C1  g6608_1 gnd 2.080806f
C2  g6608_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6608_0 1 2.224404
R2 1 g6608_1 2.224404
.ends

.subckt netg3543 g3543_1 g3543_0 gnd
C1  g3543_1 gnd 2.080806f
C2  g3543_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3543_0 2.224404
R2 g3543_1 1 2.224404
.ends

.subckt netg2368 g2368_1 g2368_2 g2368_0 gnd
C1  g2368_1 gnd 2.080806f
C2  g2368_2 gnd 2.080806f
C3  g2368_0 gnd 2.080806f
R1 g2368_2 g2368_0 2.224404
R2 g2368_1 g2368_2 2.224404
.ends

.subckt netg2588 g2588_2 g2588_0 gnd
C1  g2588_2 gnd 2.080806f
C2  g2588_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2588_0 1 2.224404
R2 1 g2588_2 2.224404
.ends

.subckt netg3475 g3475_1 g3475_0 gnd
C1  g3475_1 gnd 2.080806f
C2  g3475_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3475_0 2.224404
R2 g3475_1 1 2.224404
.ends

.subckt netg6041 g6041_0 g6041_1 gnd
C1  g6041_0 gnd 2.080806f
C2  g6041_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6041_0 1 2.224404
R2 g6041_1 1 2.224404
.ends

.subckt netg2920 g2920_0 g2920_1 gnd
C1  g2920_0 gnd 2.080806f
C2  g2920_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2920_0 2.224404
R2 g2920_1 1 2.224404
.ends

.subckt netg6561 g6561_1 g6561_0 gnd
C1  g6561_1 gnd 2.080806f
C2  g6561_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6561_0 2.224404
R2 g6561_1 1 2.224404
.ends

.subckt netg1015 g1015_0 g1015_2 g1015_1 gnd
C1  g1015_0 gnd 2.080806f
C2  g1015_2 gnd 2.080806f
C3  g1015_1 gnd 2.080806f
R1 g1015_0 g1015_2 2.224404
R2 g1015_2 g1015_1 2.224404
.ends

.subckt netg5520 g5520_0 g5520_1 gnd
C1  g5520_0 gnd 2.080806f
C2  g5520_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5520_0 1 2.224404
R2 1 g5520_1 2.224404
.ends

.subckt netx211 x211_0 x211_1 gnd
C1  x211_0 gnd 2.080806f
C2  x211_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x211_0 1 2.224404
R2 1 x211_1 2.224404
.ends

.subckt netg2776 g2776_1 g2776_0 gnd
C1  g2776_1 gnd 2.080806f
C2  g2776_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2776_0 1 2.224404
R2 1 g2776_1 2.224404
.ends

.subckt netg6683 g6683_0 g6683_1 gnd
C1  g6683_0 gnd 2.080806f
C2  g6683_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6683_0 1 2.224404
R2 1 g6683_1 2.224404
.ends

.subckt netg1583 g1583_0 g1583_1 gnd
C1  g1583_0 gnd 2.080806f
C2  g1583_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1583_0 2.224404
R2 g1583_1 1 2.224404
.ends

.subckt netg1219 g1219_0 g1219_1 gnd
C1  g1219_0 gnd 2.080806f
C2  g1219_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1219_0 2.224404
R2 g1219_1 1 2.224404
.ends

.subckt netg6034 g6034_0 g6034_1 gnd
C1  g6034_0 gnd 2.080806f
C2  g6034_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6034_0 1 2.224404
R2 1 g6034_1 2.224404
.ends

.subckt netg559 g559_1 g559_0 gnd
C1  g559_1 gnd 2.080806f
C2  g559_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g559_0 2.224404
R2 1 g559_1 2.224404
.ends

.subckt netg6417 g6417_1 g6417_0 gnd
C1  g6417_1 gnd 2.080806f
C2  g6417_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6417_0 2.224404
R2 g6417_1 1 2.224404
.ends

.subckt netg6412 g6412_1 g6412_0 gnd
C1  g6412_1 gnd 2.080806f
C2  g6412_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6412_0 1 2.224404
R2 1 g6412_1 2.224404
.ends

.subckt netg4222 g4222_1 g4222_0 gnd
C1  g4222_1 gnd 2.080806f
C2  g4222_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4222_0 2.224404
R2 g4222_1 1 2.224404
.ends

.subckt netg3377 g3377_2 g3377_1 gnd
C1  g3377_2 gnd 2.080806f
C2  g3377_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3377_1 2.224404
R2 g3377_2 1 2.224404
.ends

.subckt netg6698 g6698_1 g6698_0 gnd
C1  g6698_1 gnd 2.080806f
C2  g6698_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6698_0 2.224404
R2 1 g6698_1 2.224404
.ends

.subckt netg4054 g4054_1 g4054_0 gnd
C1  g4054_1 gnd 2.080806f
C2  g4054_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4054_0 2.224404
R2 1 g4054_1 2.224404
.ends

.subckt netg4262 g4262_1 g4262_0 gnd
C1  g4262_1 gnd 2.080806f
C2  g4262_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4262_0 1 2.224404
R2 1 g4262_1 2.224404
.ends

.subckt netg5274 g5274_1 g5274_0 gnd
C1  g5274_1 gnd 2.080806f
C2  g5274_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5274_0 1 2.224404
R2 1 g5274_1 2.224404
.ends

.subckt netg5829 g5829_0 g5829_1 gnd
C1  g5829_0 gnd 2.080806f
C2  g5829_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5829_0 2.224404
R2 g5829_1 1 2.224404
.ends

.subckt netg5454 g5454_1 g5454_0 g5454_2 gnd
C1  g5454_1 gnd 2.080806f
C2  g5454_0 gnd 2.080806f
C3  g5454_2 gnd 2.080806f
R1 g5454_0 g5454_1 2.224404
R2 g5454_2 g5454_0 2.224404
.ends

.subckt netg1887 g1887_1 g1887_0 gnd
C1  g1887_1 gnd 2.080806f
C2  g1887_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1887_0 1 2.224404
R2 1 g1887_1 2.224404
.ends

.subckt netg1024 g1024_2 g1024_1 g1024_0 gnd
C1  g1024_2 gnd 2.080806f
C2  g1024_1 gnd 2.080806f
C3  g1024_0 gnd 2.080806f
R1 g1024_1 g1024_0 2.224404
R2 g1024_2 g1024_1 2.224404
.ends

.subckt netg6654 g6654_0 g6654_1 gnd
C1  g6654_0 gnd 2.080806f
C2  g6654_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6654_0 2.224404
R2 g6654_1 1 2.224404
.ends

.subckt netg4285 g4285_1 g4285_0 gnd
C1  g4285_1 gnd 2.080806f
C2  g4285_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4285_0 2.224404
R2 g4285_1 1 2.224404
.ends

.subckt netg7086 g7086_1 g7086_0 gnd
C1  g7086_1 gnd 2.080806f
C2  g7086_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7086_0 1 2.224404
R2 1 g7086_1 2.224404
.ends

.subckt netg7372 g7372_0 g7372_1 gnd
C1  g7372_0 gnd 2.080806f
C2  g7372_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7372_0 2.224404
R2 g7372_1 1 2.224404
.ends

.subckt netg1076 g1076_2 g1076_1 gnd
C1  g1076_2 gnd 2.080806f
C2  g1076_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1076_2 1 2.224404
R2 g1076_1 1 2.224404
.ends

.subckt netg6530 g6530_1 g6530_0 gnd
C1  g6530_1 gnd 2.080806f
C2  g6530_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6530_0 1 2.224404
R2 g6530_1 1 2.224404
.ends

.subckt netg2392 g2392_2 g2392_1 gnd
C1  g2392_2 gnd 2.080806f
C2  g2392_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2392_1 1 2.224404
R2 1 g2392_2 2.224404
.ends

.subckt netg7424 g7424_1 g7424_0 gnd
C1  g7424_1 gnd 2.080806f
C2  g7424_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7424_0 1 2.224404
R2 1 g7424_1 2.224404
.ends

.subckt netg6924 g6924_1 g6924_0 gnd
C1  g6924_1 gnd 2.080806f
C2  g6924_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6924_0 2.224404
R2 g6924_1 1 2.224404
.ends

.subckt netg5121 g5121_0 g5121_1 gnd
C1  g5121_0 gnd 2.080806f
C2  g5121_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5121_0 1 2.224404
R2 g5121_1 1 2.224404
.ends

.subckt netg5027 g5027_1 g5027_2 g5027_0 gnd
C1  g5027_1 gnd 2.080806f
C2  g5027_2 gnd 2.080806f
C3  g5027_0 gnd 2.080806f
R1 g5027_2 g5027_0 2.224404
R2 g5027_1 g5027_2 2.224404
.ends

.subckt netg5995 g5995_1 g5995_0 gnd
C1  g5995_1 gnd 2.080806f
C2  g5995_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5995_0 2.224404
R2 g5995_1 1 2.224404
.ends

.subckt netg5033 g5033_2 g5033_0 g5033_1 gnd
C1  g5033_2 gnd 2.080806f
C2  g5033_0 gnd 2.080806f
C3  g5033_1 gnd 2.080806f
R1 g5033_1 g5033_0 2.224404
R2 g5033_2 g5033_1 2.224404
.ends

.subckt netg7180 g7180_2 g7180_1 g7180_0 gnd
C1  g7180_2 gnd 2.080806f
C2  g7180_1 gnd 2.080806f
C3  g7180_0 gnd 2.080806f
R1 g7180_2 g7180_0 2.224404
R2 g7180_2 g7180_1 2.224404
.ends

.subckt netg1315 g1315_0 g1315_1 gnd
C1  g1315_0 gnd 2.080806f
C2  g1315_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1315_0 1 2.224404
R2 g1315_1 1 2.224404
.ends

.subckt netg6174 g6174_0 g6174_1 gnd
C1  g6174_0 gnd 2.080806f
C2  g6174_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6174_0 2.224404
R2 g6174_1 1 2.224404
.ends

.subckt netg2763 g2763_1 g2763_0 gnd
C1  g2763_1 gnd 2.080806f
C2  g2763_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2763_0 2.224404
R2 g2763_1 1 2.224404
.ends

.subckt netg5846 g5846_1 g5846_0 gnd
C1  g5846_1 gnd 2.080806f
C2  g5846_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5846_0 2.224404
R2 g5846_1 1 2.224404
.ends

.subckt netg5700 g5700_1 g5700_0 g5700_2 gnd
C1  g5700_1 gnd 2.080806f
C2  g5700_0 gnd 2.080806f
C3  g5700_2 gnd 2.080806f
R1 g5700_2 g5700_0 2.224404
R2 g5700_1 g5700_2 2.224404
.ends

.subckt netg3459 g3459_2 g3459_0 gnd
C1  g3459_2 gnd 2.080806f
C2  g3459_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3459_0 2.224404
R2 g3459_2 1 2.224404
.ends

.subckt netg3465 g3465_1 g3465_0 gnd
C1  g3465_1 gnd 2.080806f
C2  g3465_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3465_0 2.224404
R2 g3465_1 1 2.224404
.ends

.subckt netg7348 g7348_0 g7348_1 gnd
C1  g7348_0 gnd 2.080806f
C2  g7348_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7348_0 1 2.224404
R2 g7348_1 1 2.224404
.ends

.subckt netg5864 g5864_1 g5864_0 gnd
C1  g5864_1 gnd 2.080806f
C2  g5864_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5864_0 1 2.224404
R2 1 g5864_1 2.224404
.ends

.subckt netg3891 g3891_0 g3891_1 gnd
C1  g3891_0 gnd 2.080806f
C2  g3891_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3891_0 1 2.224404
R2 1 g3891_1 2.224404
.ends

.subckt netg7339 g7339_1 g7339_0 gnd
C1  g7339_1 gnd 2.080806f
C2  g7339_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7339_0 1 2.224404
R2 1 g7339_1 2.224404
.ends

.subckt netg5981 g5981_1 g5981_0 gnd
C1  g5981_1 gnd 2.080806f
C2  g5981_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5981_0 1 2.224404
R2 1 g5981_1 2.224404
.ends

.subckt netg7115 g7115_0 g7115_1 gnd
C1  g7115_0 gnd 2.080806f
C2  g7115_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7115_0 1 2.224404
R2 g7115_1 1 2.224404
.ends

.subckt netg6670 g6670_1 g6670_0 gnd
C1  g6670_1 gnd 2.080806f
C2  g6670_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6670_0 2.224404
R2 g6670_1 1 2.224404
.ends

.subckt netg2507 g2507_1 g2507_2 g2507_0 gnd
C1  g2507_1 gnd 2.080806f
C2  g2507_2 gnd 2.080806f
C3  g2507_0 gnd 2.080806f
R1 g2507_0 g2507_1 2.224404
R2 g2507_1 g2507_2 2.224404
.ends

.subckt netg6070 g6070_0 g6070_1 gnd
C1  g6070_0 gnd 2.080806f
C2  g6070_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6070_0 2.224404
R2 g6070_1 1 2.224404
.ends

.subckt netg7256 g7256_1 g7256_0 gnd
C1  g7256_1 gnd 2.080806f
C2  g7256_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7256_0 2.224404
R2 1 g7256_1 2.224404
.ends

.subckt netg4041 g4041_1 g4041_0 gnd
C1  g4041_1 gnd 2.080806f
C2  g4041_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4041_0 1 2.224404
R2 1 g4041_1 2.224404
.ends

.subckt netx522 x522_0 x522_1 gnd
C1  x522_0 gnd 2.080806f
C2  x522_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x522_0 2.224404
R2 x522_1 1 2.224404
.ends

.subckt netg99 g99_1 g99_0 gnd
C1  g99_1 gnd 2.080806f
C2  g99_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g99_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g99_1 2.224404
.ends

.subckt netg5086 g5086_0 g5086_2 g5086_1 gnd
C1  g5086_0 gnd 2.080806f
C2  g5086_2 gnd 2.080806f
C3  g5086_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5086_0 1 2.224404
R2 g5086_1 1 2.224404
R3 g5086_1 g5086_2 2.224404
.ends

.subckt netg4343 g4343_0 g4343_1 gnd
C1  g4343_0 gnd 2.080806f
C2  g4343_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4343_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4343_1 2 2.224404
.ends

.subckt netg1587 g1587_0 g1587_1 gnd
C1  g1587_0 gnd 2.080806f
C2  g1587_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1587_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1587_1 2.224404
.ends

.subckt netg3472 g3472_1 g3472_0 gnd
C1  g3472_1 gnd 2.080806f
C2  g3472_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3472_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3472_1 2.224404
.ends

.subckt netg7014 g7014_1 g7014_0 gnd
C1  g7014_1 gnd 2.080806f
C2  g7014_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7014_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7014_1 2.224404
.ends

.subckt netg3186 g3186_2 g3186_1 g3186_0 gnd
C1  g3186_2 gnd 2.080806f
C2  g3186_1 gnd 2.080806f
C3  g3186_0 gnd 2.080806f
R1 g3186_0 g3186_1 2.224404
C4 1 gnd 2.080806f
R2 g3186_1 1 2.224404
R3 1 g3186_2 2.224404
.ends

.subckt netg1048 g1048_0 g1048_2 g1048_1 gnd
C1  g1048_0 gnd 2.080806f
C2  g1048_2 gnd 2.080806f
C3  g1048_1 gnd 2.080806f
R1 g1048_1 g1048_0 2.224404
C4 1 gnd 2.080806f
R2 1 g1048_1 2.224404
R3 g1048_2 1 2.224404
.ends

.subckt netg6370 g6370_1 g6370_0 gnd
C1  g6370_1 gnd 2.080806f
C2  g6370_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6370_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g6370_1 2 2.224404
.ends

.subckt netg5214 g5214_0 g5214_1 g5214_2 gnd
C1  g5214_0 gnd 2.080806f
C2  g5214_1 gnd 2.080806f
C3  g5214_2 gnd 2.080806f
R1 g5214_2 g5214_0 2.224404
C4 1 gnd 2.080806f
R2 g5214_2 1 2.224404
R3 g5214_1 1 2.224404
.ends

.subckt netg6722 g6722_0 g6722_2 gnd
C1  g6722_0 gnd 2.080806f
C2  g6722_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6722_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6722_2 2.224404
.ends

.subckt netg5492 g5492_1 g5492_0 gnd
C1  g5492_1 gnd 2.080806f
C2  g5492_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5492_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g5492_1 2.224404
.ends

.subckt netx232 x232_0 x232_1 gnd
C1  x232_0 gnd 2.080806f
C2  x232_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x232_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 x232_1 2.224404
.ends

.subckt netg6687 g6687_2 g6687_1 g6687_3 g6687_0 gnd
C1  g6687_2 gnd 2.080806f
C2  g6687_1 gnd 2.080806f
C3  g6687_3 gnd 2.080806f
C4  g6687_0 gnd 2.080806f
R1 g6687_1 g6687_0 2.224404
R2 g6687_2 g6687_0 2.224404
R3 g6687_2 g6687_3 2.224404
.ends

.subckt netg2880 g2880_0 g2880_1 gnd
C1  g2880_0 gnd 2.080806f
C2  g2880_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2880_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2880_1 2 2.224404
.ends

.subckt netg2594 g2594_2 g2594_0 g2594_1 gnd
C1  g2594_2 gnd 2.080806f
C2  g2594_0 gnd 2.080806f
C3  g2594_1 gnd 2.080806f
R1 g2594_1 g2594_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2594_1 2.224404
R3 1 g2594_2 2.224404
.ends

.subckt netg6917 g6917_0 g6917_1 gnd
C1  g6917_0 gnd 2.080806f
C2  g6917_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6917_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6917_1 2 2.224404
.ends

.subckt netx302 x302_1 x302_0 gnd
C1  x302_1 gnd 2.080806f
C2  x302_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x302_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x302_1 2 2.224404
.ends

.subckt netg6044 g6044_1 g6044_0 gnd
C1  g6044_1 gnd 2.080806f
C2  g6044_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6044_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6044_1 2 2.224404
.ends

.subckt netg1938 g1938_0 g1938_1 gnd
C1  g1938_0 gnd 2.080806f
C2  g1938_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1938_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g1938_1 2 2.224404
.ends

.subckt netg2624 g2624_1 g2624_2 g2624_0 gnd
C1  g2624_1 gnd 2.080806f
C2  g2624_2 gnd 2.080806f
C3  g2624_0 gnd 2.080806f
R1 g2624_0 g2624_2 2.224404
C4 1 gnd 2.080806f
R2 1 g2624_0 2.224404
R3 g2624_1 1 2.224404
.ends

.subckt netg1877 g1877_0 g1877_2 g1877_1 gnd
C1  g1877_0 gnd 2.080806f
C2  g1877_2 gnd 2.080806f
C3  g1877_1 gnd 2.080806f
R1 g1877_0 g1877_2 2.224404
C4 1 gnd 2.080806f
R2 1 g1877_0 2.224404
R3 g1877_1 1 2.224404
.ends

.subckt netg5598 g5598_0 g5598_1 gnd
C1  g5598_0 gnd 2.080806f
C2  g5598_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5598_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5598_1 2 2.224404
.ends

.subckt netg6198 g6198_1 g6198_0 gnd
C1  g6198_1 gnd 2.080806f
C2  g6198_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6198_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6198_1 2.224404
.ends

.subckt netg2231 g2231_1 g2231_0 gnd
C1  g2231_1 gnd 2.080806f
C2  g2231_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2231_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2231_1 2.224404
.ends

.subckt netg2665 g2665_0 g2665_1 g2665_2 gnd
C1  g2665_0 gnd 2.080806f
C2  g2665_1 gnd 2.080806f
C3  g2665_2 gnd 2.080806f
R1 g2665_0 g2665_1 2.224404
C4 1 gnd 2.080806f
R2 1 g2665_0 2.224404
R3 g2665_2 1 2.224404
.ends

.subckt netg6975 g6975_1 g6975_0 gnd
C1  g6975_1 gnd 2.080806f
C2  g6975_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6975_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6975_1 2 2.224404
.ends

.subckt netg544 g544_1 g544_0 gnd
C1  g544_1 gnd 2.080806f
C2  g544_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g544_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g544_1 2.224404
.ends

.subckt netg4893 g4893_1 g4893_0 g4893_2 gnd
C1  g4893_1 gnd 2.080806f
C2  g4893_0 gnd 2.080806f
C3  g4893_2 gnd 2.080806f
R1 g4893_1 g4893_0 2.224404
C4 1 gnd 2.080806f
R2 1 g4893_1 2.224404
R3 g4893_2 1 2.224404
.ends

.subckt netg3114 g3114_0 g3114_2 g3114_1 gnd
C1  g3114_0 gnd 2.080806f
C2  g3114_2 gnd 2.080806f
C3  g3114_1 gnd 2.080806f
R1 g3114_0 g3114_1 2.224404
C4 1 gnd 2.080806f
R2 1 g3114_0 2.224404
R3 g3114_2 1 2.224404
.ends

.subckt netg6927 g6927_0 g6927_1 gnd
C1  g6927_0 gnd 2.080806f
C2  g6927_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6927_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6927_1 2.224404
.ends

.subckt netg3165 g3165_1 g3165_2 g3165_0 gnd
C1  g3165_1 gnd 2.080806f
C2  g3165_2 gnd 2.080806f
C3  g3165_0 gnd 2.080806f
R1 g3165_0 g3165_1 2.224404
C4 1 gnd 2.080806f
R2 g3165_1 1 2.224404
R3 1 g3165_2 2.224404
.ends

.subckt netg3902 g3902_1 g3902_0 gnd
C1  g3902_1 gnd 2.080806f
C2  g3902_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3902_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3902_1 2 2.224404
.ends

.subckt netg5153 g5153_2 g5153_1 g5153_0 gnd
C1  g5153_2 gnd 2.080806f
C2  g5153_1 gnd 2.080806f
C3  g5153_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5153_0 2.224404
R2 1 g5153_1 2.224404
C5 2 gnd 2.080806f
R3 g5153_0 2 2.224404
R4 2 g5153_2 2.224404
.ends

.subckt netg5578 g5578_0 g5578_1 g5578_2 gnd
C1  g5578_0 gnd 2.080806f
C2  g5578_1 gnd 2.080806f
C3  g5578_2 gnd 2.080806f
R1 g5578_2 g5578_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5578_2 2.224404
R3 g5578_1 1 2.224404
.ends

.subckt netg4657 g4657_0 g4657_1 g4657_2 gnd
C1  g4657_0 gnd 2.080806f
C2  g4657_1 gnd 2.080806f
C3  g4657_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4657_0 1 2.224404
R2 1 g4657_1 2.224404
C5 2 gnd 2.080806f
R3 2 g4657_0 2.224404
R4 2 g4657_2 2.224404
.ends

.subckt netg6288 g6288_0 g6288_2 g6288_1 gnd
C1  g6288_0 gnd 2.080806f
C2  g6288_2 gnd 2.080806f
C3  g6288_1 gnd 2.080806f
R1 g6288_2 g6288_0 2.224404
C4 1 gnd 2.080806f
R2 1 g6288_2 2.224404
R3 g6288_1 1 2.224404
.ends

.subckt netg82 g82_0 g82_1 gnd
C1  g82_0 gnd 2.080806f
C2  g82_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g82_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g82_1 2 2.224404
.ends

.subckt netg1907 g1907_0 g1907_1 gnd
C1  g1907_0 gnd 2.080806f
C2  g1907_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1907_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1907_1 2.224404
.ends

.subckt netg4953 g4953_0 g4953_2 gnd
C1  g4953_0 gnd 2.080806f
C2  g4953_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4953_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4953_2 2 2.224404
.ends

.subckt netg6653 g6653_1 g6653_0 gnd
C1  g6653_1 gnd 2.080806f
C2  g6653_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6653_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6653_1 2 2.224404
.ends

.subckt netg5047 g5047_0 g5047_2 gnd
C1  g5047_0 gnd 2.080806f
C2  g5047_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5047_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5047_2 2 2.224404
.ends

.subckt netg6164 g6164_1 g6164_0 gnd
C1  g6164_1 gnd 2.080806f
C2  g6164_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6164_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g6164_1 2 2.224404
.ends

.subckt netg5422 g5422_1 g5422_0 gnd
C1  g5422_1 gnd 2.080806f
C2  g5422_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5422_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5422_1 2 2.224404
.ends

.subckt netg1936 g1936_1 g1936_0 gnd
C1  g1936_1 gnd 2.080806f
C2  g1936_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1936_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g1936_1 2 2.224404
.ends

.subckt netg2498 g2498_0 g2498_1 g2498_2 gnd
C1  g2498_0 gnd 2.080806f
C2  g2498_1 gnd 2.080806f
C3  g2498_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2498_0 2.224404
R2 g2498_1 1 2.224404
R3 g2498_2 g2498_1 2.224404
.ends

.subckt netg2722 g2722_2 g2722_0 g2722_1 gnd
C1  g2722_2 gnd 2.080806f
C2  g2722_0 gnd 2.080806f
C3  g2722_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2722_0 2.224404
R2 g2722_1 1 2.224404
R3 g2722_1 g2722_2 2.224404
.ends

.subckt netg3276 g3276_0 g3276_2 g3276_1 gnd
C1  g3276_0 gnd 2.080806f
C2  g3276_2 gnd 2.080806f
C3  g3276_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3276_0 2.224404
R2 1 g3276_2 2.224404
R3 g3276_1 g3276_2 2.224404
.ends

.subckt netg958 g958_1 g958_2 gnd
C1  g958_1 gnd 2.080806f
C2  g958_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g958_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g958_1 2.224404
.ends

.subckt netg5539 g5539_1 g5539_0 gnd
C1  g5539_1 gnd 2.080806f
C2  g5539_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5539_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5539_1 2 2.224404
.ends

.subckt netg4066 g4066_1 g4066_0 gnd
C1  g4066_1 gnd 2.080806f
C2  g4066_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4066_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4066_1 2 2.224404
.ends

.subckt netg2769 g2769_0 g2769_1 gnd
C1  g2769_0 gnd 2.080806f
C2  g2769_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2769_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2769_1 2 2.224404
.ends

.subckt netg6049 g6049_0 g6049_1 gnd
C1  g6049_0 gnd 2.080806f
C2  g6049_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6049_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6049_1 2 2.224404
.ends

.subckt netg3380 g3380_1 g3380_0 g3380_2 gnd
C1  g3380_1 gnd 2.080806f
C2  g3380_0 gnd 2.080806f
C3  g3380_2 gnd 2.080806f
R1 g3380_2 g3380_0 2.224404
C4 1 gnd 2.080806f
R2 g3380_2 1 2.224404
R3 g3380_1 1 2.224404
.ends

.subckt netg6007 g6007_0 g6007_1 gnd
C1  g6007_0 gnd 2.080806f
C2  g6007_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6007_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6007_1 2 2.224404
.ends

.subckt netg4905 g4905_2 g4905_1 g4905_0 gnd
C1  g4905_2 gnd 2.080806f
C2  g4905_1 gnd 2.080806f
C3  g4905_0 gnd 2.080806f
R1 g4905_2 g4905_0 2.224404
C4 1 gnd 2.080806f
R2 g4905_2 1 2.224404
R3 1 g4905_1 2.224404
.ends

.subckt netg2695 g2695_1 g2695_0 g2695_2 gnd
C1  g2695_1 gnd 2.080806f
C2  g2695_0 gnd 2.080806f
C3  g2695_2 gnd 2.080806f
R1 g2695_0 g2695_2 2.224404
C4 1 gnd 2.080806f
R2 g2695_2 1 2.224404
R3 1 g2695_1 2.224404
.ends

.subckt netg6552 g6552_0 g6552_1 gnd
C1  g6552_0 gnd 2.080806f
C2  g6552_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6552_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g6552_1 2 2.224404
.ends

.subckt netg3368 g3368_2 g3368_1 g3368_0 gnd
C1  g3368_2 gnd 2.080806f
C2  g3368_1 gnd 2.080806f
C3  g3368_0 gnd 2.080806f
R1 g3368_2 g3368_0 2.224404
C4 1 gnd 2.080806f
R2 1 g3368_2 2.224404
R3 1 g3368_1 2.224404
.ends

.subckt netg5622 g5622_0 g5622_2 gnd
C1  g5622_0 gnd 2.080806f
C2  g5622_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5622_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5622_2 2.224404
.ends

.subckt netg3318 g3318_0 g3318_2 g3318_1 gnd
C1  g3318_0 gnd 2.080806f
C2  g3318_2 gnd 2.080806f
C3  g3318_1 gnd 2.080806f
R1 g3318_1 g3318_0 2.224404
C4 1 gnd 2.080806f
R2 1 g3318_1 2.224404
R3 g3318_2 1 2.224404
.ends

.subckt netg2401 g2401_1 g2401_0 g2401_2 gnd
C1  g2401_1 gnd 2.080806f
C2  g2401_0 gnd 2.080806f
C3  g2401_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2401_0 2.224404
R2 g2401_1 1 2.224404
R3 g2401_2 g2401_1 2.224404
.ends

.subckt netg1439 g1439_1 g1439_0 gnd
C1  g1439_1 gnd 2.080806f
C2  g1439_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1439_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1439_1 2 2.224404
.ends

.subckt netg2232 g2232_1 g2232_0 gnd
C1  g2232_1 gnd 2.080806f
C2  g2232_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2232_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2232_1 2.224404
.ends

.subckt netg6466 g6466_0 g6466_1 gnd
C1  g6466_0 gnd 2.080806f
C2  g6466_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6466_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6466_1 2 2.224404
.ends

.subckt netg5929 g5929_0 g5929_1 gnd
C1  g5929_0 gnd 2.080806f
C2  g5929_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5929_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5929_1 2 2.224404
.ends

.subckt netg4319 g4319_1 g4319_0 gnd
C1  g4319_1 gnd 2.080806f
C2  g4319_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4319_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4319_1 2 2.224404
.ends

.subckt netg3019 g3019_1 g3019_0 gnd
C1  g3019_1 gnd 2.080806f
C2  g3019_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3019_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g3019_1 2.224404
.ends

.subckt netg7138 g7138_0 g7138_1 gnd
C1  g7138_0 gnd 2.080806f
C2  g7138_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7138_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7138_1 2.224404
.ends

.subckt netg6262 g6262_0 g6262_1 gnd
C1  g6262_0 gnd 2.080806f
C2  g6262_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6262_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6262_1 2 2.224404
.ends

.subckt netg3545 g3545_0 g3545_1 gnd
C1  g3545_0 gnd 2.080806f
C2  g3545_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3545_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3545_1 2 2.224404
.ends

.subckt netg6540 g6540_0 g6540_1 gnd
C1  g6540_0 gnd 2.080806f
C2  g6540_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6540_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6540_1 2.224404
.ends

.subckt netg6964 g6964_1 g6964_0 g6964_2 gnd
C1  g6964_1 gnd 2.080806f
C2  g6964_0 gnd 2.080806f
C3  g6964_2 gnd 2.080806f
R1 g6964_0 g6964_2 2.224404
C4 1 gnd 2.080806f
R2 1 g6964_0 2.224404
R3 g6964_1 1 2.224404
.ends

.subckt netg1454 g1454_0 g1454_1 gnd
C1  g1454_0 gnd 2.080806f
C2  g1454_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1454_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1454_1 2.224404
.ends

.subckt netg2468 g2468_1 g2468_2 g2468_0 gnd
C1  g2468_1 gnd 2.080806f
C2  g2468_2 gnd 2.080806f
C3  g2468_0 gnd 2.080806f
R1 g2468_2 g2468_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2468_0 2.224404
R3 g2468_1 1 2.224404
.ends

.subckt netg5915 g5915_0 g5915_1 gnd
C1  g5915_0 gnd 2.080806f
C2  g5915_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5915_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5915_1 2 2.224404
.ends

.subckt netg5668 g5668_2 g5668_0 g5668_1 gnd
C1  g5668_2 gnd 2.080806f
C2  g5668_0 gnd 2.080806f
C3  g5668_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5668_0 1 2.224404
R2 1 g5668_2 2.224404
R3 g5668_1 g5668_2 2.224404
.ends

.subckt netg6387 g6387_1 g6387_0 gnd
C1  g6387_1 gnd 2.080806f
C2  g6387_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6387_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6387_1 2.224404
.ends

.subckt netg5923 g5923_2 g5923_1 g5923_0 gnd
C1  g5923_2 gnd 2.080806f
C2  g5923_1 gnd 2.080806f
C3  g5923_0 gnd 2.080806f
R1 g5923_0 g5923_1 2.224404
C4 1 gnd 2.080806f
R2 1 g5923_0 2.224404
R3 1 g5923_2 2.224404
.ends

.subckt netg2528 g2528_1 g2528_0 g2528_2 gnd
C1  g2528_1 gnd 2.080806f
C2  g2528_0 gnd 2.080806f
C3  g2528_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2528_0 1 2.224404
R2 1 g2528_1 2.224404
R3 g2528_1 g2528_2 2.224404
.ends

.subckt netg5685 g5685_2 g5685_0 g5685_1 gnd
C1  g5685_2 gnd 2.080806f
C2  g5685_0 gnd 2.080806f
C3  g5685_1 gnd 2.080806f
R1 g5685_2 g5685_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5685_0 2.224404
R3 g5685_1 1 2.224404
.ends

.subckt netg6934 g6934_0 g6934_1 gnd
C1  g6934_0 gnd 2.080806f
C2  g6934_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6934_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6934_1 2.224404
.ends

.subckt netx321 x321_0 x321_1 gnd
C1  x321_0 gnd 2.080806f
C2  x321_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x321_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x321_1 2 2.224404
.ends

.subckt netg1057 g1057_2 g1057_0 g1057_1 gnd
C1  g1057_2 gnd 2.080806f
C2  g1057_0 gnd 2.080806f
C3  g1057_1 gnd 2.080806f
R1 g1057_0 g1057_2 2.224404
C4 1 gnd 2.080806f
R2 g1057_2 1 2.224404
R3 g1057_1 1 2.224404
.ends

.subckt netg4292 g4292_0 g4292_1 gnd
C1  g4292_0 gnd 2.080806f
C2  g4292_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4292_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4292_1 2 2.224404
.ends

.subckt netg2615 g2615_0 g2615_2 g2615_1 gnd
C1  g2615_0 gnd 2.080806f
C2  g2615_2 gnd 2.080806f
C3  g2615_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2615_0 1 2.224404
R2 1 g2615_1 2.224404
R3 g2615_2 1 2.224404
.ends

.subckt netg6796 g6796_2 g6796_1 g6796_0 gnd
C1  g6796_2 gnd 2.080806f
C2  g6796_1 gnd 2.080806f
C3  g6796_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6796_0 1 2.224404
R2 1 g6796_2 2.224404
R3 g6796_2 g6796_1 2.224404
.ends

.subckt netg3567 g3567_0 g3567_1 gnd
C1  g3567_0 gnd 2.080806f
C2  g3567_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3567_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3567_1 2.224404
.ends

.subckt netg1157 g1157_0 g1157_1 gnd
C1  g1157_0 gnd 2.080806f
C2  g1157_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1157_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1157_1 2.224404
.ends

.subckt netg6495 g6495_0 g6495_2 g6495_1 gnd
C1  g6495_0 gnd 2.080806f
C2  g6495_2 gnd 2.080806f
C3  g6495_1 gnd 2.080806f
R1 g6495_2 g6495_0 2.224404
C4 1 gnd 2.080806f
R2 1 g6495_2 2.224404
R3 g6495_1 1 2.224404
.ends

.subckt netg2346 g2346_1 g2346_0 gnd
C1  g2346_1 gnd 2.080806f
C2  g2346_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2346_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2346_1 2.224404
.ends

.subckt netg2418 g2418_0 g2418_2 g2418_1 gnd
C1  g2418_0 gnd 2.080806f
C2  g2418_2 gnd 2.080806f
C3  g2418_1 gnd 2.080806f
R1 g2418_2 g2418_0 2.224404
C4 1 gnd 2.080806f
R2 g2418_2 1 2.224404
R3 1 g2418_1 2.224404
.ends

.subckt netg3539 g3539_1 g3539_0 gnd
C1  g3539_1 gnd 2.080806f
C2  g3539_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3539_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3539_1 2.224404
.ends

.subckt netg4044 g4044_1 g4044_0 gnd
C1  g4044_1 gnd 2.080806f
C2  g4044_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4044_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4044_1 2.224404
.ends

.subckt netg2825 g2825_0 g2825_1 gnd
C1  g2825_0 gnd 2.080806f
C2  g2825_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2825_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2825_1 2 2.224404
.ends

.subckt netg4003 g4003_1 g4003_2 g4003_0 gnd
C1  g4003_1 gnd 2.080806f
C2  g4003_2 gnd 2.080806f
C3  g4003_0 gnd 2.080806f
R1 g4003_2 g4003_0 2.224404
C4 1 gnd 2.080806f
R2 1 g4003_2 2.224404
R3 1 g4003_1 2.224404
.ends

.subckt netg2395 g2395_2 g2395_1 g2395_0 gnd
C1  g2395_2 gnd 2.080806f
C2  g2395_1 gnd 2.080806f
C3  g2395_0 gnd 2.080806f
R1 g2395_2 g2395_0 2.224404
C4 1 gnd 2.080806f
R2 g2395_0 1 2.224404
R3 1 g2395_1 2.224404
.ends

.subckt netg3893 g3893_0 g3893_1 gnd
C1  g3893_0 gnd 2.080806f
C2  g3893_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3893_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g3893_1 2 2.224404
.ends

.subckt netg1513 g1513_0 g1513_1 gnd
C1  g1513_0 gnd 2.080806f
C2  g1513_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1513_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1513_1 2.224404
.ends

.subckt netg5677 g5677_0 g5677_2 g5677_1 gnd
C1  g5677_0 gnd 2.080806f
C2  g5677_2 gnd 2.080806f
C3  g5677_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5677_0 1 2.224404
R2 g5677_1 1 2.224404
R3 1 g5677_2 2.224404
.ends

.subckt netg5553 g5553_0 g5553_1 gnd
C1  g5553_0 gnd 2.080806f
C2  g5553_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5553_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5553_1 2.224404
.ends

.subckt netg7433 g7433_2 g7433_0 g7433_1 gnd
C1  g7433_2 gnd 2.080806f
C2  g7433_0 gnd 2.080806f
C3  g7433_1 gnd 2.080806f
R1 g7433_0 g7433_2 2.224404
C4 1 gnd 2.080806f
R2 1 g7433_0 2.224404
R3 g7433_1 1 2.224404
.ends

.subckt netg5861 g5861_0 g5861_2 g5861_1 gnd
C1  g5861_0 gnd 2.080806f
C2  g5861_2 gnd 2.080806f
C3  g5861_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5861_0 2.224404
R2 g5861_2 1 2.224404
R3 g5861_1 g5861_2 2.224404
.ends

.subckt netg6074 g6074_1 g6074_0 gnd
C1  g6074_1 gnd 2.080806f
C2  g6074_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6074_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6074_1 2 2.224404
.ends

.subckt netg5734 g5734_1 g5734_2 gnd
C1  g5734_1 gnd 2.080806f
C2  g5734_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5734_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5734_1 2.224404
.ends

.subckt netg4190 g4190_2 g4190_0 g4190_1 gnd
C1  g4190_2 gnd 2.080806f
C2  g4190_0 gnd 2.080806f
C3  g4190_1 gnd 2.080806f
R1 g4190_0 g4190_1 2.224404
C4 1 gnd 2.080806f
R2 g4190_1 1 2.224404
R3 1 g4190_2 2.224404
.ends

.subckt netg3504 g3504_1 g3504_0 gnd
C1  g3504_1 gnd 2.080806f
C2  g3504_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3504_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3504_1 2 2.224404
.ends

.subckt netg5967 g5967_1 g5967_0 gnd
C1  g5967_1 gnd 2.080806f
C2  g5967_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5967_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5967_1 2 2.224404
.ends

.subckt netg7000 g7000_1 g7000_0 gnd
C1  g7000_1 gnd 2.080806f
C2  g7000_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7000_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7000_1 2.224404
.ends

.subckt netg5522 g5522_2 g5522_0 g5522_1 gnd
C1  g5522_2 gnd 2.080806f
C2  g5522_0 gnd 2.080806f
C3  g5522_1 gnd 2.080806f
R1 g5522_1 g5522_0 2.224404
C4 1 gnd 2.080806f
R2 g5522_0 1 2.224404
R3 1 g5522_2 2.224404
.ends

.subckt netg3441 g3441_1 g3441_2 gnd
C1  g3441_1 gnd 2.080806f
C2  g3441_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3441_2 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3441_1 2 2.224404
.ends

.subckt netg6535 g6535_1 g6535_0 gnd
C1  g6535_1 gnd 2.080806f
C2  g6535_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6535_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6535_1 2 2.224404
.ends

.subckt netg6541 g6541_1 g6541_0 gnd
C1  g6541_1 gnd 2.080806f
C2  g6541_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6541_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6541_1 2 2.224404
.ends

.subckt netg3485 g3485_1 g3485_0 gnd
C1  g3485_1 gnd 2.080806f
C2  g3485_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3485_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3485_1 2 2.224404
.ends

.subckt netg4617 g4617_1 g4617_0 gnd
C1  g4617_1 gnd 2.080806f
C2  g4617_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4617_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4617_1 2 2.224404
.ends

.subckt netg1579 g1579_1 g1579_0 gnd
C1  g1579_1 gnd 2.080806f
C2  g1579_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1579_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1579_1 2 2.224404
.ends

.subckt netg4151 g4151_1 g4151_2 g4151_0 gnd
C1  g4151_1 gnd 2.080806f
C2  g4151_2 gnd 2.080806f
C3  g4151_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4151_0 2.224404
R2 g4151_1 1 2.224404
R3 1 g4151_2 2.224404
.ends

.subckt netg4213 g4213_1 g4213_2 gnd
C1  g4213_1 gnd 2.080806f
C2  g4213_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4213_1 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4213_2 2.224404
.ends

.subckt netg6093 g6093_2 g6093_1 g6093_0 gnd
C1  g6093_2 gnd 2.080806f
C2  g6093_1 gnd 2.080806f
C3  g6093_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6093_0 2.224404
R2 g6093_2 1 2.224404
R3 g6093_1 g6093_2 2.224404
.ends

.subckt netg3569 g3569_0 g3569_1 gnd
C1  g3569_0 gnd 2.080806f
C2  g3569_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3569_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3569_1 2 2.224404
.ends

.subckt netg2800 g2800_0 g2800_1 gnd
C1  g2800_0 gnd 2.080806f
C2  g2800_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2800_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2800_1 2 2.224404
.ends

.subckt netg5089 g5089_0 g5089_2 g5089_1 gnd
C1  g5089_0 gnd 2.080806f
C2  g5089_2 gnd 2.080806f
C3  g5089_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5089_0 2.224404
R2 g5089_1 1 2.224404
R3 g5089_2 1 2.224404
.ends

.subckt netg6467 g6467_1 g6467_0 gnd
C1  g6467_1 gnd 2.080806f
C2  g6467_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6467_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6467_1 2 2.224404
.ends

.subckt netg6856 g6856_1 g6856_2 g6856_0 gnd
C1  g6856_1 gnd 2.080806f
C2  g6856_2 gnd 2.080806f
C3  g6856_0 gnd 2.080806f
R1 g6856_1 g6856_0 2.224404
C4 1 gnd 2.080806f
R2 g6856_0 1 2.224404
R3 1 g6856_2 2.224404
.ends

.subckt netg7312 g7312_2 g7312_0 g7312_1 gnd
C1  g7312_2 gnd 2.080806f
C2  g7312_0 gnd 2.080806f
C3  g7312_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7312_0 1 2.224404
R2 1 g7312_1 2.224404
R3 1 g7312_2 2.224404
.ends

.subckt netg2958 g2958_0 g2958_1 gnd
C1  g2958_0 gnd 2.080806f
C2  g2958_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2958_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2958_1 2.224404
.ends

.subckt netg6327 g6327_0 g6327_1 gnd
C1  g6327_0 gnd 2.080806f
C2  g6327_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6327_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6327_1 2.224404
.ends

.subckt netg4178 g4178_1 g4178_0 gnd
C1  g4178_1 gnd 2.080806f
C2  g4178_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4178_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g4178_1 2.224404
.ends

.subckt netg5886 g5886_1 g5886_0 gnd
C1  g5886_1 gnd 2.080806f
C2  g5886_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5886_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5886_1 2 2.224404
.ends

.subckt netg6315 g6315_1 g6315_0 gnd
C1  g6315_1 gnd 2.080806f
C2  g6315_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6315_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6315_1 2.224404
.ends

.subckt netg2561 g2561_2 g2561_1 g2561_0 gnd
C1  g2561_2 gnd 2.080806f
C2  g2561_1 gnd 2.080806f
C3  g2561_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2561_0 2.224404
R2 g2561_1 1 2.224404
R3 g2561_1 g2561_2 2.224404
.ends

.subckt netg1571 g1571_1 g1571_0 gnd
C1  g1571_1 gnd 2.080806f
C2  g1571_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1571_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1571_1 2 2.224404
.ends

.subckt netg1435 g1435_1 g1435_0 gnd
C1  g1435_1 gnd 2.080806f
C2  g1435_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1435_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1435_1 2.224404
.ends

.subckt netg991 g991_2 g991_0 gnd
C1  g991_2 gnd 2.080806f
C2  g991_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g991_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g991_2 2 2.224404
.ends

.subckt netg6551 g6551_0 g6551_1 gnd
C1  g6551_0 gnd 2.080806f
C2  g6551_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6551_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6551_1 2.224404
.ends

.subckt netg6374 g6374_1 g6374_2 g6374_0 gnd
C1  g6374_1 gnd 2.080806f
C2  g6374_2 gnd 2.080806f
C3  g6374_0 gnd 2.080806f
R1 g6374_1 g6374_0 2.224404
C4 1 gnd 2.080806f
R2 g6374_0 1 2.224404
R3 1 g6374_2 2.224404
.ends

.subckt netg2353 g2353_0 g2353_1 g2353_2 gnd
C1  g2353_0 gnd 2.080806f
C2  g2353_1 gnd 2.080806f
C3  g2353_2 gnd 2.080806f
R1 g2353_0 g2353_2 2.224404
C4 1 gnd 2.080806f
R2 g2353_2 1 2.224404
R3 1 g2353_1 2.224404
.ends

.subckt netg2618 g2618_1 g2618_2 gnd
C1  g2618_1 gnd 2.080806f
C2  g2618_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2618_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2618_1 2.224404
.ends

.subckt netg1253 g1253_1 g1253_0 gnd
C1  g1253_1 gnd 2.080806f
C2  g1253_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1253_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1253_1 2.224404
.ends

.subckt netg2450 g2450_0 g2450_1 g2450_2 gnd
C1  g2450_0 gnd 2.080806f
C2  g2450_1 gnd 2.080806f
C3  g2450_2 gnd 2.080806f
R1 g2450_1 g2450_0 2.224404
C4 1 gnd 2.080806f
R2 g2450_0 1 2.224404
R3 1 g2450_2 2.224404
.ends

.subckt netg5731 g5731_0 g5731_1 g5731_2 gnd
C1  g5731_0 gnd 2.080806f
C2  g5731_1 gnd 2.080806f
C3  g5731_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5731_0 2.224404
R2 g5731_2 1 2.224404
R3 g5731_1 g5731_2 2.224404
.ends

.subckt netg2627 g2627_0 g2627_2 g2627_1 gnd
C1  g2627_0 gnd 2.080806f
C2  g2627_2 gnd 2.080806f
C3  g2627_1 gnd 2.080806f
R1 g2627_1 g2627_0 2.224404
C4 1 gnd 2.080806f
R2 g2627_1 1 2.224404
R3 1 g2627_2 2.224404
.ends

.subckt netg3303 g3303_1 g3303_2 gnd
C1  g3303_1 gnd 2.080806f
C2  g3303_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3303_2 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g3303_1 2.224404
.ends

.subckt netg6124 g6124_1 g6124_0 g6124_2 gnd
C1  g6124_1 gnd 2.080806f
C2  g6124_0 gnd 2.080806f
C3  g6124_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6124_0 1 2.224404
R2 1 g6124_2 2.224404
R3 g6124_1 g6124_2 2.224404
.ends

.subckt netg6893 g6893_1 g6893_0 gnd
C1  g6893_1 gnd 2.080806f
C2  g6893_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6893_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6893_1 2.224404
.ends

.subckt netg3058 g3058_0 g3058_1 gnd
C1  g3058_0 gnd 2.080806f
C2  g3058_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3058_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g3058_1 2 2.224404
.ends

.subckt netg6987 g6987_2 g6987_1 g6987_0 gnd
C1  g6987_2 gnd 2.080806f
C2  g6987_1 gnd 2.080806f
C3  g6987_0 gnd 2.080806f
R1 g6987_1 g6987_0 2.224404
C4 1 gnd 2.080806f
R2 g6987_0 1 2.224404
R3 1 g6987_2 2.224404
.ends

.subckt netg5036 g5036_1 g5036_0 g5036_2 gnd
C1  g5036_1 gnd 2.080806f
C2  g5036_0 gnd 2.080806f
C3  g5036_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5036_0 1 2.224404
R2 1 g5036_1 2.224404
R3 g5036_1 g5036_2 2.224404
.ends

.subckt netg1581 g1581_0 g1581_1 gnd
C1  g1581_0 gnd 2.080806f
C2  g1581_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1581_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1581_1 2 2.224404
.ends

.subckt netg6625 g6625_2 g6625_1 g6625_0 gnd
C1  g6625_2 gnd 2.080806f
C2  g6625_1 gnd 2.080806f
C3  g6625_0 gnd 2.080806f
R1 g6625_0 g6625_1 2.224404
C4 1 gnd 2.080806f
R2 g6625_1 1 2.224404
R3 1 g6625_2 2.224404
.ends

.subckt netg4448 g4448_1 g4448_0 gnd
C1  g4448_1 gnd 2.080806f
C2  g4448_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4448_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4448_1 2 2.224404
.ends

.subckt netg955 g955_0 g955_2 g955_1 gnd
C1  g955_0 gnd 2.080806f
C2  g955_2 gnd 2.080806f
C3  g955_1 gnd 2.080806f
R1 g955_0 g955_1 2.224404
C4 1 gnd 2.080806f
R2 1 g955_0 2.224404
R3 g955_2 1 2.224404
.ends

.subckt netg3987 g3987_0 g3987_1 gnd
C1  g3987_0 gnd 2.080806f
C2  g3987_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3987_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3987_1 2 2.224404
.ends

.subckt netg4045 g4045_0 g4045_1 gnd
C1  g4045_0 gnd 2.080806f
C2  g4045_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4045_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4045_1 2 2.224404
.ends

.subckt netg1932 g1932_0 g1932_1 gnd
C1  g1932_0 gnd 2.080806f
C2  g1932_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1932_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1932_1 2 2.224404
.ends

.subckt netg3538 g3538_1 g3538_0 gnd
C1  g3538_1 gnd 2.080806f
C2  g3538_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3538_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3538_1 2.224404
.ends

.subckt netg2659 g2659_1 g2659_0 g2659_2 gnd
C1  g2659_1 gnd 2.080806f
C2  g2659_0 gnd 2.080806f
C3  g2659_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2659_0 1 2.224404
R2 1 g2659_2 2.224404
R3 g2659_2 g2659_1 2.224404
.ends

.subckt netx272 x272_0 x272_1 gnd
C1  x272_0 gnd 2.080806f
C2  x272_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x272_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x272_1 2 2.224404
.ends

.subckt netg2805 g2805_0 g2805_1 gnd
C1  g2805_0 gnd 2.080806f
C2  g2805_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2805_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2805_1 2.224404
.ends

.subckt netg5107 g5107_0 g5107_2 g5107_1 gnd
C1  g5107_0 gnd 2.080806f
C2  g5107_2 gnd 2.080806f
C3  g5107_1 gnd 2.080806f
R1 g5107_0 g5107_1 2.224404
C4 1 gnd 2.080806f
R2 g5107_0 1 2.224404
R3 g5107_2 1 2.224404
.ends

.subckt netg3918 g3918_1 g3918_0 gnd
C1  g3918_1 gnd 2.080806f
C2  g3918_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3918_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3918_1 2.224404
.ends

.subckt netg6904 g6904_1 g6904_0 gnd
C1  g6904_1 gnd 2.080806f
C2  g6904_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6904_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6904_1 2.224404
.ends

.subckt netg6400 g6400_0 g6400_1 gnd
C1  g6400_0 gnd 2.080806f
C2  g6400_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6400_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6400_1 2.224404
.ends

.subckt netg6515 g6515_1 g6515_0 gnd
C1  g6515_1 gnd 2.080806f
C2  g6515_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6515_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6515_1 2.224404
.ends

.subckt netg2573 g2573_2 g2573_1 g2573_0 gnd
C1  g2573_2 gnd 2.080806f
C2  g2573_1 gnd 2.080806f
C3  g2573_0 gnd 2.080806f
R1 g2573_1 g2573_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2573_1 2.224404
R3 g2573_2 1 2.224404
.ends

.subckt netg6096 g6096_1 g6096_2 gnd
C1  g6096_1 gnd 2.080806f
C2  g6096_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6096_2 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6096_1 2.224404
.ends

.subckt netg6829 g6829_2 g6829_1 g6829_0 g6829_3 gnd
C1  g6829_2 gnd 2.080806f
C2  g6829_1 gnd 2.080806f
C3  g6829_0 gnd 2.080806f
C4  g6829_3 gnd 2.080806f
R1 g6829_3 g6829_0 2.224404
R2 g6829_2 g6829_3 2.224404
R3 g6829_1 g6829_2 2.224404
.ends

.subckt netg5407 g5407_1 g5407_0 gnd
C1  g5407_1 gnd 2.080806f
C2  g5407_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5407_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5407_1 2 2.224404
.ends

.subckt netg4303 g4303_0 g4303_1 gnd
C1  g4303_0 gnd 2.080806f
C2  g4303_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4303_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g4303_1 2.224404
.ends

.subckt netg3321 g3321_0 g3321_1 g3321_2 gnd
C1  g3321_0 gnd 2.080806f
C2  g3321_1 gnd 2.080806f
C3  g3321_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3321_0 1 2.224404
R2 1 g3321_1 2.224404
R3 g3321_1 g3321_2 2.224404
.ends

.subckt netg895 g895_2 g895_1 g895_0 gnd
C1  g895_2 gnd 2.080806f
C2  g895_1 gnd 2.080806f
C3  g895_0 gnd 2.080806f
R1 g895_0 g895_2 2.224404
C4 1 gnd 2.080806f
R2 g895_2 1 2.224404
R3 1 g895_1 2.224404
.ends

.subckt netg6715 g6715_0 g6715_1 g6715_2 gnd
C1  g6715_0 gnd 2.080806f
C2  g6715_1 gnd 2.080806f
C3  g6715_2 gnd 2.080806f
R1 g6715_0 g6715_2 2.224404
C4 1 gnd 2.080806f
R2 g6715_0 1 2.224404
R3 1 g6715_1 2.224404
.ends

.subckt netx382 x382_1 x382_0 gnd
C1  x382_1 gnd 2.080806f
C2  x382_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x382_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x382_1 2 2.224404
.ends

.subckt netg2600 g2600_2 g2600_0 g2600_1 gnd
C1  g2600_2 gnd 2.080806f
C2  g2600_0 gnd 2.080806f
C3  g2600_1 gnd 2.080806f
R1 g2600_0 g2600_1 2.224404
C4 1 gnd 2.080806f
R2 1 g2600_1 2.224404
R3 g2600_2 1 2.224404
.ends

.subckt netg3386 g3386_1 g3386_2 g3386_0 gnd
C1  g3386_1 gnd 2.080806f
C2  g3386_2 gnd 2.080806f
C3  g3386_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3386_0 2.224404
R2 g3386_2 1 2.224404
R3 g3386_2 g3386_1 2.224404
.ends

.subckt netg3297 g3297_2 g3297_1 g3297_0 gnd
C1  g3297_2 gnd 2.080806f
C2  g3297_1 gnd 2.080806f
C3  g3297_0 gnd 2.080806f
R1 g3297_2 g3297_0 2.224404
C4 1 gnd 2.080806f
R2 1 g3297_2 2.224404
R3 1 g3297_1 2.224404
.ends

.subckt netg3527 g3527_0 g3527_1 gnd
C1  g3527_0 gnd 2.080806f
C2  g3527_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3527_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3527_1 2.224404
.ends

.subckt netg7444 g7444_1 g7444_0 gnd
C1  g7444_1 gnd 2.080806f
C2  g7444_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7444_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7444_1 2.224404
.ends

.subckt netg4296 g4296_0 g4296_1 gnd
C1  g4296_0 gnd 2.080806f
C2  g4296_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4296_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4296_1 2.224404
.ends

.subckt netg5593 g5593_2 g5593_1 g5593_0 gnd
C1  g5593_2 gnd 2.080806f
C2  g5593_1 gnd 2.080806f
C3  g5593_0 gnd 2.080806f
R1 g5593_0 g5593_1 2.224404
C4 1 gnd 2.080806f
R2 1 g5593_0 2.224404
R3 g5593_2 1 2.224404
.ends

.subckt netg2806 g2806_1 g2806_0 gnd
C1  g2806_1 gnd 2.080806f
C2  g2806_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2806_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2806_1 2.224404
.ends

.subckt netg2917 g2917_1 g2917_0 gnd
C1  g2917_1 gnd 2.080806f
C2  g2917_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2917_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2917_1 2 2.224404
.ends

.subckt netg4985 g4985_2 g4985_1 g4985_0 gnd
C1  g4985_2 gnd 2.080806f
C2  g4985_1 gnd 2.080806f
C3  g4985_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4985_0 2.224404
R2 g4985_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g4985_0 2.224404
R4 g4985_2 2 2.224404
.ends

.subckt netg4060 g4060_0 g4060_1 gnd
C1  g4060_0 gnd 2.080806f
C2  g4060_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4060_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4060_1 2.224404
.ends

.subckt netg1387 g1387_0 g1387_1 g1387_2 gnd
C1  g1387_0 gnd 2.080806f
C2  g1387_1 gnd 2.080806f
C3  g1387_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1387_0 1 2.224404
R2 1 g1387_2 2.224404
R3 g1387_2 g1387_1 2.224404
.ends

.subckt netg5003 g5003_1 g5003_2 g5003_0 gnd
C1  g5003_1 gnd 2.080806f
C2  g5003_2 gnd 2.080806f
C3  g5003_0 gnd 2.080806f
R1 g5003_2 g5003_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5003_2 2.224404
R3 g5003_1 1 2.224404
.ends

.subckt netg2044 g2044_0 g2044_1 gnd
C1  g2044_0 gnd 2.080806f
C2  g2044_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2044_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2044_1 2 2.224404
.ends

.subckt netg6685 g6685_0 g6685_1 gnd
C1  g6685_0 gnd 2.080806f
C2  g6685_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6685_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6685_1 2 2.224404
.ends

.subckt netg5387 g5387_0 g5387_1 gnd
C1  g5387_0 gnd 2.080806f
C2  g5387_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5387_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5387_1 2.224404
.ends

.subckt netg1871 g1871_2 g1871_1 g1871_0 gnd
C1  g1871_2 gnd 2.080806f
C2  g1871_1 gnd 2.080806f
C3  g1871_0 gnd 2.080806f
R1 g1871_2 g1871_0 2.224404
C4 1 gnd 2.080806f
R2 g1871_0 1 2.224404
R3 1 g1871_1 2.224404
.ends

.subckt netg4401 g4401_0 g4401_1 gnd
C1  g4401_0 gnd 2.080806f
C2  g4401_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4401_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4401_1 2.224404
.ends

.subckt netg1865 g1865_1 g1865_0 g1865_2 gnd
C1  g1865_1 gnd 2.080806f
C2  g1865_0 gnd 2.080806f
C3  g1865_2 gnd 2.080806f
R1 g1865_0 g1865_1 2.224404
C4 1 gnd 2.080806f
R2 g1865_1 1 2.224404
R3 1 g1865_2 2.224404
.ends

.subckt netg4887 g4887_1 g4887_2 g4887_0 gnd
C1  g4887_1 gnd 2.080806f
C2  g4887_2 gnd 2.080806f
C3  g4887_0 gnd 2.080806f
R1 g4887_2 g4887_0 2.224404
C4 1 gnd 2.080806f
R2 g4887_0 1 2.224404
R3 1 g4887_1 2.224404
.ends

.subckt netg3192 g3192_1 g3192_2 g3192_0 gnd
C1  g3192_1 gnd 2.080806f
C2  g3192_2 gnd 2.080806f
C3  g3192_0 gnd 2.080806f
R1 g3192_2 g3192_0 2.224404
C4 1 gnd 2.080806f
R2 1 g3192_0 2.224404
R3 1 g3192_1 2.224404
.ends

.subckt netg2471 g2471_0 g2471_2 g2471_1 gnd
C1  g2471_0 gnd 2.080806f
C2  g2471_2 gnd 2.080806f
C3  g2471_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2471_0 2.224404
R2 1 g2471_1 2.224404
C5 2 gnd 2.080806f
R3 g2471_0 2 2.224404
R4 2 g2471_2 2.224404
.ends

.subckt netg6226 g6226_1 g6226_0 g6226_2 gnd
C1  g6226_1 gnd 2.080806f
C2  g6226_0 gnd 2.080806f
C3  g6226_2 gnd 2.080806f
R1 g6226_1 g6226_0 2.224404
C4 1 gnd 2.080806f
R2 1 g6226_1 2.224404
R3 g6226_2 1 2.224404
.ends

.subckt netg5909 g5909_1 g5909_0 g5909_2 gnd
C1  g5909_1 gnd 2.080806f
C2  g5909_0 gnd 2.080806f
C3  g5909_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5909_0 1 2.224404
R2 1 g5909_2 2.224404
R3 g5909_1 g5909_2 2.224404
.ends

.subckt netg4764 g4764_1 g4764_2 g4764_0 gnd
C1  g4764_1 gnd 2.080806f
C2  g4764_2 gnd 2.080806f
C3  g4764_0 gnd 2.080806f
R1 g4764_0 g4764_1 2.224404
C4 1 gnd 2.080806f
R2 g4764_1 1 2.224404
R3 1 g4764_2 2.224404
.ends

.subckt netg4157 g4157_0 g4157_2 gnd
C1  g4157_0 gnd 2.080806f
C2  g4157_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4157_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4157_2 2 2.224404
.ends

.subckt netg5232 g5232_0 g5232_1 gnd
C1  g5232_0 gnd 2.080806f
C2  g5232_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5232_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5232_1 2.224404
.ends

.subckt netg1137 g1137_1 g1137_0 gnd
C1  g1137_1 gnd 2.080806f
C2  g1137_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1137_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1137_1 2.224404
.ends

.subckt netx282 x282_1 x282_0 gnd
C1  x282_1 gnd 2.080806f
C2  x282_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x282_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 x282_1 2.224404
.ends

.subckt netg1553 g1553_0 g1553_1 gnd
C1  g1553_0 gnd 2.080806f
C2  g1553_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1553_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1553_1 2.224404
.ends

.subckt netg4667 g4667_0 g4667_1 gnd
C1  g4667_0 gnd 2.080806f
C2  g4667_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4667_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4667_1 2 2.224404
.ends

.subckt netg1073 g1073_1 g1073_0 g1073_2 gnd
C1  g1073_1 gnd 2.080806f
C2  g1073_0 gnd 2.080806f
C3  g1073_2 gnd 2.080806f
R1 g1073_1 g1073_0 2.224404
C4 1 gnd 2.080806f
R2 1 g1073_1 2.224404
R3 g1073_2 1 2.224404
.ends

.subckt netg2829 g2829_1 g2829_0 gnd
C1  g2829_1 gnd 2.080806f
C2  g2829_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2829_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2829_1 2.224404
.ends

.subckt netg1042 g1042_1 g1042_0 g1042_2 gnd
C1  g1042_1 gnd 2.080806f
C2  g1042_0 gnd 2.080806f
C3  g1042_2 gnd 2.080806f
R1 g1042_0 g1042_2 2.224404
C4 1 gnd 2.080806f
R2 1 g1042_0 2.224404
R3 1 g1042_1 2.224404
.ends

.subckt netg6419 g6419_0 g6419_1 gnd
C1  g6419_0 gnd 2.080806f
C2  g6419_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6419_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6419_1 2 2.224404
.ends

.subckt netg3554 g3554_1 g3554_0 gnd
C1  g3554_1 gnd 2.080806f
C2  g3554_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3554_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3554_1 2.224404
.ends

.subckt netg3474 g3474_1 g3474_0 gnd
C1  g3474_1 gnd 2.080806f
C2  g3474_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3474_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3474_1 2.224404
.ends

.subckt netg6824 g6824_1 g6824_0 gnd
C1  g6824_1 gnd 2.080806f
C2  g6824_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6824_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6824_1 2.224404
.ends

.subckt netg5160 g5160_1 g5160_0 g5160_2 gnd
C1  g5160_1 gnd 2.080806f
C2  g5160_0 gnd 2.080806f
C3  g5160_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5160_0 2.224404
R2 g5160_1 1 2.224404
R3 1 g5160_2 2.224404
.ends

.subckt netg4781 g4781_1 g4781_0 g4781_2 gnd
C1  g4781_1 gnd 2.080806f
C2  g4781_0 gnd 2.080806f
C3  g4781_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4781_0 1 2.224404
R2 1 g4781_2 2.224404
R3 g4781_2 g4781_1 2.224404
.ends

.subckt netx441 x441_0 x441_1 gnd
C1  x441_0 gnd 2.080806f
C2  x441_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x441_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x441_1 2 2.224404
.ends

.subckt netg7041 g7041_1 g7041_2 g7041_0 gnd
C1  g7041_1 gnd 2.080806f
C2  g7041_2 gnd 2.080806f
C3  g7041_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7041_0 2.224404
R2 g7041_2 1 2.224404
R3 g7041_2 g7041_1 2.224404
.ends

.subckt netg3502 g3502_1 g3502_0 gnd
C1  g3502_1 gnd 2.080806f
C2  g3502_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3502_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3502_1 2 2.224404
.ends

.subckt netg5858 g5858_0 g5858_1 gnd
C1  g5858_0 gnd 2.080806f
C2  g5858_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5858_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5858_1 2 2.224404
.ends

.subckt netg5951 g5951_0 g5951_1 gnd
C1  g5951_0 gnd 2.080806f
C2  g5951_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5951_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g5951_1 2.224404
.ends

.subckt netg1433 g1433_1 g1433_0 gnd
C1  g1433_1 gnd 2.080806f
C2  g1433_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1433_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1433_1 2 2.224404
.ends

.subckt netg6116 g6116_0 g6116_2 g6116_1 gnd
C1  g6116_0 gnd 2.080806f
C2  g6116_2 gnd 2.080806f
C3  g6116_1 gnd 2.080806f
R1 g6116_1 g6116_0 2.224404
C4 1 gnd 2.080806f
R2 g6116_0 1 2.224404
R3 1 g6116_2 2.224404
.ends

.subckt netg7106 g7106_0 g7106_1 gnd
C1  g7106_0 gnd 2.080806f
C2  g7106_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7106_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7106_1 2.224404
.ends

.subckt netg6193 g6193_0 g6193_1 gnd
C1  g6193_0 gnd 2.080806f
C2  g6193_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6193_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6193_1 2 2.224404
.ends

.subckt netg6386 g6386_1 g6386_0 gnd
C1  g6386_1 gnd 2.080806f
C2  g6386_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6386_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6386_1 2 2.224404
.ends

.subckt netg4405 g4405_0 g4405_1 gnd
C1  g4405_0 gnd 2.080806f
C2  g4405_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4405_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4405_1 2.224404
.ends

.subckt netg937 g937_2 g937_0 g937_1 gnd
C1  g937_2 gnd 2.080806f
C2  g937_0 gnd 2.080806f
C3  g937_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g937_0 2.224404
R2 g937_1 1 2.224404
R3 g937_1 g937_2 2.224404
.ends

.subckt netg2347 g2347_0 g2347_2 g2347_1 gnd
C1  g2347_0 gnd 2.080806f
C2  g2347_2 gnd 2.080806f
C3  g2347_1 gnd 2.080806f
R1 g2347_1 g2347_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2347_0 2.224404
R3 g2347_2 1 2.224404
.ends

.subckt netg3219 g3219_1 g3219_2 g3219_0 gnd
C1  g3219_1 gnd 2.080806f
C2  g3219_2 gnd 2.080806f
C3  g3219_0 gnd 2.080806f
R1 g3219_0 g3219_2 2.224404
C4 1 gnd 2.080806f
R2 g3219_2 1 2.224404
R3 1 g3219_1 2.224404
.ends

.subckt netg1311 g1311_1 g1311_0 gnd
C1  g1311_1 gnd 2.080806f
C2  g1311_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1311_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g1311_1 2.224404
.ends

.subckt netg3054 g3054_1 g3054_0 gnd
C1  g3054_1 gnd 2.080806f
C2  g3054_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3054_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3054_1 2.224404
.ends

.subckt netg964 g964_1 g964_0 g964_2 gnd
C1  g964_1 gnd 2.080806f
C2  g964_0 gnd 2.080806f
C3  g964_2 gnd 2.080806f
R1 g964_0 g964_2 2.224404
C4 1 gnd 2.080806f
R2 g964_2 1 2.224404
R3 1 g964_1 2.224404
.ends

.subckt netg6941 g6941_1 g6941_0 gnd
C1  g6941_1 gnd 2.080806f
C2  g6941_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6941_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6941_1 2 2.224404
.ends

.subckt netg1552 g1552_0 g1552_1 gnd
C1  g1552_0 gnd 2.080806f
C2  g1552_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1552_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1552_1 2.224404
.ends

.subckt netg3222 g3222_0 g3222_2 g3222_1 gnd
C1  g3222_0 gnd 2.080806f
C2  g3222_2 gnd 2.080806f
C3  g3222_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3222_0 2.224404
R2 1 g3222_2 2.224404
R3 g3222_1 g3222_2 2.224404
.ends

.subckt netg6527 g6527_0 g6527_1 gnd
C1  g6527_0 gnd 2.080806f
C2  g6527_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6527_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6527_1 2.224404
.ends

.subckt netg5508 g5508_2 g5508_0 g5508_1 gnd
C1  g5508_2 gnd 2.080806f
C2  g5508_0 gnd 2.080806f
C3  g5508_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5508_0 1 2.224404
R2 1 g5508_2 2.224404
R3 g5508_2 g5508_1 2.224404
.ends

.subckt netg4095 g4095_1 g4095_0 gnd
C1  g4095_1 gnd 2.080806f
C2  g4095_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4095_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4095_1 2.224404
.ends

.subckt netg898 g898_1 g898_2 g898_0 gnd
C1  g898_1 gnd 2.080806f
C2  g898_2 gnd 2.080806f
C3  g898_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g898_0 2.224404
R2 g898_1 1 2.224404
R3 g898_2 g898_1 2.224404
.ends

.subckt netg1175 g1175_1 g1175_0 gnd
C1  g1175_1 gnd 2.080806f
C2  g1175_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1175_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g1175_1 2.224404
.ends

.subckt netg6478 g6478_1 g6478_2 g6478_0 gnd
C1  g6478_1 gnd 2.080806f
C2  g6478_2 gnd 2.080806f
C3  g6478_0 gnd 2.080806f
R1 g6478_0 g6478_1 2.224404
C4 1 gnd 2.080806f
R2 1 g6478_0 2.224404
R3 g6478_2 1 2.224404
.ends

.subckt netg7357 g7357_1 g7357_0 gnd
C1  g7357_1 gnd 2.080806f
C2  g7357_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7357_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g7357_1 2.224404
.ends

.subckt netg7343 g7343_1 g7343_0 gnd
C1  g7343_1 gnd 2.080806f
C2  g7343_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7343_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g7343_1 2.224404
.ends

.subckt netg919 g919_2 g919_1 g919_0 gnd
C1  g919_2 gnd 2.080806f
C2  g919_1 gnd 2.080806f
C3  g919_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g919_0 1 2.224404
R2 1 g919_2 2.224404
R3 g919_2 g919_1 2.224404
.ends

.subckt netg2716 g2716_1 g2716_0 g2716_2 gnd
C1  g2716_1 gnd 2.080806f
C2  g2716_0 gnd 2.080806f
C3  g2716_2 gnd 2.080806f
R1 g2716_0 g2716_1 2.224404
C4 1 gnd 2.080806f
R2 g2716_1 1 2.224404
R3 1 g2716_2 2.224404
.ends

.subckt netg3138 g3138_0 g3138_2 g3138_1 gnd
C1  g3138_0 gnd 2.080806f
C2  g3138_2 gnd 2.080806f
C3  g3138_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3138_0 2.224404
R2 1 g3138_1 2.224404
C5 2 gnd 2.080806f
R3 g3138_0 2 2.224404
R4 2 g3138_2 2.224404
.ends

.subckt netg1096 g1096_0 g1096_1 gnd
C1  g1096_0 gnd 2.080806f
C2  g1096_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1096_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1096_1 2.224404
.ends

.subckt netg4046 g4046_0 g4046_1 gnd
C1  g4046_0 gnd 2.080806f
C2  g4046_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4046_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4046_1 2 2.224404
.ends

.subckt netg7216 g7216_1 g7216_0 gnd
C1  g7216_1 gnd 2.080806f
C2  g7216_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7216_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7216_1 2.224404
.ends

.subckt netg4399 g4399_1 g4399_0 gnd
C1  g4399_1 gnd 2.080806f
C2  g4399_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4399_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4399_1 2.224404
.ends

.subckt netg7104 g7104_0 g7104_1 gnd
C1  g7104_0 gnd 2.080806f
C2  g7104_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7104_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7104_1 2 2.224404
.ends

.subckt netx71 x71_0 x71_1 gnd
C1  x71_0 gnd 2.080806f
C2  x71_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x71_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 x71_1 2 2.224404
.ends

.subckt netg3264 g3264_0 g3264_1 g3264_2 gnd
C1  g3264_0 gnd 2.080806f
C2  g3264_1 gnd 2.080806f
C3  g3264_2 gnd 2.080806f
R1 g3264_2 g3264_0 2.224404
C4 1 gnd 2.080806f
R2 1 g3264_2 2.224404
R3 g3264_1 1 2.224404
.ends

.subckt netg5194 g5194_2 g5194_0 g5194_1 gnd
C1  g5194_2 gnd 2.080806f
C2  g5194_0 gnd 2.080806f
C3  g5194_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5194_0 1 2.224404
R2 g5194_1 1 2.224404
R3 g5194_2 g5194_1 2.224404
.ends

.subckt netg4154 g4154_1 g4154_2 gnd
C1  g4154_1 gnd 2.080806f
C2  g4154_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4154_2 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4154_1 2 2.224404
.ends

.subckt netg6051 g6051_1 g6051_0 gnd
C1  g6051_1 gnd 2.080806f
C2  g6051_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6051_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g6051_1 2 2.224404
.ends

.subckt netg5954 g5954_1 g5954_0 gnd
C1  g5954_1 gnd 2.080806f
C2  g5954_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5954_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5954_1 2 2.224404
.ends

.subckt netg3542 g3542_1 g3542_0 gnd
C1  g3542_1 gnd 2.080806f
C2  g3542_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3542_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3542_1 2 2.224404
.ends

.subckt netg6883 g6883_1 g6883_0 gnd
C1  g6883_1 gnd 2.080806f
C2  g6883_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6883_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6883_1 2.224404
.ends

.subckt netg1844 g1844_3 g1844_1 g1844_2 gnd
C1  g1844_3 gnd 2.080806f
C2  g1844_1 gnd 2.080806f
C3  g1844_2 gnd 2.080806f
R1 g1844_2 g1844_3 2.224404
C4 1 gnd 2.080806f
R2 g1844_3 1 2.224404
R3 1 g1844_1 2.224404
.ends

.subckt netg4312 g4312_1 g4312_0 gnd
C1  g4312_1 gnd 2.080806f
C2  g4312_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4312_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4312_1 2 2.224404
.ends

.subckt netx351 x351_0 x351_1 gnd
C1  x351_0 gnd 2.080806f
C2  x351_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x351_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x351_1 2 2.224404
.ends

.subckt netg3347 g3347_1 g3347_0 gnd
C1  g3347_1 gnd 2.080806f
C2  g3347_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3347_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3347_1 2.224404
.ends

.subckt netg6932 g6932_1 g6932_0 gnd
C1  g6932_1 gnd 2.080806f
C2  g6932_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6932_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6932_1 2.224404
.ends

.subckt netg681 g681_1 g681_0 gnd
C1  g681_1 gnd 2.080806f
C2  g681_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g681_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g681_1 2.224404
.ends

.subckt netg7441 g7441_1 g7441_0 gnd
C1  g7441_1 gnd 2.080806f
C2  g7441_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7441_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7441_1 2.224404
.ends

.subckt netg1283 g1283_0 g1283_1 gnd
C1  g1283_0 gnd 2.080806f
C2  g1283_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1283_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1283_1 2 2.224404
.ends

.subckt netg3309 g3309_0 g3309_2 g3309_1 gnd
C1  g3309_0 gnd 2.080806f
C2  g3309_2 gnd 2.080806f
C3  g3309_1 gnd 2.080806f
R1 g3309_0 g3309_1 2.224404
C4 1 gnd 2.080806f
R2 g3309_0 1 2.224404
R3 1 g3309_2 2.224404
.ends

.subckt netg7017 g7017_0 g7017_1 gnd
C1  g7017_0 gnd 2.080806f
C2  g7017_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7017_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7017_1 2 2.224404
.ends

.subckt netg6637 g6637_1 g6637_0 g6637_2 gnd
C1  g6637_1 gnd 2.080806f
C2  g6637_0 gnd 2.080806f
C3  g6637_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6637_0 1 2.224404
R2 1 g6637_1 2.224404
R3 g6637_1 g6637_2 2.224404
.ends

.subckt netg7291 g7291_1 g7291_0 gnd
C1  g7291_1 gnd 2.080806f
C2  g7291_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7291_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7291_1 2.224404
.ends

.subckt netg2374 g2374_2 g2374_0 g2374_1 gnd
C1  g2374_2 gnd 2.080806f
C2  g2374_0 gnd 2.080806f
C3  g2374_1 gnd 2.080806f
R1 g2374_1 g2374_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2374_1 2.224404
R3 g2374_2 1 2.224404
.ends

.subckt netg3921 g3921_1 g3921_0 gnd
C1  g3921_1 gnd 2.080806f
C2  g3921_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3921_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g3921_1 2 2.224404
.ends

.subckt netg1229 g1229_0 g1229_1 gnd
C1  g1229_0 gnd 2.080806f
C2  g1229_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1229_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1229_1 2.224404
.ends

.subckt netx521 x521_1 x521_0 gnd
C1  x521_1 gnd 2.080806f
C2  x521_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x521_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 x521_1 2.224404
.ends

.subckt netx182 x182_0 x182_1 gnd
C1  x182_0 gnd 2.080806f
C2  x182_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x182_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 x182_1 2.224404
.ends

.subckt netg7134 g7134_2 g7134_0 g7134_1 gnd
C1  g7134_2 gnd 2.080806f
C2  g7134_0 gnd 2.080806f
C3  g7134_1 gnd 2.080806f
R1 g7134_1 g7134_0 2.224404
C4 1 gnd 2.080806f
R2 g7134_0 1 2.224404
R3 1 g7134_2 2.224404
.ends

.subckt netg6360 g6360_0 g6360_1 gnd
C1  g6360_0 gnd 2.080806f
C2  g6360_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6360_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g6360_1 2 2.224404
.ends

.subckt netg2638 g2638_0 g2638_2 g2638_1 gnd
C1  g2638_0 gnd 2.080806f
C2  g2638_2 gnd 2.080806f
C3  g2638_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2638_0 1 2.224404
R2 1 g2638_1 2.224404
R3 g2638_2 1 2.224404
.ends

.subckt netg6712 g6712_1 g6712_0 g6712_2 gnd
C1  g6712_1 gnd 2.080806f
C2  g6712_0 gnd 2.080806f
C3  g6712_2 gnd 2.080806f
R1 g6712_2 g6712_0 2.224404
C4 1 gnd 2.080806f
R2 g6712_0 1 2.224404
R3 1 g6712_1 2.224404
.ends

.subckt netg1021 g1021_0 g1021_2 g1021_1 gnd
C1  g1021_0 gnd 2.080806f
C2  g1021_2 gnd 2.080806f
C3  g1021_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g1021_0 2.224404
R2 1 g1021_1 2.224404
C5 2 gnd 2.080806f
R3 g1021_0 2 2.224404
R4 2 g1021_2 2.224404
.ends

.subckt netg5485 g5485_1 g5485_0 gnd
C1  g5485_1 gnd 2.080806f
C2  g5485_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5485_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5485_1 2 2.224404
.ends

.subckt netg2386 g2386_1 g2386_2 g2386_0 gnd
C1  g2386_1 gnd 2.080806f
C2  g2386_2 gnd 2.080806f
C3  g2386_0 gnd 2.080806f
R1 g2386_2 g2386_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2386_2 2.224404
R3 g2386_1 1 2.224404
.ends

.subckt netg5413 g5413_1 g5413_0 gnd
C1  g5413_1 gnd 2.080806f
C2  g5413_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5413_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5413_1 2 2.224404
.ends

.subckt netg2997 g2997_1 g2997_0 gnd
C1  g2997_1 gnd 2.080806f
C2  g2997_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2997_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2997_1 2 2.224404
.ends

.subckt netg1903 g1903_0 g1903_1 gnd
C1  g1903_0 gnd 2.080806f
C2  g1903_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1903_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1903_1 2 2.224404
.ends

.subckt netg2662 g2662_2 g2662_1 g2662_0 gnd
C1  g2662_2 gnd 2.080806f
C2  g2662_1 gnd 2.080806f
C3  g2662_0 gnd 2.080806f
R1 g2662_0 g2662_1 2.224404
C4 1 gnd 2.080806f
R2 1 g2662_0 2.224404
R3 g2662_2 1 2.224404
.ends

.subckt netg5465 g5465_1 g5465_0 gnd
C1  g5465_1 gnd 2.080806f
C2  g5465_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5465_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5465_1 2 2.224404
.ends

.subckt netg3395 g3395_0 g3395_1 g3395_2 gnd
C1  g3395_0 gnd 2.080806f
C2  g3395_1 gnd 2.080806f
C3  g3395_2 gnd 2.080806f
R1 g3395_2 g3395_0 2.224404
C4 1 gnd 2.080806f
R2 g3395_0 1 2.224404
R3 1 g3395_1 2.224404
.ends

.subckt netg6557 g6557_1 g6557_0 gnd
C1  g6557_1 gnd 2.080806f
C2  g6557_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6557_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6557_1 2.224404
.ends

.subckt netg2698 g2698_2 g2698_0 g2698_1 gnd
C1  g2698_2 gnd 2.080806f
C2  g2698_0 gnd 2.080806f
C3  g2698_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2698_0 2.224404
R2 g2698_1 1 2.224404
R3 g2698_2 g2698_1 2.224404
.ends

.subckt netg7007 g7007_1 g7007_0 gnd
C1  g7007_1 gnd 2.080806f
C2  g7007_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7007_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7007_1 2.224404
.ends

.subckt netg4255 g4255_0 g4255_1 gnd
C1  g4255_0 gnd 2.080806f
C2  g4255_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4255_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4255_1 2 2.224404
.ends

.subckt netg7274 g7274_0 g7274_1 gnd
C1  g7274_0 gnd 2.080806f
C2  g7274_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7274_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7274_1 2 2.224404
.ends

.subckt netg2734 g2734_2 g2734_1 gnd
C1  g2734_2 gnd 2.080806f
C2  g2734_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2734_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2734_2 2 2.224404
.ends

.subckt netg859 g859_2 g859_1 g859_0 gnd
C1  g859_2 gnd 2.080806f
C2  g859_1 gnd 2.080806f
C3  g859_0 gnd 2.080806f
R1 g859_2 g859_0 2.224404
C4 1 gnd 2.080806f
R2 1 g859_2 2.224404
R3 g859_1 1 2.224404
.ends

.subckt netg1221 g1221_1 g1221_0 gnd
C1  g1221_1 gnd 2.080806f
C2  g1221_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1221_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1221_1 2 2.224404
.ends

.subckt netg4105 g4105_1 g4105_0 gnd
C1  g4105_1 gnd 2.080806f
C2  g4105_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4105_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4105_1 2 2.224404
.ends

.subckt netg6421 g6421_1 g6421_0 gnd
C1  g6421_1 gnd 2.080806f
C2  g6421_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6421_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g6421_1 2 2.224404
.ends

.subckt netg7122 g7122_0 g7122_1 gnd
C1  g7122_0 gnd 2.080806f
C2  g7122_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7122_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7122_1 2 2.224404
.ends

.subckt netg4282 g4282_1 g4282_0 gnd
C1  g4282_1 gnd 2.080806f
C2  g4282_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4282_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4282_1 2 2.224404
.ends

.subckt netg3052 g3052_0 g3052_1 gnd
C1  g3052_0 gnd 2.080806f
C2  g3052_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3052_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3052_1 2.224404
.ends

.subckt netg3120 g3120_0 g3120_2 g3120_1 gnd
C1  g3120_0 gnd 2.080806f
C2  g3120_2 gnd 2.080806f
C3  g3120_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3120_0 2.224404
R2 g3120_1 1 2.224404
C5 2 gnd 2.080806f
R3 g3120_0 2 2.224404
R4 g3120_2 2 2.224404
.ends

.subckt netg2495 g2495_0 g2495_1 g2495_2 gnd
C1  g2495_0 gnd 2.080806f
C2  g2495_1 gnd 2.080806f
C3  g2495_2 gnd 2.080806f
R1 g2495_1 g2495_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2495_1 2.224404
R3 g2495_2 1 2.224404
.ends

.subckt netg5323 g5323_0 g5323_1 gnd
C1  g5323_0 gnd 2.080806f
C2  g5323_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5323_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5323_1 2.224404
.ends

.subckt netx241 x241_0 x241_1 gnd
C1  x241_0 gnd 2.080806f
C2  x241_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x241_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 x241_1 2.224404
.ends

.subckt netg1114 g1114_0 g1114_1 gnd
C1  g1114_0 gnd 2.080806f
C2  g1114_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1114_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1114_1 2.224404
.ends

.subckt netg2630 g2630_2 g2630_0 g2630_1 gnd
C1  g2630_2 gnd 2.080806f
C2  g2630_0 gnd 2.080806f
C3  g2630_1 gnd 2.080806f
R1 g2630_1 g2630_0 2.224404
C4 1 gnd 2.080806f
R2 g2630_0 1 2.224404
R3 1 g2630_2 2.224404
.ends

.subckt netx112 x112_1 x112_0 gnd
C1  x112_1 gnd 2.080806f
C2  x112_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x112_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x112_1 2 2.224404
.ends

.subckt netg5719 g5719_1 g5719_2 gnd
C1  g5719_1 gnd 2.080806f
C2  g5719_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5719_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5719_1 2.224404
.ends

.subckt netg3234 g3234_2 g3234_1 g3234_0 gnd
C1  g3234_2 gnd 2.080806f
C2  g3234_1 gnd 2.080806f
C3  g3234_0 gnd 2.080806f
R1 g3234_0 g3234_1 2.224404
C4 1 gnd 2.080806f
R2 g3234_1 1 2.224404
R3 1 g3234_2 2.224404
.ends

.subckt netg5836 g5836_2 g5836_1 g5836_0 gnd
C1  g5836_2 gnd 2.080806f
C2  g5836_1 gnd 2.080806f
C3  g5836_0 gnd 2.080806f
R1 g5836_1 g5836_0 2.224404
C4 1 gnd 2.080806f
R2 g5836_1 1 2.224404
R3 1 g5836_2 2.224404
.ends

.subckt netg7360 g7360_2 g7360_0 g7360_1 gnd
C1  g7360_2 gnd 2.080806f
C2  g7360_0 gnd 2.080806f
C3  g7360_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7360_0 1 2.224404
R2 g7360_1 1 2.224404
R3 1 g7360_2 2.224404
.ends

.subckt netg2459 g2459_2 g2459_1 g2459_0 gnd
C1  g2459_2 gnd 2.080806f
C2  g2459_1 gnd 2.080806f
C3  g2459_0 gnd 2.080806f
R1 g2459_2 g2459_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2459_0 2.224404
R3 g2459_1 1 2.224404
.ends

.subckt netg3352 g3352_0 g3352_2 g3352_1 gnd
C1  g3352_0 gnd 2.080806f
C2  g3352_2 gnd 2.080806f
C3  g3352_1 gnd 2.080806f
R1 g3352_0 g3352_1 2.224404
C4 1 gnd 2.080806f
R2 g3352_0 1 2.224404
R3 1 g3352_2 2.224404
.ends

.subckt netg5098 g5098_2 g5098_1 g5098_0 gnd
C1  g5098_2 gnd 2.080806f
C2  g5098_1 gnd 2.080806f
C3  g5098_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5098_0 2.224404
R2 g5098_1 1 2.224404
R3 g5098_2 g5098_1 2.224404
.ends

.subckt netg7100 g7100_0 g7100_1 gnd
C1  g7100_0 gnd 2.080806f
C2  g7100_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7100_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g7100_1 2 2.224404
.ends

.subckt netg5115 g5115_1 g5115_0 g5115_2 gnd
C1  g5115_1 gnd 2.080806f
C2  g5115_0 gnd 2.080806f
C3  g5115_2 gnd 2.080806f
R1 g5115_0 g5115_2 2.224404
C4 1 gnd 2.080806f
R2 1 g5115_2 2.224404
R3 1 g5115_1 2.224404
.ends

.subckt netg1263 g1263_1 g1263_0 gnd
C1  g1263_1 gnd 2.080806f
C2  g1263_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1263_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1263_1 2 2.224404
.ends

.subckt netx142 x142_1 x142_0 gnd
C1  x142_1 gnd 2.080806f
C2  x142_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x142_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 x142_1 2 2.224404
.ends

.subckt netg3064 g3064_1 g3064_0 gnd
C1  g3064_1 gnd 2.080806f
C2  g3064_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3064_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g3064_1 2 2.224404
.ends

.subckt netg5062 g5062_0 g5062_1 g5062_2 gnd
C1  g5062_0 gnd 2.080806f
C2  g5062_1 gnd 2.080806f
C3  g5062_2 gnd 2.080806f
R1 g5062_0 g5062_2 2.224404
C4 1 gnd 2.080806f
R2 1 g5062_2 2.224404
R3 g5062_1 1 2.224404
.ends

.subckt netg7075 g7075_1 g7075_0 gnd
C1  g7075_1 gnd 2.080806f
C2  g7075_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7075_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7075_1 2.224404
.ends

.subckt netg3095 g3095_1 g3095_0 gnd
C1  g3095_1 gnd 2.080806f
C2  g3095_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3095_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3095_1 2.224404
.ends

.subckt netg4419 g4419_1 g4419_0 gnd
C1  g4419_1 gnd 2.080806f
C2  g4419_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4419_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4419_1 2 2.224404
.ends

.subckt netg2777 g2777_1 g2777_0 gnd
C1  g2777_1 gnd 2.080806f
C2  g2777_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2777_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2777_1 2 2.224404
.ends

.subckt netg928 g928_0 g928_1 g928_2 gnd
C1  g928_0 gnd 2.080806f
C2  g928_1 gnd 2.080806f
C3  g928_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g928_0 2.224404
R2 g928_2 1 2.224404
R3 g928_1 g928_2 2.224404
.ends

.subckt netg6811 g6811_2 g6811_0 g6811_1 gnd
C1  g6811_2 gnd 2.080806f
C2  g6811_0 gnd 2.080806f
C3  g6811_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6811_0 2.224404
R2 g6811_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g6811_0 2.224404
R4 g6811_2 2 2.224404
.ends

.subckt netg934 g934_0 g934_2 g934_1 gnd
C1  g934_0 gnd 2.080806f
C2  g934_2 gnd 2.080806f
C3  g934_1 gnd 2.080806f
R1 g934_1 g934_0 2.224404
C4 1 gnd 2.080806f
R2 1 g934_1 2.224404
R3 g934_2 1 2.224404
.ends

.subckt netg5118 g5118_1 g5118_0 gnd
C1  g5118_1 gnd 2.080806f
C2  g5118_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5118_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5118_1 2.224404
.ends

.subckt netg4164 g4164_1 g4164_0 g4164_2 gnd
C1  g4164_1 gnd 2.080806f
C2  g4164_0 gnd 2.080806f
C3  g4164_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4164_0 1 2.224404
R2 g4164_1 1 2.224404
R3 g4164_1 g4164_2 2.224404
.ends

.subckt netx271 x271_1 x271_0 gnd
C1  x271_1 gnd 2.080806f
C2  x271_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x271_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 x271_1 2 2.224404
.ends

.subckt netg5600 g5600_0 g5600_1 gnd
C1  g5600_0 gnd 2.080806f
C2  g5600_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5600_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5600_1 2.224404
.ends

.subckt netg1551 g1551_1 g1551_0 gnd
C1  g1551_1 gnd 2.080806f
C2  g1551_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1551_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1551_1 2 2.224404
.ends

.subckt netg2597 g2597_1 g2597_0 g2597_2 gnd
C1  g2597_1 gnd 2.080806f
C2  g2597_0 gnd 2.080806f
C3  g2597_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2597_0 1 2.224404
R2 1 g2597_2 2.224404
R3 g2597_2 g2597_1 2.224404
.ends

.subckt netg3084 g3084_1 g3084_0 gnd
C1  g3084_1 gnd 2.080806f
C2  g3084_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3084_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3084_1 2.224404
.ends

.subckt netg5661 g5661_1 g5661_2 g5661_0 gnd
C1  g5661_1 gnd 2.080806f
C2  g5661_2 gnd 2.080806f
C3  g5661_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5661_0 2.224404
R2 g5661_1 1 2.224404
R3 g5661_2 g5661_1 2.224404
.ends

.subckt netg2377 g2377_0 g2377_2 g2377_1 gnd
C1  g2377_0 gnd 2.080806f
C2  g2377_2 gnd 2.080806f
C3  g2377_1 gnd 2.080806f
R1 g2377_0 g2377_2 2.224404
C4 1 gnd 2.080806f
R2 g2377_2 1 2.224404
R3 1 g2377_1 2.224404
.ends

.subckt netx442 x442_1 x442_0 gnd
C1  x442_1 gnd 2.080806f
C2  x442_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x442_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 x442_1 2.224404
.ends

.subckt netg6607 g6607_1 g6607_0 gnd
C1  g6607_1 gnd 2.080806f
C2  g6607_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6607_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6607_1 2 2.224404
.ends

.subckt netg1365 g1365_0 g1365_1 gnd
C1  g1365_0 gnd 2.080806f
C2  g1365_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1365_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g1365_1 2 2.224404
.ends

.subckt netg2725 g2725_0 g2725_1 g2725_2 gnd
C1  g2725_0 gnd 2.080806f
C2  g2725_1 gnd 2.080806f
C3  g2725_2 gnd 2.080806f
R1 g2725_1 g2725_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2725_1 2.224404
R3 g2725_2 1 2.224404
.ends

.subckt netg5728 g5728_1 g5728_2 g5728_0 gnd
C1  g5728_1 gnd 2.080806f
C2  g5728_2 gnd 2.080806f
C3  g5728_0 gnd 2.080806f
R1 g5728_0 g5728_2 2.224404
C4 1 gnd 2.080806f
R2 1 g5728_2 2.224404
R3 g5728_1 1 2.224404
.ends

.subckt netg5616 g5616_1 g5616_0 g5616_2 gnd
C1  g5616_1 gnd 2.080806f
C2  g5616_0 gnd 2.080806f
C3  g5616_2 gnd 2.080806f
R1 g5616_0 g5616_1 2.224404
C4 1 gnd 2.080806f
R2 g5616_1 1 2.224404
R3 1 g5616_2 2.224404
.ends

.subckt netg7018 g7018_1 g7018_0 gnd
C1  g7018_1 gnd 2.080806f
C2  g7018_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7018_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7018_1 2 2.224404
.ends

.subckt netg7370 g7370_1 g7370_0 gnd
C1  g7370_1 gnd 2.080806f
C2  g7370_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7370_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7370_1 2.224404
.ends

.subckt netg3279 g3279_1 g3279_2 gnd
C1  g3279_1 gnd 2.080806f
C2  g3279_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3279_2 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g3279_1 2.224404
.ends

.subckt netg6523 g6523_1 g6523_0 gnd
C1  g6523_1 gnd 2.080806f
C2  g6523_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6523_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6523_1 2.224404
.ends

.subckt netg3342 g3342_1 g3342_2 g3342_0 gnd
C1  g3342_1 gnd 2.080806f
C2  g3342_2 gnd 2.080806f
C3  g3342_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3342_0 1 2.224404
R2 1 g3342_1 2.224404
R3 g3342_2 g3342_1 2.224404
.ends

.subckt netg6445 g6445_0 g6445_1 gnd
C1  g6445_0 gnd 2.080806f
C2  g6445_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6445_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g6445_1 2 2.224404
.ends

.subckt netg7184 g7184_0 g7184_1 gnd
C1  g7184_0 gnd 2.080806f
C2  g7184_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7184_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7184_1 2.224404
.ends

.subckt netg6063 g6063_1 g6063_0 gnd
C1  g6063_1 gnd 2.080806f
C2  g6063_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6063_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6063_1 2.224404
.ends

.subckt netg5664 g5664_0 g5664_2 g5664_1 gnd
C1  g5664_0 gnd 2.080806f
C2  g5664_2 gnd 2.080806f
C3  g5664_1 gnd 2.080806f
R1 g5664_0 g5664_1 2.224404
C4 1 gnd 2.080806f
R2 1 g5664_1 2.224404
R3 g5664_2 1 2.224404
.ends

.subckt netg3273 g3273_1 g3273_0 g3273_2 gnd
C1  g3273_1 gnd 2.080806f
C2  g3273_0 gnd 2.080806f
C3  g3273_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3273_0 2.224404
R2 g3273_2 1 2.224404
R3 g3273_2 g3273_1 2.224404
.ends

.subckt netg3246 g3246_0 g3246_2 g3246_1 gnd
C1  g3246_0 gnd 2.080806f
C2  g3246_2 gnd 2.080806f
C3  g3246_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3246_0 1 2.224404
R2 g3246_1 1 2.224404
R3 1 g3246_2 2.224404
.ends

.subckt netx111 x111_1 x111_0 gnd
C1  x111_1 gnd 2.080806f
C2  x111_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x111_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x111_1 2 2.224404
.ends

.subckt netx551 x551_0 x551_1 gnd
C1  x551_0 gnd 2.080806f
C2  x551_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x551_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 x551_1 2 2.224404
.ends

.subckt netg5351 g5351_1 g5351_0 gnd
C1  g5351_1 gnd 2.080806f
C2  g5351_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5351_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5351_1 2 2.224404
.ends

.subckt netg5588 g5588_1 g5588_0 gnd
C1  g5588_1 gnd 2.080806f
C2  g5588_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5588_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5588_1 2 2.224404
.ends

.subckt netg4130 g4130_1 g4130_0 gnd
C1  g4130_1 gnd 2.080806f
C2  g4130_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4130_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4130_1 2 2.224404
.ends

.subckt netg2603 g2603_1 g2603_2 g2603_0 gnd
C1  g2603_1 gnd 2.080806f
C2  g2603_2 gnd 2.080806f
C3  g2603_0 gnd 2.080806f
R1 g2603_1 g2603_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2603_0 2.224404
R3 g2603_2 1 2.224404
.ends

.subckt netg1517 g1517_1 g1517_0 gnd
C1  g1517_1 gnd 2.080806f
C2  g1517_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1517_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g1517_1 2 2.224404
.ends

.subckt netg3267 g3267_0 g3267_1 g3267_2 gnd
C1  g3267_0 gnd 2.080806f
C2  g3267_1 gnd 2.080806f
C3  g3267_2 gnd 2.080806f
R1 g3267_1 g3267_0 2.224404
C4 1 gnd 2.080806f
R2 g3267_0 1 2.224404
R3 g3267_2 1 2.224404
.ends

.subckt netg4012 g4012_0 g4012_1 gnd
C1  g4012_0 gnd 2.080806f
C2  g4012_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4012_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4012_1 2.224404
.ends

.subckt netg6556 g6556_0 g6556_1 gnd
C1  g6556_0 gnd 2.080806f
C2  g6556_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6556_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6556_1 2.224404
.ends

.subckt netg3162 g3162_0 g3162_1 g3162_2 gnd
C1  g3162_0 gnd 2.080806f
C2  g3162_1 gnd 2.080806f
C3  g3162_2 gnd 2.080806f
R1 g3162_0 g3162_2 2.224404
C4 1 gnd 2.080806f
R2 g3162_2 1 2.224404
R3 1 g3162_1 2.224404
.ends

.subckt netg4271 g4271_1 g4271_0 gnd
C1  g4271_1 gnd 2.080806f
C2  g4271_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4271_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4271_1 2 2.224404
.ends

.subckt netg3709 g3709_0 g3709_3 g3709_2 g3709_1 gnd
C1  g3709_0 gnd 2.080806f
C2  g3709_3 gnd 2.080806f
C3  g3709_2 gnd 2.080806f
C4  g3709_1 gnd 2.080806f
R1 g3709_2 g3709_0 2.224404
R2 g3709_2 g3709_1 2.224404
C5 1 gnd 2.080806f
R3 g3709_0 1 2.224404
R4 1 g3709_3 2.224404
.ends

.subckt netg6562 g6562_0 g6562_1 gnd
C1  g6562_0 gnd 2.080806f
C2  g6562_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6562_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6562_1 2 2.224404
.ends

.subckt netg1927 g1927_0 g1927_1 gnd
C1  g1927_0 gnd 2.080806f
C2  g1927_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1927_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1927_1 2 2.224404
.ends

.subckt netg5852 g5852_2 g5852_0 g5852_1 gnd
C1  g5852_2 gnd 2.080806f
C2  g5852_0 gnd 2.080806f
C3  g5852_1 gnd 2.080806f
R1 g5852_0 g5852_1 2.224404
C4 1 gnd 2.080806f
R2 g5852_1 1 2.224404
R3 1 g5852_2 2.224404
.ends

.subckt netg6802 g6802_1 g6802_0 g6802_2 gnd
C1  g6802_1 gnd 2.080806f
C2  g6802_0 gnd 2.080806f
C3  g6802_2 gnd 2.080806f
R1 g6802_0 g6802_1 2.224404
C4 1 gnd 2.080806f
R2 g6802_1 1 2.224404
R3 1 g6802_2 2.224404
.ends

.subckt netg5226 g5226_0 g5226_2 g5226_1 gnd
C1  g5226_0 gnd 2.080806f
C2  g5226_2 gnd 2.080806f
C3  g5226_1 gnd 2.080806f
R1 g5226_0 g5226_2 2.224404
C4 1 gnd 2.080806f
R2 g5226_2 1 2.224404
R3 g5226_1 1 2.224404
.ends

.subckt netg6951 g6951_1 g6951_0 g6951_2 gnd
C1  g6951_1 gnd 2.080806f
C2  g6951_0 gnd 2.080806f
C3  g6951_2 gnd 2.080806f
R1 g6951_0 g6951_2 2.224404
C4 1 gnd 2.080806f
R2 g6951_2 1 2.224404
R3 1 g6951_1 2.224404
.ends

.subckt netg904 g904_2 g904_1 g904_0 gnd
C1  g904_2 gnd 2.080806f
C2  g904_1 gnd 2.080806f
C3  g904_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g904_0 1 2.224404
R2 1 g904_2 2.224404
R3 g904_2 g904_1 2.224404
.ends

.subckt netg1995 g1995_2 g1995_0 g1995_1 gnd
C1  g1995_2 gnd 2.080806f
C2  g1995_0 gnd 2.080806f
C3  g1995_1 gnd 2.080806f
R1 g1995_0 g1995_1 2.224404
C4 1 gnd 2.080806f
R2 1 g1995_0 2.224404
R3 g1995_2 1 2.224404
.ends

.subckt netg5068 g5068_1 g5068_0 g5068_2 gnd
C1  g5068_1 gnd 2.080806f
C2  g5068_0 gnd 2.080806f
C3  g5068_2 gnd 2.080806f
R1 g5068_2 g5068_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5068_0 2.224404
R3 1 g5068_1 2.224404
.ends

.subckt netg5549 g5549_2 g5549_1 g5549_0 gnd
C1  g5549_2 gnd 2.080806f
C2  g5549_1 gnd 2.080806f
C3  g5549_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5549_0 1 2.224404
R2 1 g5549_1 2.224404
R3 g5549_2 g5549_1 2.224404
.ends

.subckt netg5243 g5243_0 g5243_1 gnd
C1  g5243_0 gnd 2.080806f
C2  g5243_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5243_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5243_1 2.224404
.ends

.subckt netg3090 g3090_2 g3090_1 g3090_0 gnd
C1  g3090_2 gnd 2.080806f
C2  g3090_1 gnd 2.080806f
C3  g3090_0 gnd 2.080806f
R1 g3090_0 g3090_1 2.224404
C4 1 gnd 2.080806f
R2 1 g3090_0 2.224404
R3 g3090_2 1 2.224404
.ends

.subckt netg6745 g6745_2 g6745_0 g6745_1 gnd
C1  g6745_2 gnd 2.080806f
C2  g6745_0 gnd 2.080806f
C3  g6745_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6745_0 1 2.224404
R2 1 g6745_2 2.224404
R3 g6745_2 g6745_1 2.224404
.ends

.subckt netg6086 g6086_1 g6086_0 gnd
C1  g6086_1 gnd 2.080806f
C2  g6086_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6086_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6086_1 2.224404
.ends

.subckt netg5474 g5474_1 g5474_0 gnd
C1  g5474_1 gnd 2.080806f
C2  g5474_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5474_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g5474_1 2.224404
.ends

.subckt netg901 g901_2 g901_0 g901_1 gnd
C1  g901_2 gnd 2.080806f
C2  g901_0 gnd 2.080806f
C3  g901_1 gnd 2.080806f
R1 g901_1 g901_0 2.224404
C4 1 gnd 2.080806f
R2 g901_1 1 2.224404
R3 1 g901_2 2.224404
.ends

.subckt netg3171 g3171_2 g3171_0 g3171_1 gnd
C1  g3171_2 gnd 2.080806f
C2  g3171_0 gnd 2.080806f
C3  g3171_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3171_0 1 2.224404
R2 1 g3171_1 2.224404
R3 g3171_1 g3171_2 2.224404
.ends

.subckt netg5385 g5385_0 g5385_1 gnd
C1  g5385_0 gnd 2.080806f
C2  g5385_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5385_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5385_1 2.224404
.ends

.subckt netg1012 g1012_0 g1012_2 g1012_1 gnd
C1  g1012_0 gnd 2.080806f
C2  g1012_2 gnd 2.080806f
C3  g1012_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1012_0 1 2.224404
R2 1 g1012_2 2.224404
R3 g1012_1 g1012_2 2.224404
.ends

.subckt netg982 g982_2 g982_1 g982_0 gnd
C1  g982_2 gnd 2.080806f
C2  g982_1 gnd 2.080806f
C3  g982_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g982_0 1 2.224404
R2 g982_2 1 2.224404
R3 g982_1 g982_2 2.224404
.ends

.subckt netg1079 g1079_0 g1079_2 g1079_1 gnd
C1  g1079_0 gnd 2.080806f
C2  g1079_2 gnd 2.080806f
C3  g1079_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g1079_0 2.224404
R2 g1079_2 1 2.224404
R3 g1079_1 g1079_2 2.224404
.ends

.subckt netg3126 g3126_0 g3126_1 g3126_2 gnd
C1  g3126_0 gnd 2.080806f
C2  g3126_1 gnd 2.080806f
C3  g3126_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3126_0 1 2.224404
R2 1 g3126_2 2.224404
R3 g3126_2 g3126_1 2.224404
.ends

.subckt netg6080 g6080_0 g6080_1 gnd
C1  g6080_0 gnd 2.080806f
C2  g6080_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6080_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6080_1 2 2.224404
.ends

.subckt netg5139 g5139_2 g5139_1 g5139_0 gnd
C1  g5139_2 gnd 2.080806f
C2  g5139_1 gnd 2.080806f
C3  g5139_0 gnd 2.080806f
R1 g5139_1 g5139_0 2.224404
C4 1 gnd 2.080806f
R2 g5139_0 1 2.224404
R3 1 g5139_2 2.224404
.ends

.subckt netg5486 g5486_1 g5486_0 gnd
C1  g5486_1 gnd 2.080806f
C2  g5486_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5486_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5486_1 2 2.224404
.ends

.subckt netg7301 g7301_1 g7301_0 gnd
C1  g7301_1 gnd 2.080806f
C2  g7301_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7301_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7301_1 2 2.224404
.ends

.subckt netg4167 g4167_0 g4167_2 g4167_1 gnd
C1  g4167_0 gnd 2.080806f
C2  g4167_2 gnd 2.080806f
C3  g4167_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4167_0 1 2.224404
R2 1 g4167_2 2.224404
R3 g4167_2 g4167_1 2.224404
.ends

.subckt netg1310 g1310_1 g1310_0 gnd
C1  g1310_1 gnd 2.080806f
C2  g1310_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1310_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g1310_1 2.224404
.ends

.subckt netg7174 g7174_1 g7174_0 gnd
C1  g7174_1 gnd 2.080806f
C2  g7174_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7174_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7174_1 2 2.224404
.ends

.subckt netg5694 g5694_1 g5694_2 g5694_0 gnd
C1  g5694_1 gnd 2.080806f
C2  g5694_2 gnd 2.080806f
C3  g5694_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5694_0 1 2.224404
R2 1 g5694_1 2.224404
R3 g5694_2 g5694_1 2.224404
.ends

.subckt netg3249 g3249_1 g3249_0 g3249_2 gnd
C1  g3249_1 gnd 2.080806f
C2  g3249_0 gnd 2.080806f
C3  g3249_2 gnd 2.080806f
R1 g3249_1 g3249_0 2.224404
C4 1 gnd 2.080806f
R2 1 g3249_1 2.224404
R3 g3249_2 1 2.224404
.ends

.subckt netg5697 g5697_0 g5697_1 g5697_2 gnd
C1  g5697_0 gnd 2.080806f
C2  g5697_1 gnd 2.080806f
C3  g5697_2 gnd 2.080806f
R1 g5697_0 g5697_1 2.224404
C4 1 gnd 2.080806f
R2 1 g5697_0 2.224404
R3 g5697_2 1 2.224404
.ends

.subckt netg943 g943_0 g943_2 g943_1 gnd
C1  g943_0 gnd 2.080806f
C2  g943_2 gnd 2.080806f
C3  g943_1 gnd 2.080806f
R1 g943_0 g943_1 2.224404
C4 1 gnd 2.080806f
R2 1 g943_0 2.224404
R3 g943_2 1 2.224404
.ends

.subckt netg6898 g6898_0 g6898_1 gnd
C1  g6898_0 gnd 2.080806f
C2  g6898_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6898_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6898_1 2 2.224404
.ends

.subckt netg6109 g6109_1 g6109_2 gnd
C1  g6109_1 gnd 2.080806f
C2  g6109_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6109_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6109_2 2 2.224404
.ends

.subckt netx552 x552_0 x552_1 gnd
C1  x552_0 gnd 2.080806f
C2  x552_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x552_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 x552_1 2.224404
.ends

.subckt netg3507 g3507_0 g3507_1 gnd
C1  g3507_0 gnd 2.080806f
C2  g3507_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3507_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3507_1 2.224404
.ends

.subckt netg6389 g6389_0 g6389_1 gnd
C1  g6389_0 gnd 2.080806f
C2  g6389_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6389_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6389_1 2.224404
.ends

.subckt netg1574 g1574_0 g1574_1 gnd
C1  g1574_0 gnd 2.080806f
C2  g1574_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1574_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1574_1 2.224404
.ends

.subckt netg5332 g5332_1 g5332_0 gnd
C1  g5332_1 gnd 2.080806f
C2  g5332_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5332_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5332_1 2 2.224404
.ends

.subckt netg3536 g3536_1 g3536_0 gnd
C1  g3536_1 gnd 2.080806f
C2  g3536_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3536_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3536_1 2.224404
.ends

.subckt netg2564 g2564_2 g2564_1 gnd
C1  g2564_2 gnd 2.080806f
C2  g2564_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2564_1 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2564_2 2.224404
.ends

.subckt netg4374 g4374_0 g4374_1 g4374_2 gnd
C1  g4374_0 gnd 2.080806f
C2  g4374_1 gnd 2.080806f
C3  g4374_2 gnd 2.080806f
R1 g4374_1 g4374_0 2.224404
C4 1 gnd 2.080806f
R2 1 g4374_0 2.224404
R3 1 g4374_2 2.224404
.ends

.subckt netg7109 g7109_2 g7109_1 g7109_0 gnd
C1  g7109_2 gnd 2.080806f
C2  g7109_1 gnd 2.080806f
C3  g7109_0 gnd 2.080806f
R1 g7109_2 g7109_0 2.224404
C4 1 gnd 2.080806f
R2 g7109_0 1 2.224404
R3 1 g7109_1 2.224404
.ends

.subckt netg4421 g4421_1 g4421_0 gnd
C1  g4421_1 gnd 2.080806f
C2  g4421_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4421_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g4421_1 2.224404
.ends

.subckt netg2415 g2415_2 g2415_1 g2415_0 gnd
C1  g2415_2 gnd 2.080806f
C2  g2415_1 gnd 2.080806f
C3  g2415_0 gnd 2.080806f
R1 g2415_0 g2415_2 2.224404
C4 1 gnd 2.080806f
R2 g2415_0 1 2.224404
R3 g2415_1 1 2.224404
.ends

.subckt netg5041 g5041_0 g5041_1 g5041_2 gnd
C1  g5041_0 gnd 2.080806f
C2  g5041_1 gnd 2.080806f
C3  g5041_2 gnd 2.080806f
R1 g5041_2 g5041_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5041_0 2.224404
R3 g5041_1 1 2.224404
.ends

.subckt netg2570 g2570_1 g2570_2 g2570_0 gnd
C1  g2570_1 gnd 2.080806f
C2  g2570_2 gnd 2.080806f
C3  g2570_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2570_0 1 2.224404
R2 1 g2570_1 2.224404
C5 2 gnd 2.080806f
R3 2 g2570_0 2.224404
R4 2 g2570_2 2.224404
.ends

.subckt netg5867 g5867_2 g5867_0 g5867_1 gnd
C1  g5867_2 gnd 2.080806f
C2  g5867_0 gnd 2.080806f
C3  g5867_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5867_0 1 2.224404
R2 1 g5867_1 2.224404
R3 g5867_1 g5867_2 2.224404
.ends

.subckt netg6879 g6879_1 g6879_0 gnd
C1  g6879_1 gnd 2.080806f
C2  g6879_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6879_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g6879_1 2 2.224404
.ends

.subckt netg6876 g6876_0 g6876_1 gnd
C1  g6876_0 gnd 2.080806f
C2  g6876_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6876_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6876_1 2.224404
.ends

.subckt netg5725 g5725_1 g5725_0 g5725_2 gnd
C1  g5725_1 gnd 2.080806f
C2  g5725_0 gnd 2.080806f
C3  g5725_2 gnd 2.080806f
R1 g5725_0 g5725_1 2.224404
C4 1 gnd 2.080806f
R2 1 g5725_0 2.224404
R3 g5725_2 1 2.224404
.ends

.subckt netg1942 g1942_0 g1942_1 g1942_2 gnd
C1  g1942_0 gnd 2.080806f
C2  g1942_1 gnd 2.080806f
C3  g1942_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g1942_0 2.224404
R2 g1942_1 1 2.224404
R3 g1942_2 1 2.224404
.ends

.subckt netg3183 g3183_0 g3183_1 g3183_2 gnd
C1  g3183_0 gnd 2.080806f
C2  g3183_1 gnd 2.080806f
C3  g3183_2 gnd 2.080806f
R1 g3183_0 g3183_2 2.224404
C4 1 gnd 2.080806f
R2 g3183_2 1 2.224404
R3 1 g3183_1 2.224404
.ends

.subckt netg4263 g4263_1 g4263_0 gnd
C1  g4263_1 gnd 2.080806f
C2  g4263_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4263_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4263_1 2.224404
.ends

.subckt netg7425 g7425_0 g7425_1 gnd
C1  g7425_0 gnd 2.080806f
C2  g7425_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7425_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7425_1 2 2.224404
.ends

.subckt netg1508 g1508_0 g1508_1 gnd
C1  g1508_0 gnd 2.080806f
C2  g1508_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1508_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g1508_1 2 2.224404
.ends

.subckt netg1558 g1558_0 g1558_1 gnd
C1  g1558_0 gnd 2.080806f
C2  g1558_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1558_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1558_1 2.224404
.ends

.subckt netg5434 g5434_2 g5434_0 g5434_1 gnd
C1  g5434_2 gnd 2.080806f
C2  g5434_0 gnd 2.080806f
C3  g5434_1 gnd 2.080806f
R1 g5434_0 g5434_1 2.224404
C4 1 gnd 2.080806f
R2 g5434_1 1 2.224404
R3 1 g5434_2 2.224404
.ends

.subckt netg7203 g7203_2 g7203_1 g7203_0 gnd
C1  g7203_2 gnd 2.080806f
C2  g7203_1 gnd 2.080806f
C3  g7203_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7203_0 2.224404
R2 g7203_2 1 2.224404
R3 g7203_1 g7203_2 2.224404
.ends

.subckt netg7341 g7341_1 g7341_0 gnd
C1  g7341_1 gnd 2.080806f
C2  g7341_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7341_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7341_1 2.224404
.ends

.subckt netg2804 g2804_0 g2804_1 gnd
C1  g2804_0 gnd 2.080806f
C2  g2804_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2804_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2804_1 2 2.224404
.ends

.subckt netg7119 g7119_1 g7119_0 g7119_2 gnd
C1  g7119_1 gnd 2.080806f
C2  g7119_0 gnd 2.080806f
C3  g7119_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7119_0 2.224404
R2 g7119_2 1 2.224404
R3 g7119_2 g7119_1 2.224404
.ends

.subckt netg4349 g4349_1 g4349_0 gnd
C1  g4349_1 gnd 2.080806f
C2  g4349_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4349_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4349_1 2.224404
.ends

.subckt netg4260 g4260_0 g4260_1 gnd
C1  g4260_0 gnd 2.080806f
C2  g4260_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4260_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4260_1 2 2.224404
.ends

.subckt netg6528 g6528_1 g6528_0 gnd
C1  g6528_1 gnd 2.080806f
C2  g6528_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6528_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6528_1 2.224404
.ends

.subckt netg7264 g7264_1 g7264_0 gnd
C1  g7264_1 gnd 2.080806f
C2  g7264_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7264_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7264_1 2 2.224404
.ends

.subckt netg6905 g6905_3 g6905_2 gnd
C1  g6905_3 gnd 2.080806f
C2  g6905_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6905_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6905_3 2.224404
.ends

.subckt netg7084 g7084_1 g7084_0 gnd
C1  g7084_1 gnd 2.080806f
C2  g7084_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7084_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7084_1 2 2.224404
.ends

.subckt netg4973 g4973_0 g4973_2 g4973_1 gnd
C1  g4973_0 gnd 2.080806f
C2  g4973_2 gnd 2.080806f
C3  g4973_1 gnd 2.080806f
R1 g4973_1 g4973_0 2.224404
C4 1 gnd 2.080806f
R2 1 g4973_0 2.224404
R3 g4973_2 1 2.224404
.ends

.subckt netg2656 g2656_1 g2656_0 g2656_2 gnd
C1  g2656_1 gnd 2.080806f
C2  g2656_0 gnd 2.080806f
C3  g2656_2 gnd 2.080806f
R1 g2656_2 g2656_0 2.224404
C4 1 gnd 2.080806f
R2 g2656_2 1 2.224404
R3 g2656_1 1 2.224404
.ends

.subckt netg6054 g6054_1 g6054_0 gnd
C1  g6054_1 gnd 2.080806f
C2  g6054_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6054_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6054_1 2.224404
.ends

.subckt netg5945 g5945_2 g5945_1 g5945_0 gnd
C1  g5945_2 gnd 2.080806f
C2  g5945_1 gnd 2.080806f
C3  g5945_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5945_0 1 2.224404
R2 1 g5945_2 2.224404
R3 g5945_2 g5945_1 2.224404
.ends

.subckt netg7207 g7207_1 g7207_0 gnd
C1  g7207_1 gnd 2.080806f
C2  g7207_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7207_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7207_1 2.224404
.ends

.subckt netg3899 g3899_0 g3899_1 gnd
C1  g3899_0 gnd 2.080806f
C2  g3899_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3899_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3899_1 2.224404
.ends

.subckt netg889 g889_2 g889_1 g889_0 gnd
C1  g889_2 gnd 2.080806f
C2  g889_1 gnd 2.080806f
C3  g889_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g889_0 2.224404
R2 g889_1 1 2.224404
R3 g889_2 g889_1 2.224404
.ends

.subckt netg5989 g5989_0 g5989_1 gnd
C1  g5989_0 gnd 2.080806f
C2  g5989_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5989_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5989_1 2.224404
.ends

.subckt netg2924 g2924_1 g2924_0 gnd
C1  g2924_1 gnd 2.080806f
C2  g2924_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2924_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2924_1 2.224404
.ends

.subckt netg7176 g7176_1 g7176_0 gnd
C1  g7176_1 gnd 2.080806f
C2  g7176_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7176_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
R3 g7176_1 2 2.224404
.ends

.subckt netg7200 g7200_2 g7200_1 g7200_0 gnd
C1  g7200_2 gnd 2.080806f
C2  g7200_1 gnd 2.080806f
C3  g7200_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7200_0 1 2.224404
R2 1 g7200_1 2.224404
C5 2 gnd 2.080806f
R3 2 g7200_0 2.224404
R4 g7200_2 2 2.224404
.ends

.subckt netg1159 g1159_0 g1159_1 gnd
C1  g1159_0 gnd 2.080806f
C2  g1159_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1159_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1159_1 2.224404
.ends

.subckt netg1121 g1121_0 g1121_1 gnd
C1  g1121_0 gnd 2.080806f
C2  g1121_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1121_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1121_1 3 2.224404
.ends

.subckt netg5012 g5012_0 g5012_1 g5012_2 gnd
C1  g5012_0 gnd 2.080806f
C2  g5012_1 gnd 2.080806f
C3  g5012_2 gnd 2.080806f
R1 g5012_0 g5012_2 2.224404
C4 1 gnd 2.080806f
R2 g5012_2 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g5012_1 2.224404
.ends

.subckt netg4896 g4896_2 g4896_1 g4896_0 gnd
C1  g4896_2 gnd 2.080806f
C2  g4896_1 gnd 2.080806f
C3  g4896_0 gnd 2.080806f
R1 g4896_0 g4896_2 2.224404
C4 1 gnd 2.080806f
R2 1 g4896_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g4896_1 2 2.224404
.ends

.subckt netg2832 g2832_1 g2832_0 gnd
C1  g2832_1 gnd 2.080806f
C2  g2832_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2832_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2832_1 2.224404
.ends

.subckt netg976 g976_2 g976_0 g976_1 gnd
C1  g976_2 gnd 2.080806f
C2  g976_0 gnd 2.080806f
C3  g976_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g976_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g976_1 2 2.224404
R4 g976_2 g976_1 2.224404
.ends

.subckt netg2866 g2866_0 g2866_1 gnd
C1  g2866_0 gnd 2.080806f
C2  g2866_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2866_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g2866_1 2.224404
.ends

.subckt netg2027 g2027_1 g2027_0 gnd
C1  g2027_1 gnd 2.080806f
C2  g2027_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2027_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g2027_1 3 2.224404
.ends

.subckt netg7197 g7197_0 g7197_1 gnd
C1  g7197_0 gnd 2.080806f
C2  g7197_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7197_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g7197_1 3 2.224404
.ends

.subckt netg2942 g2942_0 g2942_1 gnd
C1  g2942_0 gnd 2.080806f
C2  g2942_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2942_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2942_1 2.224404
.ends

.subckt netx341 x341_1 x341_0 gnd
C1  x341_1 gnd 2.080806f
C2  x341_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x341_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 x341_1 3 2.224404
.ends

.subckt netg6384 g6384_0 g6384_1 gnd
C1  g6384_0 gnd 2.080806f
C2  g6384_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6384_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6384_1 3 2.224404
.ends

.subckt netg7309 g7309_1 g7309_0 g7309_2 gnd
C1  g7309_1 gnd 2.080806f
C2  g7309_0 gnd 2.080806f
C3  g7309_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7309_0 2.224404
R2 g7309_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g7309_2 2.224404
R4 g7309_1 2 2.224404
.ends

.subckt netg3560 g3560_1 g3560_0 gnd
C1  g3560_1 gnd 2.080806f
C2  g3560_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3560_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g3560_1 3 2.224404
.ends

.subckt netg1511 g1511_1 g1511_0 gnd
C1  g1511_1 gnd 2.080806f
C2  g1511_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1511_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1511_1 3 2.224404
.ends

.subckt netg7327 g7327_2 g7327_0 g7327_1 gnd
C1  g7327_2 gnd 2.080806f
C2  g7327_0 gnd 2.080806f
C3  g7327_1 gnd 2.080806f
R1 g7327_0 g7327_2 2.224404
C4 1 gnd 2.080806f
R2 g7327_2 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g7327_1 2.224404
.ends

.subckt netg4346 g4346_0 g4346_1 g4346_2 gnd
C1  g4346_0 gnd 2.080806f
C2  g4346_1 gnd 2.080806f
C3  g4346_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4346_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4346_2 2.224404
R4 g4346_2 g4346_1 2.224404
.ends

.subckt netg6299 g6299_0 g6299_1 gnd
C1  g6299_0 gnd 2.080806f
C2  g6299_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6299_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6299_1 2.224404
.ends

.subckt netg5529 g5529_2 g5529_0 g5529_1 gnd
C1  g5529_2 gnd 2.080806f
C2  g5529_0 gnd 2.080806f
C3  g5529_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5529_0 2.224404
R2 g5529_1 1 2.224404
C5 2 gnd 2.080806f
R3 g5529_1 2 2.224404
R4 2 g5529_2 2.224404
.ends

.subckt netg3100 g3100_0 g3100_1 gnd
C1  g3100_0 gnd 2.080806f
C2  g3100_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3100_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g3100_1 3 2.224404
.ends

.subckt netg6223 g6223_0 g6223_2 g6223_1 gnd
C1  g6223_0 gnd 2.080806f
C2  g6223_2 gnd 2.080806f
C3  g6223_1 gnd 2.080806f
R1 g6223_0 g6223_1 2.224404
C4 1 gnd 2.080806f
R2 1 g6223_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g6223_2 2 2.224404
.ends

.subckt netg6247 g6247_1 g6247_2 g6247_0 gnd
C1  g6247_1 gnd 2.080806f
C2  g6247_2 gnd 2.080806f
C3  g6247_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6247_0 2.224404
R2 g6247_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g6247_2 2.224404
R4 g6247_1 2 2.224404
.ends

.subckt netg3389 g3389_2 g3389_1 g3389_0 gnd
C1  g3389_2 gnd 2.080806f
C2  g3389_1 gnd 2.080806f
C3  g3389_0 gnd 2.080806f
R1 g3389_2 g3389_0 2.224404
C4 1 gnd 2.080806f
R2 g3389_2 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3389_1 2.224404
.ends

.subckt netg7009 g7009_1 g7009_0 gnd
C1  g7009_1 gnd 2.080806f
C2  g7009_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7009_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g7009_1 3 2.224404
.ends

.subckt netg4259 g4259_1 g4259_0 gnd
C1  g4259_1 gnd 2.080806f
C2  g4259_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4259_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g4259_1 2.224404
.ends

.subckt netx451 x451_0 x451_1 gnd
C1  x451_0 gnd 2.080806f
C2  x451_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x451_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 x451_1 3 2.224404
.ends

.subckt netg1085 g1085_0 g1085_1 gnd
C1  g1085_0 gnd 2.080806f
C2  g1085_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1085_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1085_1 2.224404
.ends

.subckt netg705 g705_4 g705_6 g705_3 g705_2 g705_0 gnd
C1  g705_4 gnd 2.080806f
C2  g705_6 gnd 2.080806f
C3  g705_3 gnd 2.080806f
C4  g705_2 gnd 2.080806f
C5  g705_0 gnd 2.080806f
R1 g705_0 g705_3 2.224404
R2 g705_4 g705_0 2.224404
R3 g705_6 g705_4 2.224404
R4 g705_2 g705_6 2.224404
.ends

.subckt netg2013 g2013_4 g2013_5 g2013_2 g2013_1 g2013_3 gnd
C1  g2013_4 gnd 2.080806f
C2  g2013_5 gnd 2.080806f
C3  g2013_2 gnd 2.080806f
C4  g2013_1 gnd 2.080806f
C5  g2013_3 gnd 2.080806f
R1 g2013_4 g2013_5 2.224404
R2 g2013_5 g2013_1 2.224404
R3 g2013_5 g2013_2 2.224404
R4 g2013_2 g2013_3 2.224404
.ends

.subckt netg6668 g6668_1 g6668_0 gnd
C1  g6668_1 gnd 2.080806f
C2  g6668_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6668_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g6668_1 3 2.224404
.ends

.subckt netg5414 g5414_1 g5414_0 gnd
C1  g5414_1 gnd 2.080806f
C2  g5414_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5414_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5414_1 2.224404
.ends

.subckt netg3177 g3177_1 g3177_2 gnd
C1  g3177_1 gnd 2.080806f
C2  g3177_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3177_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g3177_1 2.224404
.ends

.subckt netx202 x202_0 x202_1 gnd
C1  x202_0 gnd 2.080806f
C2  x202_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x202_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 x202_1 2.224404
.ends

.subckt netg7431 g7431_1 g7431_0 gnd
C1  g7431_1 gnd 2.080806f
C2  g7431_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7431_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g7431_1 2.224404
.ends

.subckt netg5484 g5484_0 g5484_1 gnd
C1  g5484_0 gnd 2.080806f
C2  g5484_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5484_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5484_1 2.224404
.ends

.subckt netg5855 g5855_0 g5855_1 gnd
C1  g5855_0 gnd 2.080806f
C2  g5855_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5855_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5855_1 2.224404
.ends

.subckt netg6884 g6884_0 g6884_1 gnd
C1  g6884_0 gnd 2.080806f
C2  g6884_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6884_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6884_1 2.224404
.ends

.subckt netg6361 g6361_0 g6361_1 gnd
C1  g6361_0 gnd 2.080806f
C2  g6361_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6361_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6361_1 2.224404
.ends

.subckt netg7356 g7356_0 g7356_1 gnd
C1  g7356_0 gnd 2.080806f
C2  g7356_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7356_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g7356_1 3 2.224404
.ends

.subckt netg5440 g5440_0 g5440_1 g5440_2 gnd
C1  g5440_0 gnd 2.080806f
C2  g5440_1 gnd 2.080806f
C3  g5440_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5440_0 1 2.224404
R2 g5440_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g5440_2 2.224404
.ends

.subckt netg2677 g2677_2 g2677_1 gnd
C1  g2677_2 gnd 2.080806f
C2  g2677_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2677_1 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2677_2 2.224404
.ends

.subckt netg6189 g6189_0 g6189_1 gnd
C1  g6189_0 gnd 2.080806f
C2  g6189_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6189_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6189_1 2.224404
.ends

.subckt netg7375 g7375_2 g7375_1 g7375_0 gnd
C1  g7375_2 gnd 2.080806f
C2  g7375_1 gnd 2.080806f
C3  g7375_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7375_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7375_1 2 2.224404
R4 g7375_2 g7375_1 2.224404
.ends

.subckt netg1027 g1027_1 g1027_2 g1027_0 gnd
C1  g1027_1 gnd 2.080806f
C2  g1027_2 gnd 2.080806f
C3  g1027_0 gnd 2.080806f
R1 g1027_0 g1027_1 2.224404
C4 1 gnd 2.080806f
R2 1 g1027_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g1027_2 2 2.224404
.ends

.subckt netg812 g812_3 g812_1 g812_2 g812_0 gnd
C1  g812_3 gnd 2.080806f
C2  g812_1 gnd 2.080806f
C3  g812_2 gnd 2.080806f
C4  g812_0 gnd 2.080806f
R1 g812_3 g812_0 2.224404
R2 g812_3 g812_1 2.224404
C5 1 gnd 2.080806f
R3 g812_1 1 2.224404
R4 1 g812_2 2.224404
.ends

.subckt netg1054 g1054_1 g1054_0 g1054_2 gnd
C1  g1054_1 gnd 2.080806f
C2  g1054_0 gnd 2.080806f
C3  g1054_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1054_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g1054_2 2 2.224404
R4 g1054_1 g1054_2 2.224404
.ends

.subckt netg5575 g5575_1 g5575_2 g5575_0 gnd
C1  g5575_1 gnd 2.080806f
C2  g5575_2 gnd 2.080806f
C3  g5575_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5575_0 1 2.224404
R2 g5575_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g5575_2 2.224404
R4 g5575_1 2 2.224404
.ends

.subckt netg7225 g7225_1 g7225_0 g7225_2 gnd
C1  g7225_1 gnd 2.080806f
C2  g7225_0 gnd 2.080806f
C3  g7225_2 gnd 2.080806f
R1 g7225_2 g7225_0 2.224404
C4 1 gnd 2.080806f
R2 1 g7225_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g7225_1 2 2.224404
.ends

.subckt netg6258 g6258_1 g6258_0 gnd
C1  g6258_1 gnd 2.080806f
C2  g6258_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6258_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6258_1 3 2.224404
.ends

.subckt netg7060 g7060_2 g7060_0 g7060_1 gnd
C1  g7060_2 gnd 2.080806f
C2  g7060_0 gnd 2.080806f
C3  g7060_1 gnd 2.080806f
R1 g7060_0 g7060_1 2.224404
C4 1 gnd 2.080806f
R2 1 g7060_1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g7060_2 2.224404
.ends

.subckt netg2474 g2474_0 g2474_1 g2474_2 gnd
C1  g2474_0 gnd 2.080806f
C2  g2474_1 gnd 2.080806f
C3  g2474_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2474_0 2.224404
R2 g2474_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g2474_2 2.224404
R4 g2474_1 2 2.224404
.ends

.subckt netg6161 g6161_1 g6161_0 gnd
C1  g6161_1 gnd 2.080806f
C2  g6161_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6161_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6161_1 2.224404
.ends

.subckt netg4350 g4350_1 g4350_0 gnd
C1  g4350_1 gnd 2.080806f
C2  g4350_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4350_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g4350_1 3 2.224404
.ends

.subckt netg4899 g4899_2 g4899_1 g4899_0 gnd
C1  g4899_2 gnd 2.080806f
C2  g4899_1 gnd 2.080806f
C3  g4899_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4899_0 1 2.224404
R2 1 g4899_2 2.224404
C5 2 gnd 2.080806f
R3 g4899_2 2 2.224404
R4 2 g4899_1 2.224404
.ends

.subckt netx32 x32_0 x32_1 gnd
C1  x32_0 gnd 2.080806f
C2  x32_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x32_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 x32_1 2.224404
.ends

.subckt netg7540 g7540_0 g7540_1 gnd
C1  g7540_0 gnd 2.080806f
C2  g7540_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7540_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g7540_1 3 2.224404
.ends

.subckt netg1554 g1554_0 g1554_1 gnd
C1  g1554_0 gnd 2.080806f
C2  g1554_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1554_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1554_1 2.224404
.ends

.subckt netg5326 g5326_1 g5326_0 gnd
C1  g5326_1 gnd 2.080806f
C2  g5326_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5326_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5326_1 2.224404
.ends

.subckt netg5150 g5150_2 g5150_0 g5150_1 gnd
C1  g5150_2 gnd 2.080806f
C2  g5150_0 gnd 2.080806f
C3  g5150_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5150_0 1 2.224404
R2 1 g5150_2 2.224404
C5 2 gnd 2.080806f
R3 g5150_2 2 2.224404
R4 g5150_1 2 2.224404
.ends

.subckt netg2809 g2809_0 g2809_1 gnd
C1  g2809_0 gnd 2.080806f
C2  g2809_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2809_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g2809_1 3 2.224404
.ends

.subckt netg6162 g6162_0 g6162_1 gnd
C1  g6162_0 gnd 2.080806f
C2  g6162_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6162_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g6162_1 2.224404
.ends

.subckt netg5451 g5451_2 g5451_0 g5451_1 gnd
C1  g5451_2 gnd 2.080806f
C2  g5451_0 gnd 2.080806f
C3  g5451_1 gnd 2.080806f
R1 g5451_1 g5451_0 2.224404
C4 1 gnd 2.080806f
R2 g5451_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g5451_2 2.224404
.ends

.subckt netg3141 g3141_1 g3141_2 g3141_0 gnd
C1  g3141_1 gnd 2.080806f
C2  g3141_2 gnd 2.080806f
C3  g3141_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3141_0 2.224404
R2 g3141_1 1 2.224404
C5 2 gnd 2.080806f
R3 g3141_0 2 2.224404
R4 2 g3141_2 2.224404
.ends

.subckt netg3943 g3943_1 g3943_3 g3943_0 g3943_2 gnd
C1  g3943_1 gnd 2.080806f
C2  g3943_3 gnd 2.080806f
C3  g3943_0 gnd 2.080806f
C4  g3943_2 gnd 2.080806f
R1 g3943_0 g3943_1 2.224404
C5 1 gnd 2.080806f
R2 1 g3943_1 2.224404
R3 g3943_2 1 2.224404
R4 g3943_2 g3943_3 2.224404
.ends

.subckt netg5080 g5080_1 g5080_0 g5080_2 gnd
C1  g5080_1 gnd 2.080806f
C2  g5080_0 gnd 2.080806f
C3  g5080_2 gnd 2.080806f
R1 g5080_0 g5080_1 2.224404
C4 1 gnd 2.080806f
R2 1 g5080_1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 g5080_2 2 2.224404
.ends

.subckt netg3965 g3965_1 g3965_0 g3965_2 gnd
C1  g3965_1 gnd 2.080806f
C2  g3965_0 gnd 2.080806f
C3  g3965_2 gnd 2.080806f
R1 g3965_1 g3965_0 2.224404
C4 1 gnd 2.080806f
R2 1 g3965_0 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3965_2 2.224404
.ends

.subckt netg5053 g5053_1 g5053_0 g5053_2 gnd
C1  g5053_1 gnd 2.080806f
C2  g5053_0 gnd 2.080806f
C3  g5053_2 gnd 2.080806f
R1 g5053_0 g5053_2 2.224404
C4 1 gnd 2.080806f
R2 g5053_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g5053_1 2.224404
.ends

.subckt netg6217 g6217_2 g6217_0 g6217_1 gnd
C1  g6217_2 gnd 2.080806f
C2  g6217_0 gnd 2.080806f
C3  g6217_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6217_0 1 2.224404
R2 1 g6217_2 2.224404
C5 2 gnd 2.080806f
R3 g6217_2 2 2.224404
R4 2 g6217_1 2.224404
.ends

.subckt netg6853 g6853_0 g6853_2 g6853_1 gnd
C1  g6853_0 gnd 2.080806f
C2  g6853_2 gnd 2.080806f
C3  g6853_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6853_0 1 2.224404
R2 1 g6853_1 2.224404
C5 2 gnd 2.080806f
R3 g6853_0 2 2.224404
R4 g6853_2 2 2.224404
.ends

.subckt netg4639 g4639_0 g4639_2 g4639_1 gnd
C1  g4639_0 gnd 2.080806f
C2  g4639_2 gnd 2.080806f
C3  g4639_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4639_0 2.224404
R2 1 g4639_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g4639_2 2 2.224404
.ends

.subckt netg1917 g1917_1 g1917_0 gnd
C1  g1917_1 gnd 2.080806f
C2  g1917_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1917_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1917_1 2.224404
.ends

.subckt netx181 x181_1 x181_0 gnd
C1  x181_1 gnd 2.080806f
C2  x181_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x181_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 x181_1 3 2.224404
.ends

.subckt netg6152 g6152_1 g6152_0 gnd
C1  g6152_1 gnd 2.080806f
C2  g6152_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6152_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6152_1 2.224404
.ends

.subckt netg6121 g6121_0 g6121_2 g6121_1 gnd
C1  g6121_0 gnd 2.080806f
C2  g6121_2 gnd 2.080806f
C3  g6121_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6121_0 1 2.224404
R2 g6121_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g6121_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g6121_2 3 2.224404
.ends

.subckt netg5746 g5746_1 g5746_2 g5746_0 gnd
C1  g5746_1 gnd 2.080806f
C2  g5746_2 gnd 2.080806f
C3  g5746_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5746_0 2.224404
R2 g5746_1 1 2.224404
C5 2 gnd 2.080806f
R3 g5746_0 2 2.224404
R4 2 g5746_2 2.224404
.ends

.subckt netg3123 g3123_1 g3123_2 gnd
C1  g3123_1 gnd 2.080806f
C2  g3123_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3123_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g3123_2 3 2.224404
.ends

.subckt netg1468 g1468_0 g1468_1 g1468_4 g1468_3 g1468_5 gnd
C1  g1468_0 gnd 2.080806f
C2  g1468_1 gnd 2.080806f
C3  g1468_4 gnd 2.080806f
C4  g1468_3 gnd 2.080806f
C5  g1468_5 gnd 2.080806f
R1 g1468_5 g1468_0 2.224404
R2 g1468_0 g1468_4 2.224404
C6 1 gnd 2.080806f
R3 g1468_0 1 2.224404
R4 1 g1468_3 2.224404
R5 g1468_1 g1468_3 2.224404
.ends

.subckt netg1774 g1774_1 g1774_2 g1774_3 g1774_0 gnd
C1  g1774_1 gnd 2.080806f
C2  g1774_2 gnd 2.080806f
C3  g1774_3 gnd 2.080806f
C4  g1774_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1774_0 2.224404
R2 g1774_1 1 2.224404
C6 2 gnd 2.080806f
R3 g1774_0 2 2.224404
R4 2 g1774_2 2.224404
C7 3 gnd 2.080806f
R5 g1774_1 3 2.224404
R6 3 g1774_3 2.224404
.ends

.subckt netg4358 g4358_0 g4358_1 gnd
C1  g4358_0 gnd 2.080806f
C2  g4358_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4358_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g4358_1 2.224404
.ends

.subckt netg6237 g6237_0 g6237_1 g6237_2 gnd
C1  g6237_0 gnd 2.080806f
C2  g6237_1 gnd 2.080806f
C3  g6237_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6237_0 1 2.224404
R2 1 g6237_1 2.224404
C5 2 gnd 2.080806f
R3 g6237_1 2 2.224404
R4 2 g6237_2 2.224404
.ends

.subckt netg4619 g4619_2 g4619_1 gnd
C1  g4619_2 gnd 2.080806f
C2  g4619_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4619_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g4619_1 2.224404
.ends

.subckt netg5092 g5092_0 g5092_2 g5092_1 gnd
C1  g5092_0 gnd 2.080806f
C2  g5092_2 gnd 2.080806f
C3  g5092_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5092_0 2.224404
R2 g5092_1 1 2.224404
C5 2 gnd 2.080806f
R3 g5092_0 2 2.224404
R4 2 g5092_2 2.224404
.ends

.subckt netg3240 g3240_2 g3240_1 g3240_0 gnd
C1  g3240_2 gnd 2.080806f
C2  g3240_1 gnd 2.080806f
C3  g3240_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3240_0 1 2.224404
R2 g3240_1 1 2.224404
C5 2 gnd 2.080806f
R3 g3240_1 2 2.224404
R4 2 g3240_2 2.224404
.ends

.subckt netg2313 g2313_1 g2313_0 gnd
C1  g2313_1 gnd 2.080806f
C2  g2313_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2313_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2313_1 2.224404
.ends

.subckt netg4434 g4434_1 g4434_0 gnd
C1  g4434_1 gnd 2.080806f
C2  g4434_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4434_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g4434_1 3 2.224404
.ends

.subckt netg6300 g6300_2 g6300_1 g6300_0 gnd
C1  g6300_2 gnd 2.080806f
C2  g6300_1 gnd 2.080806f
C3  g6300_0 gnd 2.080806f
R1 g6300_2 g6300_0 2.224404
C4 1 gnd 2.080806f
R2 1 g6300_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 2 g6300_1 2.224404
.ends

.subckt netg1908 g1908_1 g1908_0 gnd
C1  g1908_1 gnd 2.080806f
C2  g1908_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1908_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1908_1 2.224404
.ends

.subckt netg1572 g1572_0 g1572_1 gnd
C1  g1572_0 gnd 2.080806f
C2  g1572_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1572_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1572_1 2.224404
.ends

.subckt netg952 g952_2 g952_0 g952_1 gnd
C1  g952_2 gnd 2.080806f
C2  g952_0 gnd 2.080806f
C3  g952_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g952_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g952_1 2.224404
C6 3 gnd 2.080806f
R4 g952_1 3 2.224404
R5 3 g952_2 2.224404
.ends

.subckt netg5477 g5477_0 g5477_1 gnd
C1  g5477_0 gnd 2.080806f
C2  g5477_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5477_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5477_1 2.224404
.ends

.subckt netg2480 g2480_2 g2480_1 g2480_0 gnd
C1  g2480_2 gnd 2.080806f
C2  g2480_1 gnd 2.080806f
C3  g2480_0 gnd 2.080806f
R1 g2480_0 g2480_1 2.224404
C4 1 gnd 2.080806f
R2 g2480_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 g2480_2 2 2.224404
.ends

.subckt netg4413 g4413_1 g4413_0 gnd
C1  g4413_1 gnd 2.080806f
C2  g4413_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4413_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g4413_1 3 2.224404
.ends

.subckt netg5936 g5936_1 g5936_0 g5936_2 gnd
C1  g5936_1 gnd 2.080806f
C2  g5936_0 gnd 2.080806f
C3  g5936_2 gnd 2.080806f
R1 g5936_1 g5936_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5936_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g5936_2 2 2.224404
.ends

.subckt netg2510 g2510_0 g2510_2 g2510_1 gnd
C1  g2510_0 gnd 2.080806f
C2  g2510_2 gnd 2.080806f
C3  g2510_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2510_0 2.224404
R2 g2510_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g2510_1 2.224404
R4 2 g2510_2 2.224404
.ends

.subckt netg2867 g2867_1 g2867_2 g2867_0 gnd
C1  g2867_1 gnd 2.080806f
C2  g2867_2 gnd 2.080806f
C3  g2867_0 gnd 2.080806f
R1 g2867_0 g2867_2 2.224404
C4 1 gnd 2.080806f
R2 g2867_2 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g2867_1 2.224404
.ends

.subckt netg6140 g6140_1 g6140_0 gnd
C1  g6140_1 gnd 2.080806f
C2  g6140_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6140_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6140_1 3 2.224404
.ends

.subckt netg6188 g6188_0 g6188_1 gnd
C1  g6188_0 gnd 2.080806f
C2  g6188_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6188_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6188_1 3 2.224404
.ends

.subckt netg1306 g1306_0 g1306_1 gnd
C1  g1306_0 gnd 2.080806f
C2  g1306_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1306_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1306_1 3 2.224404
.ends

.subckt netg6127 g6127_1 g6127_2 gnd
C1  g6127_1 gnd 2.080806f
C2  g6127_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6127_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6127_1 2.224404
.ends

.subckt netg1434 g1434_1 g1434_0 gnd
C1  g1434_1 gnd 2.080806f
C2  g1434_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1434_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1434_1 2.224404
.ends

.subckt netg5315 g5315_0 g5315_1 gnd
C1  g5315_0 gnd 2.080806f
C2  g5315_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5315_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g5315_1 3 2.224404
.ends

.subckt netg6314 g6314_1 g6314_0 gnd
C1  g6314_1 gnd 2.080806f
C2  g6314_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6314_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6314_1 3 2.224404
.ends

.subckt netg7363 g7363_2 g7363_0 g7363_1 gnd
C1  g7363_2 gnd 2.080806f
C2  g7363_0 gnd 2.080806f
C3  g7363_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7363_0 2.224404
R2 g7363_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g7363_1 2 2.224404
.ends

.subckt netg3285 g3285_2 g3285_0 g3285_1 gnd
C1  g3285_2 gnd 2.080806f
C2  g3285_0 gnd 2.080806f
C3  g3285_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3285_0 2.224404
R2 g3285_2 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3285_1 2.224404
.ends

.subckt netg3243 g3243_1 g3243_2 g3243_0 gnd
C1  g3243_1 gnd 2.080806f
C2  g3243_2 gnd 2.080806f
C3  g3243_0 gnd 2.080806f
R1 g3243_0 g3243_2 2.224404
C4 1 gnd 2.080806f
R2 1 g3243_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 2 g3243_1 2.224404
.ends

.subckt netg1036 g1036_2 g1036_0 gnd
C1  g1036_2 gnd 2.080806f
C2  g1036_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1036_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g1036_2 2.224404
.ends

.subckt netg3147 g3147_1 g3147_2 g3147_0 gnd
C1  g3147_1 gnd 2.080806f
C2  g3147_2 gnd 2.080806f
C3  g3147_0 gnd 2.080806f
R1 g3147_1 g3147_0 2.224404
C4 1 gnd 2.080806f
R2 g3147_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3147_2 2.224404
.ends

.subckt netg3447 g3447_1 g3447_2 g3447_0 gnd
C1  g3447_1 gnd 2.080806f
C2  g3447_2 gnd 2.080806f
C3  g3447_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3447_0 1 2.224404
R2 1 g3447_1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3447_2 2.224404
.ends

.subckt netg7245 g7245_2 g7245_0 g7245_1 gnd
C1  g7245_2 gnd 2.080806f
C2  g7245_0 gnd 2.080806f
C3  g7245_1 gnd 2.080806f
R1 g7245_1 g7245_0 2.224404
C4 1 gnd 2.080806f
R2 1 g7245_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g7245_2 2 2.224404
.ends

.subckt netg5125 g5125_0 g5125_2 g5125_1 gnd
C1  g5125_0 gnd 2.080806f
C2  g5125_2 gnd 2.080806f
C3  g5125_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5125_0 1 2.224404
R2 1 g5125_2 2.224404
C5 2 gnd 2.080806f
R3 g5125_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5125_1 2.224404
.ends

.subckt netx262 x262_1 x262_0 gnd
C1  x262_1 gnd 2.080806f
C2  x262_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x262_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 x262_1 3 2.224404
.ends

.subckt netg5271 g5271_1 g5271_0 gnd
C1  g5271_1 gnd 2.080806f
C2  g5271_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5271_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5271_1 2.224404
.ends

.subckt netg7012 g7012_1 g7012_0 gnd
C1  g7012_1 gnd 2.080806f
C2  g7012_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7012_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g7012_1 3 2.224404
.ends

.subckt netg7242 g7242_1 g7242_2 g7242_0 gnd
C1  g7242_1 gnd 2.080806f
C2  g7242_2 gnd 2.080806f
C3  g7242_0 gnd 2.080806f
R1 g7242_0 g7242_1 2.224404
C4 1 gnd 2.080806f
R2 g7242_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g7242_2 2.224404
.ends

.subckt netg6471 g6471_2 g6471_1 g6471_0 gnd
C1  g6471_2 gnd 2.080806f
C2  g6471_1 gnd 2.080806f
C3  g6471_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6471_0 2.224404
R2 g6471_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g6471_1 2.224404
R4 g6471_2 2 2.224404
.ends

.subckt netg6793 g6793_1 g6793_2 g6793_0 gnd
C1  g6793_1 gnd 2.080806f
C2  g6793_2 gnd 2.080806f
C3  g6793_0 gnd 2.080806f
R1 g6793_0 g6793_2 2.224404
C4 1 gnd 2.080806f
R2 1 g6793_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g6793_1 2 2.224404
.ends

.subckt netg7051 g7051_0 g7051_2 g7051_1 gnd
C1  g7051_0 gnd 2.080806f
C2  g7051_2 gnd 2.080806f
C3  g7051_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7051_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7051_2 2 2.224404
R4 g7051_1 g7051_2 2.224404
.ends

.subckt netg6658 g6658_1 g6658_0 gnd
C1  g6658_1 gnd 2.080806f
C2  g6658_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6658_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g6658_1 3 2.224404
.ends

.subckt netg7255 g7255_0 g7255_1 gnd
C1  g7255_0 gnd 2.080806f
C2  g7255_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7255_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g7255_1 2.224404
.ends

.subckt netg1361 g1361_0 g1361_1 gnd
C1  g1361_0 gnd 2.080806f
C2  g1361_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1361_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1361_1 2.224404
.ends

.subckt netx311 x311_1 x311_0 gnd
C1  x311_1 gnd 2.080806f
C2  x311_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x311_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 x311_1 3 2.224404
.ends

.subckt netg6686 g6686_0 g6686_1 gnd
C1  g6686_0 gnd 2.080806f
C2  g6686_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6686_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6686_1 3 2.224404
.ends

.subckt netg925 g925_2 g925_0 g925_1 gnd
C1  g925_2 gnd 2.080806f
C2  g925_0 gnd 2.080806f
C3  g925_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g925_0 1 2.224404
R2 1 g925_2 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g925_1 2.224404
.ends

.subckt netg6799 g6799_0 g6799_2 g6799_1 gnd
C1  g6799_0 gnd 2.080806f
C2  g6799_2 gnd 2.080806f
C3  g6799_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6799_0 1 2.224404
R2 1 g6799_2 2.224404
C5 2 gnd 2.080806f
R3 g6799_2 2 2.224404
R4 2 g6799_1 2.224404
.ends

.subckt netg6144 g6144_2 g6144_1 g6144_0 gnd
C1  g6144_2 gnd 2.080806f
C2  g6144_1 gnd 2.080806f
C3  g6144_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6144_0 2.224404
R2 1 g6144_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g6144_2 2 2.224404
.ends

.subckt netx331 x331_0 x331_1 gnd
C1  x331_0 gnd 2.080806f
C2  x331_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x331_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 x331_1 2.224404
.ends

.subckt netg3135 g3135_1 g3135_0 g3135_2 gnd
C1  g3135_1 gnd 2.080806f
C2  g3135_0 gnd 2.080806f
C3  g3135_2 gnd 2.080806f
R1 g3135_1 g3135_0 2.224404
C4 1 gnd 2.080806f
R2 g3135_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3135_2 2.224404
.ends

.subckt netg7527 g7527_0 g7527_1 gnd
C1  g7527_0 gnd 2.080806f
C2  g7527_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7527_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g7527_1 2.224404
.ends

.subckt netg6524 g6524_1 g6524_0 gnd
C1  g6524_1 gnd 2.080806f
C2  g6524_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6524_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g6524_1 3 2.224404
.ends

.subckt netg3559 g3559_0 g3559_1 gnd
C1  g3559_0 gnd 2.080806f
C2  g3559_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3559_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g3559_1 3 2.224404
.ends

.subckt netg1555 g1555_0 g1555_1 gnd
C1  g1555_0 gnd 2.080806f
C2  g1555_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1555_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1555_1 3 2.224404
.ends

.subckt netg940 g940_2 g940_1 g940_0 gnd
C1  g940_2 gnd 2.080806f
C2  g940_1 gnd 2.080806f
C3  g940_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g940_0 2.224404
R2 g940_1 1 2.224404
C5 2 gnd 2.080806f
R3 g940_0 2 2.224404
R4 2 g940_2 2.224404
.ends

.subckt netg5487 g5487_1 g5487_0 gnd
C1  g5487_1 gnd 2.080806f
C2  g5487_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5487_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g5487_1 3 2.224404
.ends

.subckt netg5412 g5412_0 g5412_1 gnd
C1  g5412_0 gnd 2.080806f
C2  g5412_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5412_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g5412_1 3 2.224404
.ends

.subckt netg567 g567_1 g567_0 g567_2 gnd
C1  g567_1 gnd 2.080806f
C2  g567_0 gnd 2.080806f
C3  g567_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g567_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g567_1 2 2.224404
R4 g567_2 g567_1 2.224404
.ends

.subckt netx561 x561_1 x561_0 gnd
C1  x561_1 gnd 2.080806f
C2  x561_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x561_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 x561_1 2.224404
.ends

.subckt netg5716 g5716_0 g5716_2 g5716_1 gnd
C1  g5716_0 gnd 2.080806f
C2  g5716_2 gnd 2.080806f
C3  g5716_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5716_0 1 2.224404
R2 1 g5716_1 2.224404
C5 2 gnd 2.080806f
R3 2 g5716_0 2.224404
R4 g5716_2 2 2.224404
.ends

.subckt netg1302 g1302_0 g1302_1 gnd
C1  g1302_0 gnd 2.080806f
C2  g1302_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1302_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g1302_1 3 2.224404
.ends

.subckt netg7404 g7404_1 g7404_0 gnd
C1  g7404_1 gnd 2.080806f
C2  g7404_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7404_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g7404_1 3 2.224404
.ends

.subckt netg3371 g3371_2 g3371_1 g3371_0 gnd
C1  g3371_2 gnd 2.080806f
C2  g3371_1 gnd 2.080806f
C3  g3371_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3371_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3371_2 2.224404
R4 g3371_2 g3371_1 2.224404
.ends

.subckt netg2241 g2241_1 g2241_0 g2241_2 gnd
C1  g2241_1 gnd 2.080806f
C2  g2241_0 gnd 2.080806f
C3  g2241_2 gnd 2.080806f
R1 g2241_1 g2241_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2241_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g2241_2 2 2.224404
.ends

.subckt netg6509 g6509_0 g6509_1 gnd
C1  g6509_0 gnd 2.080806f
C2  g6509_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6509_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6509_1 3 2.224404
.ends

.subckt netg4943 g4943_2 g4943_1 g4943_0 gnd
C1  g4943_2 gnd 2.080806f
C2  g4943_1 gnd 2.080806f
C3  g4943_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4943_0 1 2.224404
R2 1 g4943_1 2.224404
C5 2 gnd 2.080806f
R3 g4943_1 2 2.224404
R4 2 g4943_2 2.224404
.ends

.subckt netg6310 g6310_0 g6310_1 gnd
C1  g6310_0 gnd 2.080806f
C2  g6310_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6310_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g6310_1 3 2.224404
.ends

.subckt netg6085 g6085_1 g6085_0 gnd
C1  g6085_1 gnd 2.080806f
C2  g6085_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6085_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6085_1 2.224404
.ends

.subckt netg1438 g1438_0 g1438_1 gnd
C1  g1438_0 gnd 2.080806f
C2  g1438_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1438_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1438_1 2.224404
.ends

.subckt netg5778 g5778_1 g5778_0 gnd
C1  g5778_1 gnd 2.080806f
C2  g5778_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5778_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5778_1 2.224404
.ends

.subckt netg7414 g7414_0 g7414_2 g7414_1 gnd
C1  g7414_0 gnd 2.080806f
C2  g7414_2 gnd 2.080806f
C3  g7414_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7414_0 2.224404
R2 g7414_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g7414_2 2 2.224404
.ends

.subckt netg7237 g7237_2 g7237_0 g7237_1 gnd
C1  g7237_2 gnd 2.080806f
C2  g7237_0 gnd 2.080806f
C3  g7237_1 gnd 2.080806f
R1 g7237_1 g7237_0 2.224404
C4 1 gnd 2.080806f
R2 g7237_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g7237_2 2.224404
.ends

.subckt netg3150 g3150_1 g3150_2 g3150_0 gnd
C1  g3150_1 gnd 2.080806f
C2  g3150_2 gnd 2.080806f
C3  g3150_0 gnd 2.080806f
R1 g3150_0 g3150_1 2.224404
C4 1 gnd 2.080806f
R2 g3150_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3150_2 2.224404
.ends

.subckt netg7153 g7153_1 g7153_0 g7153_2 gnd
C1  g7153_1 gnd 2.080806f
C2  g7153_0 gnd 2.080806f
C3  g7153_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7153_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7153_1 2.224404
R4 g7153_2 2 2.224404
.ends

.subckt netg1520 g1520_1 g1520_0 gnd
C1  g1520_1 gnd 2.080806f
C2  g1520_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1520_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1520_1 3 2.224404
.ends

.subckt netg5722 g5722_2 g5722_1 g5722_0 gnd
C1  g5722_2 gnd 2.080806f
C2  g5722_1 gnd 2.080806f
C3  g5722_0 gnd 2.080806f
R1 g5722_1 g5722_0 2.224404
C4 1 gnd 2.080806f
R2 g5722_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 g5722_2 2 2.224404
.ends

.subckt netg1497 g1497_1 g1497_0 gnd
C1  g1497_1 gnd 2.080806f
C2  g1497_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1497_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1497_1 3 2.224404
.ends

.subckt netg4447 g4447_0 g4447_1 gnd
C1  g4447_0 gnd 2.080806f
C2  g4447_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4447_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g4447_1 3 2.224404
.ends

.subckt netg5843 g5843_2 g5843_1 g5843_0 gnd
C1  g5843_2 gnd 2.080806f
C2  g5843_1 gnd 2.080806f
C3  g5843_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5843_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5843_1 2 2.224404
R4 g5843_1 g5843_2 2.224404
.ends

.subckt netg98 g98_0 g98_1 gnd
C1  g98_0 gnd 2.080806f
C2  g98_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g98_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g98_1 3 2.224404
.ends

.subckt netg5521 g5521_0 g5521_1 gnd
C1  g5521_0 gnd 2.080806f
C2  g5521_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5521_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g5521_1 3 2.224404
.ends

.subckt netg2612 g2612_1 g2612_2 g2612_0 gnd
C1  g2612_1 gnd 2.080806f
C2  g2612_2 gnd 2.080806f
C3  g2612_0 gnd 2.080806f
R1 g2612_2 g2612_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2612_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 2 g2612_1 2.224404
.ends

.subckt netg7428 g7428_1 g7428_2 g7428_0 gnd
C1  g7428_1 gnd 2.080806f
C2  g7428_2 gnd 2.080806f
C3  g7428_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7428_0 1 2.224404
R2 1 g7428_1 2.224404
C5 2 gnd 2.080806f
R3 g7428_0 2 2.224404
R4 2 g7428_2 2.224404
.ends

.subckt netg1853 g1853_2 g1853_1 g1853_0 gnd
C1  g1853_2 gnd 2.080806f
C2  g1853_1 gnd 2.080806f
C3  g1853_0 gnd 2.080806f
R1 g1853_0 g1853_2 2.224404
C4 1 gnd 2.080806f
R2 g1853_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g1853_1 2.224404
.ends

.subckt netg7027 g7027_2 g7027_1 gnd
C1  g7027_2 gnd 2.080806f
C2  g7027_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7027_1 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g7027_2 3 2.224404
.ends

.subckt netg2752 g2752_0 g2752_3 g2752_2 g2752_1 gnd
C1  g2752_0 gnd 2.080806f
C2  g2752_3 gnd 2.080806f
C3  g2752_2 gnd 2.080806f
C4  g2752_1 gnd 2.080806f
R1 g2752_2 g2752_0 2.224404
R2 g2752_3 g2752_2 2.224404
C5 1 gnd 2.080806f
R3 g2752_2 1 2.224404
R4 1 g2752_1 2.224404
.ends

.subckt netg4217 g4217_1 g4217_0 gnd
C1  g4217_1 gnd 2.080806f
C2  g4217_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4217_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g4217_1 3 2.224404
.ends

.subckt netg5563 g5563_0 g5563_2 g5563_1 gnd
C1  g5563_0 gnd 2.080806f
C2  g5563_2 gnd 2.080806f
C3  g5563_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5563_0 2.224404
R2 g5563_1 1 2.224404
C5 2 gnd 2.080806f
R3 g5563_1 2 2.224404
R4 2 g5563_2 2.224404
.ends

.subckt netg2728 g2728_0 g2728_1 g2728_2 gnd
C1  g2728_0 gnd 2.080806f
C2  g2728_1 gnd 2.080806f
C3  g2728_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2728_0 2.224404
R2 g2728_1 1 2.224404
C5 2 gnd 2.080806f
R3 g2728_1 2 2.224404
R4 g2728_2 2 2.224404
.ends

.subckt netg7336 g7336_0 g7336_2 g7336_1 gnd
C1  g7336_0 gnd 2.080806f
C2  g7336_2 gnd 2.080806f
C3  g7336_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7336_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7336_2 2.224404
R4 g7336_2 g7336_1 2.224404
.ends

.subckt netg3060 g3060_1 g3060_0 gnd
C1  g3060_1 gnd 2.080806f
C2  g3060_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3060_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g3060_1 3 2.224404
.ends

.subckt netg6453 g6453_1 g6453_0 g6453_2 gnd
C1  g6453_1 gnd 2.080806f
C2  g6453_0 gnd 2.080806f
C3  g6453_2 gnd 2.080806f
R1 g6453_0 g6453_2 2.224404
C4 1 gnd 2.080806f
R2 g6453_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g6453_1 2.224404
.ends

.subckt netg7193 g7193_1 g7193_0 g7193_2 gnd
C1  g7193_1 gnd 2.080806f
C2  g7193_0 gnd 2.080806f
C3  g7193_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7193_0 2.224404
R2 1 g7193_1 2.224404
C5 2 gnd 2.080806f
R3 2 g7193_0 2.224404
R4 g7193_2 2 2.224404
.ends

.subckt netg5917 g5917_1 g5917_2 g5917_0 gnd
C1  g5917_1 gnd 2.080806f
C2  g5917_2 gnd 2.080806f
C3  g5917_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5917_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5917_2 2 2.224404
R4 g5917_2 g5917_1 2.224404
.ends

.subckt netg4117 g4117_0 g4117_3 g4117_1 g4117_2 gnd
C1  g4117_0 gnd 2.080806f
C2  g4117_3 gnd 2.080806f
C3  g4117_1 gnd 2.080806f
C4  g4117_2 gnd 2.080806f
R1 g4117_0 g4117_1 2.224404
C5 1 gnd 2.080806f
R2 1 g4117_0 2.224404
R3 g4117_2 1 2.224404
R4 g4117_3 1 2.224404
.ends

.subckt netg2686 g2686_1 g2686_0 g2686_2 gnd
C1  g2686_1 gnd 2.080806f
C2  g2686_0 gnd 2.080806f
C3  g2686_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2686_0 1 2.224404
R2 g2686_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g2686_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g2686_2 3 2.224404
.ends

.subckt netg5643 g5643_2 g5643_0 g5643_1 gnd
C1  g5643_2 gnd 2.080806f
C2  g5643_0 gnd 2.080806f
C3  g5643_1 gnd 2.080806f
R1 g5643_0 g5643_1 2.224404
C4 1 gnd 2.080806f
R2 1 g5643_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g5643_2 2 2.224404
.ends

.subckt netg4357 g4357_0 g4357_1 gnd
C1  g4357_0 gnd 2.080806f
C2  g4357_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4357_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g4357_1 3 2.224404
.ends

.subckt netg3213 g3213_2 g3213_1 gnd
C1  g3213_2 gnd 2.080806f
C2  g3213_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3213_1 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g3213_2 3 2.224404
.ends

.subckt netx51 x51_1 x51_0 gnd
C1  x51_1 gnd 2.080806f
C2  x51_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x51_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 x51_1 2.224404
.ends

.subckt netx151 x151_0 x151_1 gnd
C1  x151_0 gnd 2.080806f
C2  x151_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x151_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 x151_1 3 2.224404
.ends

.subckt netg6995 g6995_0 g6995_1 gnd
C1  g6995_0 gnd 2.080806f
C2  g6995_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6995_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g6995_1 3 2.224404
.ends

.subckt netg4423 g4423_0 g4423_1 gnd
C1  g4423_0 gnd 2.080806f
C2  g4423_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4423_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g4423_1 2.224404
.ends

.subckt netg6537 g6537_1 g6537_0 gnd
C1  g6537_1 gnd 2.080806f
C2  g6537_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6537_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6537_1 2.224404
.ends

.subckt netg6560 g6560_1 g6560_0 gnd
C1  g6560_1 gnd 2.080806f
C2  g6560_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6560_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6560_1 3 2.224404
.ends

.subckt netg7015 g7015_1 g7015_0 gnd
C1  g7015_1 gnd 2.080806f
C2  g7015_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7015_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g7015_1 2.224404
.ends

.subckt netg3086 g3086_1 g3086_2 g3086_0 gnd
C1  g3086_1 gnd 2.080806f
C2  g3086_2 gnd 2.080806f
C3  g3086_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3086_0 2.224404
R2 g3086_1 1 2.224404
C5 2 gnd 2.080806f
R3 g3086_1 2 2.224404
R4 g3086_2 2 2.224404
.ends

.subckt netg6396 g6396_1 g6396_0 gnd
C1  g6396_1 gnd 2.080806f
C2  g6396_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6396_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6396_1 3 2.224404
.ends

.subckt netg5710 g5710_2 g5710_0 g5710_1 gnd
C1  g5710_2 gnd 2.080806f
C2  g5710_0 gnd 2.080806f
C3  g5710_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5710_0 2.224404
R2 g5710_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g5710_1 2.224404
R4 g5710_2 2 2.224404
.ends

.subckt netg5044 g5044_1 g5044_0 g5044_2 gnd
C1  g5044_1 gnd 2.080806f
C2  g5044_0 gnd 2.080806f
C3  g5044_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5044_0 1 2.224404
R2 g5044_1 1 2.224404
C5 2 gnd 2.080806f
R3 g5044_1 2 2.224404
R4 g5044_2 2 2.224404
.ends

.subckt netg5834 g5834_1 g5834_0 gnd
C1  g5834_1 gnd 2.080806f
C2  g5834_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5834_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5834_1 2.224404
.ends

.subckt netg5871 g5871_2 g5871_0 gnd
C1  g5871_2 gnd 2.080806f
C2  g5871_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5871_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5871_2 2.224404
.ends

.subckt netg6850 g6850_1 g6850_0 g6850_2 gnd
C1  g6850_1 gnd 2.080806f
C2  g6850_0 gnd 2.080806f
C3  g6850_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6850_0 2.224404
R2 g6850_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g6850_2 2.224404
R4 g6850_1 2 2.224404
.ends

.subckt netg2023 g2023_2 g2023_3 g2023_1 gnd
C1  g2023_2 gnd 2.080806f
C2  g2023_3 gnd 2.080806f
C3  g2023_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2023_3 2.224404
R2 g2023_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g2023_2 2.224404
R4 g2023_1 2 2.224404
.ends

.subckt netg1940 g1940_0 g1940_1 gnd
C1  g1940_0 gnd 2.080806f
C2  g1940_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1940_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g1940_1 3 2.224404
.ends

.subckt netg2549 g2549_0 g2549_1 g2549_2 gnd
C1  g2549_0 gnd 2.080806f
C2  g2549_1 gnd 2.080806f
C3  g2549_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2549_0 1 2.224404
R2 1 g2549_1 2.224404
C5 2 gnd 2.080806f
R3 g2549_1 2 2.224404
R4 2 g2549_2 2.224404
.ends

.subckt netg1030 g1030_1 g1030_2 gnd
C1  g1030_1 gnd 2.080806f
C2  g1030_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1030_2 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g1030_1 3 2.224404
.ends

.subckt netg2070 g2070_1 g2070_0 gnd
C1  g2070_1 gnd 2.080806f
C2  g2070_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2070_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g2070_1 3 2.224404
.ends

.subckt netg1478 g1478_0 g1478_1 gnd
C1  g1478_0 gnd 2.080806f
C2  g1478_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1478_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1478_1 2.224404
.ends

.subckt netg4666 g4666_1 g4666_0 gnd
C1  g4666_1 gnd 2.080806f
C2  g4666_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4666_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g4666_1 2.224404
.ends

.subckt netg4625 g4625_1 g4625_0 gnd
C1  g4625_1 gnd 2.080806f
C2  g4625_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4625_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g4625_1 2.224404
.ends

.subckt netg3914 g3914_0 g3914_1 gnd
C1  g3914_0 gnd 2.080806f
C2  g3914_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3914_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g3914_1 3 2.224404
.ends

.subckt netg7321 g7321_0 g7321_2 g7321_1 gnd
C1  g7321_0 gnd 2.080806f
C2  g7321_2 gnd 2.080806f
C3  g7321_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7321_0 1 2.224404
R2 1 g7321_2 2.224404
C5 2 gnd 2.080806f
R3 g7321_2 2 2.224404
R4 2 g7321_1 2.224404
.ends

.subckt netg5780 g5780_1 g5780_2 gnd
C1  g5780_1 gnd 2.080806f
C2  g5780_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5780_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g5780_2 3 2.224404
.ends

.subckt netg6318 g6318_2 g6318_0 g6318_1 g6318_3 gnd
C1  g6318_2 gnd 2.080806f
C2  g6318_0 gnd 2.080806f
C3  g6318_1 gnd 2.080806f
C4  g6318_3 gnd 2.080806f
R1 g6318_0 g6318_2 2.224404
R2 g6318_1 g6318_2 2.224404
C5 1 gnd 2.080806f
R3 g6318_2 1 2.224404
R4 1 g6318_3 2.224404
.ends

.subckt netg1060 g1060_2 g1060_3 g1060_5 g1060_4 g1060_1 g1060_0 gnd
C1  g1060_2 gnd 2.080806f
C2  g1060_3 gnd 2.080806f
C3  g1060_5 gnd 2.080806f
C4  g1060_4 gnd 2.080806f
C5  g1060_1 gnd 2.080806f
C6  g1060_0 gnd 2.080806f
R1 g1060_2 g1060_0 2.224404
R2 g1060_0 g1060_4 2.224404
R3 g1060_3 g1060_2 2.224404
R4 g1060_5 g1060_3 2.224404
R5 g1060_5 g1060_1 2.224404
.ends

.subckt netg3407 g3407_1 g3407_2 g3407_0 gnd
C1  g3407_1 gnd 2.080806f
C2  g3407_2 gnd 2.080806f
C3  g3407_0 gnd 2.080806f
R1 g3407_1 g3407_0 2.224404
C4 1 gnd 2.080806f
R2 g3407_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3407_2 2.224404
.ends

.subckt netg5083 g5083_0 g5083_1 g5083_2 gnd
C1  g5083_0 gnd 2.080806f
C2  g5083_1 gnd 2.080806f
C3  g5083_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5083_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5083_1 2 2.224404
C6 3 gnd 2.080806f
R4 g5083_1 3 2.224404
R5 g5083_2 3 2.224404
.ends

.subckt netg5489 g5489_0 g5489_1 gnd
C1  g5489_0 gnd 2.080806f
C2  g5489_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5489_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 g5489_1 3 2.224404
.ends

.subckt netg3270 g3270_0 g3270_1 g3270_2 gnd
C1  g3270_0 gnd 2.080806f
C2  g3270_1 gnd 2.080806f
C3  g3270_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3270_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3270_2 2.224404
R4 g3270_2 g3270_1 2.224404
.ends

.subckt netg7421 g7421_1 g7421_0 gnd
C1  g7421_1 gnd 2.080806f
C2  g7421_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7421_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 g7421_1 3 2.224404
.ends

.subckt netx472 x472_1 x472_0 gnd
C1  x472_1 gnd 2.080806f
C2  x472_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x472_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 x472_1 2.224404
.ends

.subckt netg3947 g3947_0 g3947_1 g3947_2 gnd
C1  g3947_0 gnd 2.080806f
C2  g3947_1 gnd 2.080806f
C3  g3947_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3947_0 1 2.224404
R2 1 g3947_2 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3947_1 2.224404
.ends

.subckt netg1897 g1897_0 g1897_1 gnd
C1  g1897_0 gnd 2.080806f
C2  g1897_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1897_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1897_1 2.224404
.ends

.subckt netg5903 g5903_1 g5903_0 g5903_2 gnd
C1  g5903_1 gnd 2.080806f
C2  g5903_0 gnd 2.080806f
C3  g5903_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5903_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5903_1 2.224404
R4 2 g5903_2 2.224404
.ends

.subckt netg4931 g4931_0 g4931_3 g4931_1 g4931_2 gnd
C1  g4931_0 gnd 2.080806f
C2  g4931_3 gnd 2.080806f
C3  g4931_1 gnd 2.080806f
C4  g4931_2 gnd 2.080806f
R1 g4931_3 g4931_0 2.224404
R2 g4931_1 g4931_3 2.224404
C5 1 gnd 2.080806f
R3 1 g4931_1 2.224404
R4 g4931_2 1 2.224404
.ends

.subckt netg7033 g7033_0 g7033_1 g7033_4 g7033_3 gnd
C1  g7033_0 gnd 2.080806f
C2  g7033_1 gnd 2.080806f
C3  g7033_4 gnd 2.080806f
C4  g7033_3 gnd 2.080806f
R1 g7033_0 g7033_4 2.224404
C5 1 gnd 2.080806f
R2 1 g7033_4 2.224404
R3 g7033_3 1 2.224404
C6 2 gnd 2.080806f
R4 2 g7033_3 2.224404
R5 g7033_1 2 2.224404
.ends

.subckt netg6826 g6826_0 g6826_1 gnd
C1  g6826_0 gnd 2.080806f
C2  g6826_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6826_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6826_1 2.224404
.ends

.subckt netg5649 g5649_0 g5649_2 g5649_1 gnd
C1  g5649_0 gnd 2.080806f
C2  g5649_2 gnd 2.080806f
C3  g5649_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5649_0 2.224404
R2 1 g5649_2 2.224404
C5 2 gnd 2.080806f
R3 2 g5649_2 2.224404
R4 g5649_1 2 2.224404
.ends

.subckt netg3526 g3526_0 g3526_1 gnd
C1  g3526_0 gnd 2.080806f
C2  g3526_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3526_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g3526_1 2.224404
.ends

.subckt netg4967 g4967_1 g4967_2 g4967_0 gnd
C1  g4967_1 gnd 2.080806f
C2  g4967_2 gnd 2.080806f
C3  g4967_0 gnd 2.080806f
R1 g4967_2 g4967_0 2.224404
C4 1 gnd 2.080806f
R2 1 g4967_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
R4 g4967_1 2 2.224404
.ends

.subckt netg1066 g1066_0 g1066_1 g1066_2 gnd
C1  g1066_0 gnd 2.080806f
C2  g1066_1 gnd 2.080806f
C3  g1066_2 gnd 2.080806f
R1 g1066_2 g1066_0 2.224404
C4 1 gnd 2.080806f
R2 g1066_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g1066_1 2.224404
.ends

.subckt netg5707 g5707_1 g5707_0 g5707_2 gnd
C1  g5707_1 gnd 2.080806f
C2  g5707_0 gnd 2.080806f
C3  g5707_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5707_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5707_1 2 2.224404
C6 3 gnd 2.080806f
R4 g5707_1 3 2.224404
R5 g5707_2 3 2.224404
.ends

.subckt netg7088 g7088_0 g7088_1 gnd
C1  g7088_0 gnd 2.080806f
C2  g7088_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7088_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g7088_1 2.224404
.ends

.subckt netg5912 g5912_2 g5912_0 g5912_1 gnd
C1  g5912_2 gnd 2.080806f
C2  g5912_0 gnd 2.080806f
C3  g5912_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5912_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g5912_1 3 2.224404
R5 g5912_2 g5912_1 2.224404
.ends

.subckt netg5942 g5942_2 g5942_1 g5942_0 gnd
C1  g5942_2 gnd 2.080806f
C2  g5942_1 gnd 2.080806f
C3  g5942_0 gnd 2.080806f
R1 g5942_1 g5942_0 2.224404
C4 1 gnd 2.080806f
R2 g5942_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5942_2 2.224404
.ends

.subckt netg4940 g4940_2 g4940_0 g4940_1 gnd
C1  g4940_2 gnd 2.080806f
C2  g4940_0 gnd 2.080806f
C3  g4940_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4940_0 2.224404
R2 1 g4940_1 2.224404
C5 2 gnd 2.080806f
R3 g4940_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g4940_2 2.224404
.ends

.subckt netg2756 g2756_0 g2756_2 g2756_1 gnd
C1  g2756_0 gnd 2.080806f
C2  g2756_2 gnd 2.080806f
C3  g2756_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2756_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2756_1 2 2.224404
C6 3 gnd 2.080806f
R4 3 g2756_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g2756_2 4 2.224404
.ends

.subckt netg3444 g3444_1 g3444_0 g3444_2 gnd
C1  g3444_1 gnd 2.080806f
C2  g3444_0 gnd 2.080806f
C3  g3444_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3444_0 2.224404
R2 g3444_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g3444_1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g3444_2 3 2.224404
.ends

.subckt netg4183 g4183_0 g4183_1 g4183_2 gnd
C1  g4183_0 gnd 2.080806f
C2  g4183_1 gnd 2.080806f
C3  g4183_2 gnd 2.080806f
R1 g4183_1 g4183_0 2.224404
C4 1 gnd 2.080806f
R2 1 g4183_0 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g4183_2 2.224404
.ends

.subckt netg1536 g1536_1 g1536_0 gnd
C1  g1536_1 gnd 2.080806f
C2  g1536_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1536_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1536_1 4 2.224404
.ends

.subckt netg1006 g1006_2 g1006_0 g1006_1 gnd
C1  g1006_2 gnd 2.080806f
C2  g1006_0 gnd 2.080806f
C3  g1006_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g1006_0 2.224404
R2 g1006_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g1006_2 2.224404
.ends

.subckt netg2938 g2938_1 g2938_0 gnd
C1  g2938_1 gnd 2.080806f
C2  g2938_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2938_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g2938_1 2.224404
.ends

.subckt netg4964 g4964_1 g4964_2 g4964_0 gnd
C1  g4964_1 gnd 2.080806f
C2  g4964_2 gnd 2.080806f
C3  g4964_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4964_0 2.224404
R2 g4964_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g4964_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g4964_1 3 2.224404
.ends

.subckt netg2848 g2848_1 g2848_0 gnd
C1  g2848_1 gnd 2.080806f
C2  g2848_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2848_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g2848_1 2.224404
.ends

.subckt netg1101 g1101_1 g1101_0 gnd
C1  g1101_1 gnd 2.080806f
C2  g1101_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1101_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1101_1 4 2.224404
.ends

.subckt netg1458 g1458_1 g1458_0 gnd
C1  g1458_1 gnd 2.080806f
C2  g1458_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1458_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1458_1 4 2.224404
.ends

.subckt netg5095 g5095_2 g5095_1 g5095_0 gnd
C1  g5095_2 gnd 2.080806f
C2  g5095_1 gnd 2.080806f
C3  g5095_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5095_0 2.224404
R2 g5095_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g5095_2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5095_1 2.224404
.ends

.subckt netg3483 g3483_1 g3483_0 gnd
C1  g3483_1 gnd 2.080806f
C2  g3483_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3483_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g3483_1 4 2.224404
.ends

.subckt netg4188 g4188_0 g4188_1 gnd
C1  g4188_0 gnd 2.080806f
C2  g4188_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4188_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g4188_1 2.224404
.ends

.subckt netg3002 g3002_1 g3002_0 gnd
C1  g3002_1 gnd 2.080806f
C2  g3002_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3002_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g3002_1 2.224404
.ends

.subckt netg5464 g5464_1 g5464_0 gnd
C1  g5464_1 gnd 2.080806f
C2  g5464_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5464_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 g5464_1 4 2.224404
.ends

.subckt netg2522 g2522_2 g2522_1 g2522_0 gnd
C1  g2522_2 gnd 2.080806f
C2  g2522_1 gnd 2.080806f
C3  g2522_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2522_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2522_1 2 2.224404
C6 3 gnd 2.080806f
R4 g2522_1 3 2.224404
R5 g2522_2 3 2.224404
.ends

.subckt netg1330 g1330_6 g1330_5 g1330_4 g1330_0 g1330_3 g1330_1 gnd
C1  g1330_6 gnd 2.080806f
C2  g1330_5 gnd 2.080806f
C3  g1330_4 gnd 2.080806f
C4  g1330_0 gnd 2.080806f
C5  g1330_3 gnd 2.080806f
C6  g1330_1 gnd 2.080806f
R1 g1330_0 g1330_5 2.224404
R2 g1330_6 g1330_0 2.224404
R3 g1330_3 g1330_6 2.224404
R4 g1330_3 g1330_1 2.224404
R5 g1330_4 g1330_3 2.224404
.ends

.subckt netg5272 g5272_0 g5272_1 gnd
C1  g5272_0 gnd 2.080806f
C2  g5272_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5272_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g5272_1 2.224404
.ends

.subckt netg5761 g5761_0 g5761_1 g5761_2 gnd
C1  g5761_0 gnd 2.080806f
C2  g5761_1 gnd 2.080806f
C3  g5761_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5761_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5761_2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5761_1 2.224404
.ends

.subckt netg1152 g1152_0 g1152_1 gnd
C1  g1152_0 gnd 2.080806f
C2  g1152_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1152_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1152_1 4 2.224404
.ends

.subckt netg7411 g7411_0 g7411_1 gnd
C1  g7411_0 gnd 2.080806f
C2  g7411_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7411_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g7411_1 2.224404
.ends

.subckt netg1120 g1120_1 g1120_0 gnd
C1  g1120_1 gnd 2.080806f
C2  g1120_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1120_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g1120_1 2.224404
.ends

.subckt netg5881 g5881_2 g5881_1 g5881_0 gnd
C1  g5881_2 gnd 2.080806f
C2  g5881_1 gnd 2.080806f
C3  g5881_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5881_0 2.224404
R2 1 g5881_2 2.224404
C5 2 gnd 2.080806f
R3 g5881_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g5881_1 2.224404
.ends

.subckt netx541 x541_1 x541_0 gnd
C1  x541_1 gnd 2.080806f
C2  x541_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x541_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 x541_1 4 2.224404
.ends

.subckt netg5894 g5894_1 g5894_2 g5894_0 gnd
C1  g5894_1 gnd 2.080806f
C2  g5894_2 gnd 2.080806f
C3  g5894_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5894_0 1 2.224404
R2 1 g5894_1 2.224404
C5 2 gnd 2.080806f
R3 g5894_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5894_2 2.224404
.ends

.subckt netg6269 g6269_0 g6269_2 g6269_1 gnd
C1  g6269_0 gnd 2.080806f
C2  g6269_2 gnd 2.080806f
C3  g6269_1 gnd 2.080806f
R1 g6269_0 g6269_2 2.224404
C4 1 gnd 2.080806f
R2 g6269_2 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g6269_1 2.224404
.ends

.subckt netg6990 g6990_1 g6990_2 g6990_0 gnd
C1  g6990_1 gnd 2.080806f
C2  g6990_2 gnd 2.080806f
C3  g6990_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6990_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 g6990_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 g6990_1 2.224404
R6 g6990_2 4 2.224404
.ends

.subckt netg7366 g7366_0 g7366_2 g7366_1 gnd
C1  g7366_0 gnd 2.080806f
C2  g7366_2 gnd 2.080806f
C3  g7366_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7366_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g7366_1 2 2.224404
C6 3 gnd 2.080806f
R4 3 g7366_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g7366_2 4 2.224404
.ends

.subckt netg7158 g7158_1 g7158_2 g7158_0 gnd
C1  g7158_1 gnd 2.080806f
C2  g7158_2 gnd 2.080806f
C3  g7158_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7158_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7158_1 2 2.224404
C6 3 gnd 2.080806f
R4 3 g7158_1 2.224404
R5 g7158_2 3 2.224404
.ends

.subckt netg5220 g5220_0 g5220_2 g5220_1 gnd
C1  g5220_0 gnd 2.080806f
C2  g5220_2 gnd 2.080806f
C3  g5220_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5220_0 1 2.224404
R2 1 g5220_1 2.224404
C5 2 gnd 2.080806f
R3 2 g5220_1 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5220_2 2.224404
.ends

.subckt netg3255 g3255_2 g3255_1 g3255_0 gnd
C1  g3255_2 gnd 2.080806f
C2  g3255_1 gnd 2.080806f
C3  g3255_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3255_0 1 2.224404
R2 1 g3255_2 2.224404
C5 2 gnd 2.080806f
R3 2 g3255_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g3255_1 3 2.224404
.ends

.subckt netg1344 g1344_0 g1344_1 g1344_3 g1344_2 g1344_5 g1344_4 gnd
C1  g1344_0 gnd 2.080806f
C2  g1344_1 gnd 2.080806f
C3  g1344_3 gnd 2.080806f
C4  g1344_2 gnd 2.080806f
C5  g1344_5 gnd 2.080806f
C6  g1344_4 gnd 2.080806f
R1 g1344_0 g1344_3 2.224404
C7 1 gnd 2.080806f
R2 1 g1344_0 2.224404
R3 g1344_1 1 2.224404
C8 2 gnd 2.080806f
R4 g1344_3 2 2.224404
R5 2 g1344_2 2.224404
C9 3 gnd 2.080806f
R6 g1344_1 3 2.224404
R7 3 g1344_5 2.224404
R8 g1344_5 g1344_4 2.224404
.ends

.subckt netg5926 g5926_1 g5926_2 g5926_0 gnd
C1  g5926_1 gnd 2.080806f
C2  g5926_2 gnd 2.080806f
C3  g5926_0 gnd 2.080806f
R1 g5926_1 g5926_0 2.224404
C4 1 gnd 2.080806f
R2 g5926_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5926_2 2.224404
.ends

.subckt netg487 g487_0 g487_1 gnd
C1  g487_0 gnd 2.080806f
C2  g487_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g487_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 g487_1 4 2.224404
.ends

.subckt netg5891 g5891_1 g5891_2 g5891_0 gnd
C1  g5891_1 gnd 2.080806f
C2  g5891_2 gnd 2.080806f
C3  g5891_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5891_0 2.224404
R2 g5891_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g5891_2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g5891_1 3 2.224404
.ends

.subckt netg7303 g7303_2 g7303_1 g7303_0 gnd
C1  g7303_2 gnd 2.080806f
C2  g7303_1 gnd 2.080806f
C3  g7303_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7303_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7303_1 2.224404
C6 3 gnd 2.080806f
R4 g7303_1 3 2.224404
R5 3 g7303_2 2.224404
.ends

.subckt netg4756 g4756_0 g4756_3 g4756_2 g4756_1 gnd
C1  g4756_0 gnd 2.080806f
C2  g4756_3 gnd 2.080806f
C3  g4756_2 gnd 2.080806f
C4  g4756_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g4756_0 2.224404
R2 g4756_3 1 2.224404
R3 g4756_1 g4756_3 2.224404
C6 2 gnd 2.080806f
R4 1 2 2.224404
R5 2 g4756_2 2.224404
.ends

.subckt netg5758 g5758_0 g5758_1 g5758_2 gnd
C1  g5758_0 gnd 2.080806f
C2  g5758_1 gnd 2.080806f
C3  g5758_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5758_0 2.224404
R2 g5758_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g5758_2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g5758_1 3 2.224404
.ends

.subckt netg5478 g5478_1 g5478_0 gnd
C1  g5478_1 gnd 2.080806f
C2  g5478_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5478_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 g5478_1 4 2.224404
.ends

.subckt netg5613 g5613_0 g5613_1 g5613_2 gnd
C1  g5613_0 gnd 2.080806f
C2  g5613_1 gnd 2.080806f
C3  g5613_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5613_0 2.224404
R2 g5613_2 1 2.224404
C5 2 gnd 2.080806f
R3 g5613_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5613_1 2.224404
.ends

.subckt netg4661 g4661_1 g4661_0 gnd
C1  g4661_1 gnd 2.080806f
C2  g4661_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4661_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g4661_1 2.224404
.ends

.subckt netg2650 g2650_1 g2650_0 g2650_2 gnd
C1  g2650_1 gnd 2.080806f
C2  g2650_0 gnd 2.080806f
C3  g2650_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2650_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2650_2 2.224404
R5 g2650_2 g2650_1 2.224404
.ends

.subckt netg100 g100_0 g100_1 gnd
C1  g100_0 gnd 2.080806f
C2  g100_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g100_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g100_1 4 2.224404
.ends

.subckt netg6631 g6631_1 g6631_2 g6631_0 gnd
C1  g6631_1 gnd 2.080806f
C2  g6631_2 gnd 2.080806f
C3  g6631_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6631_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g6631_2 3 2.224404
R5 g6631_1 g6631_2 2.224404
.ends

.subckt netg6346 g6346_1 g6346_3 g6346_0 gnd
C1  g6346_1 gnd 2.080806f
C2  g6346_3 gnd 2.080806f
C3  g6346_0 gnd 2.080806f
R1 g6346_0 g6346_1 2.224404
C4 1 gnd 2.080806f
R2 g6346_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g6346_3 2.224404
.ends

.subckt netg5930 g5930_1 g5930_0 gnd
C1  g5930_1 gnd 2.080806f
C2  g5930_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5930_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g5930_1 2.224404
.ends

.subckt netg5688 g5688_0 g5688_2 g5688_1 gnd
C1  g5688_0 gnd 2.080806f
C2  g5688_2 gnd 2.080806f
C3  g5688_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5688_0 1 2.224404
R2 1 g5688_1 2.224404
C5 2 gnd 2.080806f
R3 2 g5688_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g5688_2 3 2.224404
.ends

.subckt netg6023 g6023_1 g6023_0 g6023_2 gnd
C1  g6023_1 gnd 2.080806f
C2  g6023_0 gnd 2.080806f
C3  g6023_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6023_0 1 2.224404
R2 g6023_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g6023_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 3 g6023_2 2.224404
.ends

.subckt netg2423 g2423_2 g2423_1 g2423_0 gnd
C1  g2423_2 gnd 2.080806f
C2  g2423_1 gnd 2.080806f
C3  g2423_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2423_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2423_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 g2423_2 2.224404
R5 g2423_1 3 2.224404
.ends

.subckt netg1404 g1404_1 g1404_0 gnd
C1  g1404_1 gnd 2.080806f
C2  g1404_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1404_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 g1404_1 4 2.224404
.ends

.subckt netg6818 g6818_1 g6818_0 gnd
C1  g6818_1 gnd 2.080806f
C2  g6818_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6818_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g6818_1 4 2.224404
.ends

.subckt netg747 g747_3 g747_1 g747_4 g747_2 g747_0 gnd
C1  g747_3 gnd 2.080806f
C2  g747_1 gnd 2.080806f
C3  g747_4 gnd 2.080806f
C4  g747_2 gnd 2.080806f
C5  g747_0 gnd 2.080806f
R1 g747_0 g747_2 2.224404
R2 g747_3 g747_0 2.224404
R3 g747_4 g747_0 2.224404
C6 1 gnd 2.080806f
R4 1 g747_3 2.224404
C7 2 gnd 2.080806f
R5 2 1 2.224404
R6 g747_1 2 2.224404
.ends

.subckt netg6147 g6147_2 g6147_0 g6147_1 gnd
C1  g6147_2 gnd 2.080806f
C2  g6147_0 gnd 2.080806f
C3  g6147_1 gnd 2.080806f
R1 g6147_0 g6147_2 2.224404
C4 1 gnd 2.080806f
R2 g6147_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g6147_1 2.224404
.ends

.subckt netg2761 g2761_1 g2761_0 gnd
C1  g2761_1 gnd 2.080806f
C2  g2761_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2761_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g2761_1 2.224404
.ends

.subckt netg5431 g5431_0 g5431_2 g5431_1 gnd
C1  g5431_0 gnd 2.080806f
C2  g5431_2 gnd 2.080806f
C3  g5431_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5431_0 1 2.224404
R2 1 g5431_2 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5431_1 2.224404
.ends

.subckt netg6481 g6481_1 g6481_2 g6481_0 gnd
C1  g6481_1 gnd 2.080806f
C2  g6481_2 gnd 2.080806f
C3  g6481_0 gnd 2.080806f
R1 g6481_0 g6481_2 2.224404
C4 1 gnd 2.080806f
R2 1 g6481_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g6481_1 3 2.224404
.ends

.subckt netg7551 g7551_1 g7551_0 gnd
C1  g7551_1 gnd 2.080806f
C2  g7551_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7551_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g7551_1 4 2.224404
.ends

.subckt netg4030 g4030_0 g4030_3 g4030_1 g4030_2 gnd
C1  g4030_0 gnd 2.080806f
C2  g4030_3 gnd 2.080806f
C3  g4030_1 gnd 2.080806f
C4  g4030_2 gnd 2.080806f
R1 g4030_0 g4030_1 2.224404
C5 1 gnd 2.080806f
R2 g4030_1 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g4030_3 2.224404
R5 g4030_3 g4030_2 2.224404
.ends

.subckt netg5743 g5743_0 g5743_2 g5743_1 gnd
C1  g5743_0 gnd 2.080806f
C2  g5743_2 gnd 2.080806f
C3  g5743_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5743_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5743_1 2.224404
C6 3 gnd 2.080806f
R4 g5743_1 3 2.224404
R5 3 g5743_2 2.224404
.ends

.subckt netg3482 g3482_1 g3482_0 gnd
C1  g3482_1 gnd 2.080806f
C2  g3482_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3482_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g3482_1 2.224404
.ends

.subckt netg1286 g1286_1 g1286_0 gnd
C1  g1286_1 gnd 2.080806f
C2  g1286_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1286_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 g1286_1 4 2.224404
.ends

.subckt netg4422 g4422_0 g4422_1 gnd
C1  g4422_0 gnd 2.080806f
C2  g4422_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4422_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g4422_1 4 2.224404
.ends

.subckt netg2668 g2668_2 g2668_0 gnd
C1  g2668_2 gnd 2.080806f
C2  g2668_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2668_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g2668_2 2.224404
.ends

.subckt netg7065 g7065_1 g7065_0 g7065_2 gnd
C1  g7065_1 gnd 2.080806f
C2  g7065_0 gnd 2.080806f
C3  g7065_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7065_0 1 2.224404
R2 1 g7065_1 2.224404
C5 2 gnd 2.080806f
R3 g7065_1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g7065_2 2.224404
.ends

.subckt netg4368 g4368_1 g4368_0 g4368_2 gnd
C1  g4368_1 gnd 2.080806f
C2  g4368_0 gnd 2.080806f
C3  g4368_2 gnd 2.080806f
R1 g4368_0 g4368_1 2.224404
C4 1 gnd 2.080806f
R2 g4368_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g4368_2 2.224404
.ends

.subckt netg4913 g4913_2 g4913_1 g4913_3 gnd
C1  g4913_2 gnd 2.080806f
C2  g4913_1 gnd 2.080806f
C3  g4913_3 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4913_2 2.224404
R2 g4913_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g4913_3 3 2.224404
.ends

.subckt netg3106 g3106_0 g3106_2 g3106_1 gnd
C1  g3106_0 gnd 2.080806f
C2  g3106_2 gnd 2.080806f
C3  g3106_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3106_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3106_1 2.224404
C6 3 gnd 2.080806f
R4 1 3 2.224404
R5 3 g3106_2 2.224404
.ends

.subckt netg3374 g3374_0 g3374_1 g3374_2 gnd
C1  g3374_0 gnd 2.080806f
C2  g3374_1 gnd 2.080806f
C3  g3374_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3374_0 2.224404
R2 g3374_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g3374_2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g3374_1 3 2.224404
.ends

.subckt netg1986 g1986_1 g1986_0 g1986_2 g1986_3 gnd
C1  g1986_1 gnd 2.080806f
C2  g1986_0 gnd 2.080806f
C3  g1986_2 gnd 2.080806f
C4  g1986_3 gnd 2.080806f
R1 g1986_2 g1986_0 2.224404
C5 1 gnd 2.080806f
R2 g1986_0 1 2.224404
R3 1 g1986_1 2.224404
C6 2 gnd 2.080806f
R4 2 g1986_2 2.224404
R5 g1986_3 2 2.224404
.ends

.subckt netg1484 g1484_1 g1484_5 g1484_4 g1484_0 g1484_2 gnd
C1  g1484_1 gnd 2.080806f
C2  g1484_5 gnd 2.080806f
C3  g1484_4 gnd 2.080806f
C4  g1484_0 gnd 2.080806f
C5  g1484_2 gnd 2.080806f
R1 g1484_2 g1484_0 2.224404
C6 1 gnd 2.080806f
R2 g1484_2 1 2.224404
R3 1 g1484_4 2.224404
C7 2 gnd 2.080806f
R4 g1484_4 2 2.224404
R5 2 g1484_1 2.224404
R6 2 g1484_5 2.224404
.ends

.subckt netg5174 g5174_2 g5174_1 g5174_0 gnd
C1  g5174_2 gnd 2.080806f
C2  g5174_1 gnd 2.080806f
C3  g5174_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5174_0 2.224404
R2 1 g5174_1 2.224404
C5 2 gnd 2.080806f
R3 g5174_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5174_2 2.224404
.ends

.subckt netg4400 g4400_0 g4400_1 gnd
C1  g4400_0 gnd 2.080806f
C2  g4400_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4400_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g4400_1 2.224404
.ends

.subckt netg6867 g6867_1 g6867_2 g6867_0 gnd
C1  g6867_1 gnd 2.080806f
C2  g6867_2 gnd 2.080806f
C3  g6867_0 gnd 2.080806f
R1 g6867_0 g6867_2 2.224404
C4 1 gnd 2.080806f
R2 g6867_0 1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 g6867_1 3 2.224404
.ends

.subckt netg5352 g5352_1 g5352_0 gnd
C1  g5352_1 gnd 2.080806f
C2  g5352_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5352_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 g5352_1 4 2.224404
.ends

.subckt netg973 g973_2 g973_1 g973_0 gnd
C1  g973_2 gnd 2.080806f
C2  g973_1 gnd 2.080806f
C3  g973_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g973_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g973_1 2.224404
C6 3 gnd 2.080806f
R4 g973_1 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g973_2 2.224404
.ends

.subckt netg4017 g4017_1 g4017_0 gnd
C1  g4017_1 gnd 2.080806f
C2  g4017_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4017_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g4017_1 2.224404
.ends

.subckt netg3068 g3068_1 g3068_0 gnd
C1  g3068_1 gnd 2.080806f
C2  g3068_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3068_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g3068_1 2.224404
.ends

.subckt netg3189 g3189_1 g3189_2 g3189_0 gnd
C1  g3189_1 gnd 2.080806f
C2  g3189_2 gnd 2.080806f
C3  g3189_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3189_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3189_1 2.224404
C6 3 gnd 2.080806f
R4 3 g3189_1 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g3189_2 2.224404
.ends

.subckt netg5479 g5479_1 g5479_0 gnd
C1  g5479_1 gnd 2.080806f
C2  g5479_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5479_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 g5479_1 4 2.224404
.ends

.subckt netg4917 g4917_2 g4917_0 g4917_1 gnd
C1  g4917_2 gnd 2.080806f
C2  g4917_0 gnd 2.080806f
C3  g4917_1 gnd 2.080806f
R1 g4917_0 g4917_1 2.224404
C4 1 gnd 2.080806f
R2 g4917_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g4917_2 2.224404
.ends

.subckt netg5437 g5437_2 g5437_0 g5437_1 gnd
C1  g5437_2 gnd 2.080806f
C2  g5437_0 gnd 2.080806f
C3  g5437_1 gnd 2.080806f
R1 g5437_2 g5437_0 2.224404
C4 1 gnd 2.080806f
R2 g5437_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5437_1 2.224404
.ends

.subckt netg1287 g1287_1 g1287_0 gnd
C1  g1287_1 gnd 2.080806f
C2  g1287_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1287_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g1287_1 2.224404
.ends

.subckt netg4429 g4429_0 g4429_2 g4429_1 gnd
C1  g4429_0 gnd 2.080806f
C2  g4429_2 gnd 2.080806f
C3  g4429_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4429_0 1 2.224404
R2 1 g4429_1 2.224404
C5 2 gnd 2.080806f
R3 2 g4429_1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g4429_2 3 2.224404
.ends

.subckt netg1911 g1911_1 g1911_0 gnd
C1  g1911_1 gnd 2.080806f
C2  g1911_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1911_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1911_1 4 2.224404
.ends

.subckt netg1150 g1150_1 g1150_0 gnd
C1  g1150_1 gnd 2.080806f
C2  g1150_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1150_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1150_1 4 2.224404
.ends

.subckt netg2230 g2230_1 g2230_0 gnd
C1  g2230_1 gnd 2.080806f
C2  g2230_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2230_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g2230_1 2.224404
.ends

.subckt netg110 g110_0 g110_1 gnd
C1  g110_0 gnd 2.080806f
C2  g110_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g110_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g110_1 4 2.224404
.ends

.subckt netg6864 g6864_1 g6864_0 g6864_2 gnd
C1  g6864_1 gnd 2.080806f
C2  g6864_0 gnd 2.080806f
C3  g6864_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6864_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6864_2 2 2.224404
C6 3 gnd 2.080806f
R4 g6864_2 3 2.224404
R5 3 g6864_1 2.224404
.ends

.subckt netg5900 g5900_0 g5900_1 g5900_2 gnd
C1  g5900_0 gnd 2.080806f
C2  g5900_1 gnd 2.080806f
C3  g5900_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5900_0 2.224404
R2 1 g5900_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g5900_1 3 2.224404
.ends

.subckt netg1912 g1912_0 g1912_1 gnd
C1  g1912_0 gnd 2.080806f
C2  g1912_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1912_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1912_1 4 2.224404
.ends

.subckt netg2567 g2567_1 g2567_2 g2567_0 gnd
C1  g2567_1 gnd 2.080806f
C2  g2567_2 gnd 2.080806f
C3  g2567_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2567_0 1 2.224404
R2 g2567_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g2567_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g2567_2 3 2.224404
.ends

.subckt netg5572 g5572_2 g5572_1 gnd
C1  g5572_2 gnd 2.080806f
C2  g5572_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5572_1 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g5572_2 2.224404
.ends

.subckt netg6350 g6350_0 g6350_1 gnd
C1  g6350_0 gnd 2.080806f
C2  g6350_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6350_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g6350_1 4 2.224404
.ends

.subckt netg4193 g4193_2 g4193_1 g4193_0 gnd
C1  g4193_2 gnd 2.080806f
C2  g4193_1 gnd 2.080806f
C3  g4193_0 gnd 2.080806f
R1 g4193_0 g4193_2 2.224404
C4 1 gnd 2.080806f
R2 1 g4193_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 g4193_1 3 2.224404
.ends

.subckt netg4778 g4778_2 g4778_0 g4778_1 gnd
C1  g4778_2 gnd 2.080806f
C2  g4778_0 gnd 2.080806f
C3  g4778_1 gnd 2.080806f
R1 g4778_0 g4778_1 2.224404
C4 1 gnd 2.080806f
R2 g4778_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g4778_2 2.224404
.ends

.subckt netg1719 g1719_1 g1719_2 g1719_3 gnd
C1  g1719_1 gnd 2.080806f
C2  g1719_2 gnd 2.080806f
C3  g1719_3 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g1719_2 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1719_3 3 2.224404
R5 g1719_3 g1719_1 2.224404
.ends

.subckt netg7287 g7287_1 g7287_0 g7287_2 gnd
C1  g7287_1 gnd 2.080806f
C2  g7287_0 gnd 2.080806f
C3  g7287_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7287_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7287_1 2.224404
C6 3 gnd 2.080806f
R4 g7287_1 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g7287_2 2.224404
.ends

.subckt netg6407 g6407_1 g6407_0 gnd
C1  g6407_1 gnd 2.080806f
C2  g6407_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6407_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g6407_1 2.224404
.ends

.subckt netg3522 g3522_1 g3522_0 gnd
C1  g3522_1 gnd 2.080806f
C2  g3522_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3522_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 4 g3522_1 2.224404
.ends

.subckt netg5652 g5652_0 g5652_1 g5652_2 gnd
C1  g5652_0 gnd 2.080806f
C2  g5652_1 gnd 2.080806f
C3  g5652_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5652_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5652_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 g5652_2 2.224404
R5 g5652_1 3 2.224404
.ends

.subckt netg3490 g3490_1 g3490_0 gnd
C1  g3490_1 gnd 2.080806f
C2  g3490_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3490_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g3490_1 2.224404
.ends

.subckt netg5749 g5749_0 g5749_2 g5749_1 gnd
C1  g5749_0 gnd 2.080806f
C2  g5749_2 gnd 2.080806f
C3  g5749_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5749_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5749_1 2 2.224404
C6 3 gnd 2.080806f
R4 3 g5749_1 2.224404
R5 g5749_2 3 2.224404
.ends

.subckt netg2383 g2383_0 g2383_2 g2383_1 gnd
C1  g2383_0 gnd 2.080806f
C2  g2383_2 gnd 2.080806f
C3  g2383_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2383_0 2.224404
R2 1 g2383_1 2.224404
C5 2 gnd 2.080806f
R3 2 g2383_1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g2383_2 3 2.224404
.ends

.subckt netg5631 g5631_1 g5631_0 g5631_2 gnd
C1  g5631_1 gnd 2.080806f
C2  g5631_0 gnd 2.080806f
C3  g5631_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5631_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5631_1 2.224404
R5 g5631_1 g5631_2 2.224404
.ends

.subckt netg4078 g4078_0 g4078_3 g4078_2 g4078_1 gnd
C1  g4078_0 gnd 2.080806f
C2  g4078_3 gnd 2.080806f
C3  g4078_2 gnd 2.080806f
C4  g4078_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4078_0 1 2.224404
R2 1 g4078_2 2.224404
C6 2 gnd 2.080806f
R3 g4078_2 2 2.224404
R4 2 g4078_3 2.224404
R5 g4078_3 g4078_1 2.224404
.ends

.subckt netg7423 g7423_0 g7423_1 gnd
C1  g7423_0 gnd 2.080806f
C2  g7423_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7423_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g7423_1 4 2.224404
.ends

.subckt netg4196 g4196_1 g4196_2 gnd
C1  g4196_1 gnd 2.080806f
C2  g4196_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4196_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g4196_2 4 2.224404
.ends

.subckt netg3528 g3528_1 g3528_0 gnd
C1  g3528_1 gnd 2.080806f
C2  g3528_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3528_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 4 g3528_1 2.224404
.ends

.subckt netg5984 g5984_0 g5984_1 gnd
C1  g5984_0 gnd 2.080806f
C2  g5984_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5984_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g5984_1 4 2.224404
.ends

.subckt netg3210 g3210_1 g3210_2 gnd
C1  g3210_1 gnd 2.080806f
C2  g3210_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3210_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g3210_2 4 2.224404
.ends

.subckt netg5655 g5655_0 g5655_1 g5655_2 gnd
C1  g5655_0 gnd 2.080806f
C2  g5655_1 gnd 2.080806f
C3  g5655_2 gnd 2.080806f
R1 g5655_2 g5655_0 2.224404
C4 1 gnd 2.080806f
R2 g5655_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 g5655_1 3 2.224404
.ends

.subckt netg4074 g4074_3 g4074_1 g4074_2 g4074_0 gnd
C1  g4074_3 gnd 2.080806f
C2  g4074_1 gnd 2.080806f
C3  g4074_2 gnd 2.080806f
C4  g4074_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g4074_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4074_2 2 2.224404
C7 3 gnd 2.080806f
R4 1 3 2.224404
R5 3 g4074_3 2.224404
R6 g4074_1 g4074_3 2.224404
.ends

.subckt netg5202 g5202_1 g5202_0 g5202_2 gnd
C1  g5202_1 gnd 2.080806f
C2  g5202_0 gnd 2.080806f
C3  g5202_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5202_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g5202_2 3 2.224404
R5 g5202_1 g5202_2 2.224404
.ends

.subckt netg6442 g6442_1 g6442_2 g6442_0 gnd
C1  g6442_1 gnd 2.080806f
C2  g6442_2 gnd 2.080806f
C3  g6442_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6442_0 2.224404
R2 g6442_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g6442_2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g6442_1 3 2.224404
.ends

.subckt netg3291 g3291_2 g3291_0 g3291_1 gnd
C1  g3291_2 gnd 2.080806f
C2  g3291_0 gnd 2.080806f
C3  g3291_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3291_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3291_1 2 2.224404
C6 3 gnd 2.080806f
R4 g3291_1 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 g3291_2 4 2.224404
.ends

.subckt netg907 g907_2 g907_1 g907_0 gnd
C1  g907_2 gnd 2.080806f
C2  g907_1 gnd 2.080806f
C3  g907_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g907_0 2.224404
R2 g907_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g907_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 3 g907_2 2.224404
.ends

.subckt netg5637 g5637_0 g5637_2 g5637_1 gnd
C1  g5637_0 gnd 2.080806f
C2  g5637_2 gnd 2.080806f
C3  g5637_1 gnd 2.080806f
R1 g5637_0 g5637_2 2.224404
C4 1 gnd 2.080806f
R2 g5637_2 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5637_1 2.224404
.ends

.subckt netg4232 g4232_1 g4232_0 gnd
C1  g4232_1 gnd 2.080806f
C2  g4232_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4232_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g4232_1 2.224404
.ends

.subckt netx141 x141_0 x141_1 gnd
C1  x141_0 gnd 2.080806f
C2  x141_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x141_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 x141_1 4 2.224404
.ends

.subckt netg4449 g4449_1 g4449_0 gnd
C1  g4449_1 gnd 2.080806f
C2  g4449_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4449_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 4 g4449_1 2.224404
.ends

.subckt netg2671 g2671_1 g2671_0 g2671_2 gnd
C1  g2671_1 gnd 2.080806f
C2  g2671_0 gnd 2.080806f
C3  g2671_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2671_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2671_1 2.224404
C6 3 gnd 2.080806f
R4 3 g2671_1 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g2671_2 2.224404
.ends

.subckt netg2365 g2365_0 g2365_2 g2365_1 gnd
C1  g2365_0 gnd 2.080806f
C2  g2365_2 gnd 2.080806f
C3  g2365_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2365_0 2.224404
R2 1 g2365_1 2.224404
C5 2 gnd 2.080806f
R3 g2365_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g2365_2 2.224404
.ends

.subckt netg5610 g5610_0 g5610_2 g5610_1 gnd
C1  g5610_0 gnd 2.080806f
C2  g5610_2 gnd 2.080806f
C3  g5610_1 gnd 2.080806f
R1 g5610_1 g5610_0 2.224404
C4 1 gnd 2.080806f
R2 g5610_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5610_2 2.224404
.ends

.subckt netg5309 g5309_0 g5309_1 g5309_3 g5309_2 gnd
C1  g5309_0 gnd 2.080806f
C2  g5309_1 gnd 2.080806f
C3  g5309_3 gnd 2.080806f
C4  g5309_2 gnd 2.080806f
R1 g5309_3 g5309_0 2.224404
R2 g5309_2 g5309_3 2.224404
C5 1 gnd 2.080806f
R3 g5309_0 1 2.224404
C6 2 gnd 2.080806f
R4 2 1 2.224404
C7 3 gnd 2.080806f
R5 2 3 2.224404
R6 g5309_1 3 2.224404
.ends

.subckt netg413 g413_1 g413_2 g413_0 g413_3 g413_4 gnd
C1  g413_1 gnd 2.080806f
C2  g413_2 gnd 2.080806f
C3  g413_0 gnd 2.080806f
C4  g413_3 gnd 2.080806f
C5  g413_4 gnd 2.080806f
R1 g413_1 g413_0 2.224404
C6 1 gnd 2.080806f
R2 g413_0 1 2.224404
R3 1 g413_3 2.224404
C7 2 gnd 2.080806f
R4 2 g413_3 2.224404
R5 g413_4 2 2.224404
R6 g413_4 g413_2 2.224404
.ends

.subckt netg6880 g6880_1 g6880_0 gnd
C1  g6880_1 gnd 2.080806f
C2  g6880_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6880_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g6880_1 2.224404
.ends

.subckt netg3432 g3432_1 g3432_0 g3432_2 gnd
C1  g3432_1 gnd 2.080806f
C2  g3432_0 gnd 2.080806f
C3  g3432_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3432_0 1 2.224404
R2 g3432_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g3432_2 2.224404
.ends

.subckt netg4161 g4161_1 g4161_2 g4161_0 gnd
C1  g4161_1 gnd 2.080806f
C2  g4161_2 gnd 2.080806f
C3  g4161_0 gnd 2.080806f
R1 g4161_0 g4161_2 2.224404
C4 1 gnd 2.080806f
R2 1 g4161_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
R5 g4161_1 3 2.224404
.ends

.subckt netg3462 g3462_0 g3462_1 g3462_2 gnd
C1  g3462_0 gnd 2.080806f
C2  g3462_1 gnd 2.080806f
C3  g3462_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3462_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3462_1 2.224404
C6 3 gnd 2.080806f
R4 g3462_1 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g3462_2 2.224404
.ends

.subckt netg1575 g1575_1 g1575_0 gnd
C1  g1575_1 gnd 2.080806f
C2  g1575_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1575_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1575_1 4 2.224404
.ends

.subckt netg2088 g2088_0 g2088_1 gnd
C1  g2088_0 gnd 2.080806f
C2  g2088_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2088_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
R5 g2088_1 4 2.224404
.ends

.subckt netg6754 g6754_0 g6754_2 g6754_1 gnd
C1  g6754_0 gnd 2.080806f
C2  g6754_2 gnd 2.080806f
C3  g6754_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6754_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g6754_1 2.224404
C6 3 gnd 2.080806f
R4 g6754_1 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g6754_2 2.224404
.ends

.subckt netg1529 g1529_1 g1529_0 gnd
C1  g1529_1 gnd 2.080806f
C2  g1529_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1529_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1529_1 2.224404
.ends

.subckt netx502 x502_0 x502_1 gnd
C1  x502_0 gnd 2.080806f
C2  x502_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x502_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 x502_1 2.224404
.ends

.subckt netg4026 g4026_2 g4026_3 g4026_1 g4026_0 gnd
C1  g4026_2 gnd 2.080806f
C2  g4026_3 gnd 2.080806f
C3  g4026_1 gnd 2.080806f
C4  g4026_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4026_0 1 2.224404
R2 1 g4026_1 2.224404
R3 g4026_1 g4026_2 2.224404
C6 2 gnd 2.080806f
R4 2 g4026_2 2.224404
C7 3 gnd 2.080806f
R5 2 3 2.224404
C8 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g4026_3 2.224404
.ends

.subckt netg1532 g1532_1 g1532_0 gnd
C1  g1532_1 gnd 2.080806f
C2  g1532_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1532_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g1532_1 5 2.224404
.ends

.subckt netg1868 g1868_2 g1868_0 gnd
C1  g1868_2 gnd 2.080806f
C2  g1868_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1868_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1868_2 2.224404
.ends

.subckt netg7150 g7150_2 g7150_0 g7150_1 gnd
C1  g7150_2 gnd 2.080806f
C2  g7150_0 gnd 2.080806f
C3  g7150_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7150_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7150_2 2.224404
C6 3 gnd 2.080806f
R4 g7150_2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g7150_1 2.224404
.ends

.subckt netg4250 g4250_1 g4250_0 gnd
C1  g4250_1 gnd 2.080806f
C2  g4250_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4250_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g4250_1 2.224404
.ends

.subckt netg1762 g1762_2 g1762_1 g1762_0 gnd
C1  g1762_2 gnd 2.080806f
C2  g1762_1 gnd 2.080806f
C3  g1762_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1762_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1762_2 2.224404
C7 4 gnd 2.080806f
R5 g1762_2 4 2.224404
R6 g1762_1 4 2.224404
.ends

.subckt netg2239 g2239_1 g2239_0 gnd
C1  g2239_1 gnd 2.080806f
C2  g2239_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2239_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g2239_1 2.224404
.ends

.subckt netg3333 g3333_1 g3333_2 g3333_0 gnd
C1  g3333_1 gnd 2.080806f
C2  g3333_2 gnd 2.080806f
C3  g3333_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3333_0 2.224404
R2 1 g3333_1 2.224404
C5 2 gnd 2.080806f
R3 2 g3333_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g3333_2 4 2.224404
.ends

.subckt netg1364 g1364_1 g1364_0 gnd
C1  g1364_1 gnd 2.080806f
C2  g1364_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1364_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g1364_1 5 2.224404
.ends

.subckt netg6075 g6075_2 g6075_0 g6075_3 g6075_1 gnd
C1  g6075_2 gnd 2.080806f
C2  g6075_0 gnd 2.080806f
C3  g6075_3 gnd 2.080806f
C4  g6075_1 gnd 2.080806f
R1 g6075_1 g6075_0 2.224404
C5 1 gnd 2.080806f
R2 1 g6075_1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
R4 g6075_3 2 2.224404
C7 3 gnd 2.080806f
R5 3 g6075_3 2.224404
C8 4 gnd 2.080806f
R6 4 3 2.224404
R7 g6075_2 4 2.224404
.ends

.subckt netg1896 g1896_1 g1896_0 gnd
C1  g1896_1 gnd 2.080806f
C2  g1896_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1896_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g1896_1 5 2.224404
.ends

.subckt netg6882 g6882_0 g6882_1 gnd
C1  g6882_0 gnd 2.080806f
C2  g6882_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6882_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g6882_1 2.224404
.ends

.subckt netg500 g500_0 g500_1 gnd
C1  g500_0 gnd 2.080806f
C2  g500_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g500_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g500_1 2.224404
.ends

.subckt netg5806 g5806_1 g5806_2 g5806_0 gnd
C1  g5806_1 gnd 2.080806f
C2  g5806_2 gnd 2.080806f
C3  g5806_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5806_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5806_1 2 2.224404
C6 3 gnd 2.080806f
R4 3 g5806_1 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g5806_2 4 2.224404
.ends

.subckt netg2647 g2647_2 g2647_1 g2647_0 gnd
C1  g2647_2 gnd 2.080806f
C2  g2647_1 gnd 2.080806f
C3  g2647_0 gnd 2.080806f
R1 g2647_0 g2647_2 2.224404
C4 1 gnd 2.080806f
R2 1 g2647_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g2647_1 4 2.224404
.ends

.subckt netg6618 g6618_0 g6618_1 g6618_2 gnd
C1  g6618_0 gnd 2.080806f
C2  g6618_1 gnd 2.080806f
C3  g6618_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6618_0 1 2.224404
R2 1 g6618_1 2.224404
C5 2 gnd 2.080806f
R3 2 g6618_1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g6618_2 2.224404
.ends

.subckt netg6911 g6911_4 g6911_1 g6911_3 g6911_2 g6911_0 gnd
C1  g6911_4 gnd 2.080806f
C2  g6911_1 gnd 2.080806f
C3  g6911_3 gnd 2.080806f
C4  g6911_2 gnd 2.080806f
C5  g6911_0 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g6911_0 2.224404
R2 g6911_1 1 2.224404
C7 2 gnd 2.080806f
R3 2 g6911_0 2.224404
R4 g6911_4 2 2.224404
C8 3 gnd 2.080806f
R5 g6911_4 3 2.224404
C9 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g6911_3 2.224404
R8 g6911_3 g6911_2 2.224404
.ends

.subckt netg2935 g2935_0 g2935_1 gnd
C1  g2935_0 gnd 2.080806f
C2  g2935_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2935_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g2935_1 5 2.224404
.ends

.subckt netg4365 g4365_1 g4365_0 g4365_2 gnd
C1  g4365_1 gnd 2.080806f
C2  g4365_0 gnd 2.080806f
C3  g4365_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4365_0 2.224404
R2 g4365_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g4365_2 2.224404
.ends

.subckt netg5897 g5897_2 g5897_1 g5897_0 gnd
C1  g5897_2 gnd 2.080806f
C2  g5897_1 gnd 2.080806f
C3  g5897_0 gnd 2.080806f
R1 g5897_1 g5897_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5897_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g5897_2 4 2.224404
.ends

.subckt netg7222 g7222_2 g7222_1 g7222_0 gnd
C1  g7222_2 gnd 2.080806f
C2  g7222_1 gnd 2.080806f
C3  g7222_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7222_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
R5 4 g7222_2 2.224404
R6 g7222_1 g7222_2 2.224404
.ends

.subckt netg1496 g1496_1 g1496_0 gnd
C1  g1496_1 gnd 2.080806f
C2  g1496_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1496_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g1496_1 5 2.224404
.ends

.subckt netg7281 g7281_1 g7281_0 g7281_2 gnd
C1  g7281_1 gnd 2.080806f
C2  g7281_0 gnd 2.080806f
C3  g7281_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7281_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g7281_1 2.224404
C6 3 gnd 2.080806f
R4 g7281_1 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g7281_2 2.224404
.ends

.subckt netg2989 g2989_2 g2989_3 g2989_1 g2989_5 g2989_4 g2989_0 gnd
C1  g2989_2 gnd 2.080806f
C2  g2989_3 gnd 2.080806f
C3  g2989_1 gnd 2.080806f
C4  g2989_5 gnd 2.080806f
C5  g2989_4 gnd 2.080806f
C6  g2989_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g2989_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2989_2 2.224404
C9 3 gnd 2.080806f
R4 g2989_2 3 2.224404
R5 3 g2989_3 2.224404
R6 g2989_1 g2989_3 2.224404
R7 g2989_3 g2989_4 2.224404
C10 4 gnd 2.080806f
R8 4 g2989_1 2.224404
R9 4 g2989_5 2.224404
.ends

.subckt netg2081 g2081_0 g2081_3 g2081_2 g2081_1 g2081_5 g2081_6 g2081_4 gnd
C1  g2081_0 gnd 2.080806f
C2  g2081_3 gnd 2.080806f
C3  g2081_2 gnd 2.080806f
C4  g2081_1 gnd 2.080806f
C5  g2081_5 gnd 2.080806f
C6  g2081_6 gnd 2.080806f
C7  g2081_4 gnd 2.080806f
R1 g2081_5 g2081_0 2.224404
C8 1 gnd 2.080806f
R2 g2081_0 1 2.224404
R3 g2081_3 1 2.224404
R4 g2081_3 g2081_6 2.224404
R5 g2081_6 g2081_4 2.224404
C9 2 gnd 2.080806f
R6 2 g2081_0 2.224404
R7 g2081_2 2 2.224404
C10 3 gnd 2.080806f
R8 3 g2081_3 2.224404
R9 g2081_1 3 2.224404
.ends

.subckt netg7318 g7318_2 g7318_1 gnd
C1  g7318_2 gnd 2.080806f
C2  g7318_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7318_1 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g7318_2 5 2.224404
.ends

.subckt netg1506 g1506_0 g1506_1 gnd
C1  g1506_0 gnd 2.080806f
C2  g1506_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1506_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1506_1 2.224404
.ends

.subckt netg1590 g1590_1 g1590_0 gnd
C1  g1590_1 gnd 2.080806f
C2  g1590_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1590_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 5 g1590_1 2.224404
.ends

.subckt netg4767 g4767_2 g4767_0 g4767_1 g4767_3 gnd
C1  g4767_2 gnd 2.080806f
C2  g4767_0 gnd 2.080806f
C3  g4767_1 gnd 2.080806f
C4  g4767_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g4767_0 2.224404
R2 g4767_2 1 2.224404
C6 2 gnd 2.080806f
R3 2 g4767_2 2.224404
R4 g4767_1 2 2.224404
C7 3 gnd 2.080806f
R5 g4767_1 3 2.224404
R6 g4767_3 3 2.224404
.ends

.subckt netg4113 g4113_2 g4113_3 g4113_1 g4113_0 gnd
C1  g4113_2 gnd 2.080806f
C2  g4113_3 gnd 2.080806f
C3  g4113_1 gnd 2.080806f
C4  g4113_0 gnd 2.080806f
R1 g4113_1 g4113_0 2.224404
C5 1 gnd 2.080806f
R2 g4113_0 1 2.224404
R3 1 g4113_3 2.224404
C6 2 gnd 2.080806f
R4 2 g4113_3 2.224404
C7 3 gnd 2.080806f
R5 3 2 2.224404
C8 4 gnd 2.080806f
R6 3 4 2.224404
R7 g4113_2 4 2.224404
.ends

.subckt netg4392 g4392_2 g4392_0 g4392_1 gnd
C1  g4392_2 gnd 2.080806f
C2  g4392_0 gnd 2.080806f
C3  g4392_1 gnd 2.080806f
R1 g4392_1 g4392_0 2.224404
C4 1 gnd 2.080806f
R2 g4392_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g4392_2 2.224404
.ends

.subckt netg1399 g1399_0 g1399_1 gnd
C1  g1399_0 gnd 2.080806f
C2  g1399_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1399_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1399_1 2.224404
.ends

.subckt netg1910 g1910_0 g1910_1 gnd
C1  g1910_0 gnd 2.080806f
C2  g1910_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1910_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1910_1 2.224404
.ends

.subckt netx161 x161_0 x161_1 gnd
C1  x161_0 gnd 2.080806f
C2  x161_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x161_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 x161_1 2.224404
.ends

.subckt netg5820 g5820_2 g5820_1 g5820_0 g5820_3 gnd
C1  g5820_2 gnd 2.080806f
C2  g5820_1 gnd 2.080806f
C3  g5820_0 gnd 2.080806f
C4  g5820_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g5820_0 1 2.224404
R2 g5820_1 1 2.224404
C6 2 gnd 2.080806f
R3 2 g5820_0 2.224404
R4 g5820_3 2 2.224404
C7 3 gnd 2.080806f
R5 g5820_1 3 2.224404
R6 g5820_2 3 2.224404
.ends

.subckt netg1588 g1588_0 g1588_1 gnd
C1  g1588_0 gnd 2.080806f
C2  g1588_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1588_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g1588_1 5 2.224404
.ends

.subckt netg3961 g3961_3 g3961_2 g3961_0 g3961_1 gnd
C1  g3961_3 gnd 2.080806f
C2  g3961_2 gnd 2.080806f
C3  g3961_0 gnd 2.080806f
C4  g3961_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g3961_0 1 2.224404
R2 1 g3961_2 2.224404
C6 2 gnd 2.080806f
R3 g3961_2 2 2.224404
R4 2 g3961_3 2.224404
C7 3 gnd 2.080806f
R5 3 g3961_3 2.224404
R6 g3961_1 3 2.224404
.ends

.subckt netg2019 g2019_3 g2019_1 g2019_0 gnd
C1  g2019_3 gnd 2.080806f
C2  g2019_1 gnd 2.080806f
C3  g2019_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2019_0 1 2.224404
R2 1 g2019_3 2.224404
C5 2 gnd 2.080806f
R3 g2019_3 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g2019_1 2.224404
.ends

.subckt netg4210 g4210_2 g4210_0 gnd
C1  g4210_2 gnd 2.080806f
C2  g4210_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4210_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g4210_2 5 2.224404
.ends

.subckt netg3195 g3195_2 g3195_0 g3195_1 gnd
C1  g3195_2 gnd 2.080806f
C2  g3195_0 gnd 2.080806f
C3  g3195_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3195_0 2.224404
R2 g3195_2 1 2.224404
C5 2 gnd 2.080806f
R3 g3195_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g3195_1 2.224404
.ends

.subckt netg6475 g6475_1 g6475_2 gnd
C1  g6475_1 gnd 2.080806f
C2  g6475_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6475_2 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g6475_1 2.224404
.ends

.subckt netg6304 g6304_0 g6304_2 g6304_1 gnd
C1  g6304_0 gnd 2.080806f
C2  g6304_2 gnd 2.080806f
C3  g6304_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6304_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
R5 g6304_1 4 2.224404
R6 g6304_2 g6304_1 2.224404
.ends

.subckt netg3174 g3174_0 g3174_2 g3174_1 gnd
C1  g3174_0 gnd 2.080806f
C2  g3174_2 gnd 2.080806f
C3  g3174_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3174_0 2.224404
R2 g3174_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g3174_1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g3174_2 4 2.224404
.ends

.subckt netg109 g109_0 g109_1 gnd
C1  g109_0 gnd 2.080806f
C2  g109_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g109_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g109_1 5 2.224404
.ends

.subckt netg4653 g4653_3 g4653_2 g4653_1 g4653_0 gnd
C1  g4653_3 gnd 2.080806f
C2  g4653_2 gnd 2.080806f
C3  g4653_1 gnd 2.080806f
C4  g4653_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4653_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4653_3 2.224404
R4 g4653_3 g4653_2 2.224404
C7 3 gnd 2.080806f
R5 g4653_2 3 2.224404
R6 3 g4653_1 2.224404
.ends

.subckt netg6438 g6438_0 g6438_1 gnd
C1  g6438_0 gnd 2.080806f
C2  g6438_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6438_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g6438_1 2.224404
.ends

.subckt netg561 g561_4 g561_0 g561_3 g561_1 g561_2 gnd
C1  g561_4 gnd 2.080806f
C2  g561_0 gnd 2.080806f
C3  g561_3 gnd 2.080806f
C4  g561_1 gnd 2.080806f
C5  g561_2 gnd 2.080806f
R1 g561_3 g561_0 2.224404
R2 g561_2 g561_3 2.224404
C6 1 gnd 2.080806f
R3 g561_0 1 2.224404
C7 2 gnd 2.080806f
R4 1 2 2.224404
R5 2 g561_4 2.224404
R6 g561_4 g561_1 2.224404
.ends

.subckt netg4760 g4760_1 g4760_3 g4760_2 g4760_0 gnd
C1  g4760_1 gnd 2.080806f
C2  g4760_3 gnd 2.080806f
C3  g4760_2 gnd 2.080806f
C4  g4760_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4760_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 g4760_1 2 2.224404
R4 2 g4760_2 2.224404
C7 3 gnd 2.080806f
R5 3 g4760_1 2.224404
R6 g4760_3 3 2.224404
.ends

.subckt netg1400 g1400_1 g1400_0 gnd
C1  g1400_1 gnd 2.080806f
C2  g1400_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1400_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1400_1 2.224404
.ends

.subckt netg1559 g1559_5 g1559_4 g1559_2 g1559_0 g1559_1 g1559_3 gnd
C1  g1559_5 gnd 2.080806f
C2  g1559_4 gnd 2.080806f
C3  g1559_2 gnd 2.080806f
C4  g1559_0 gnd 2.080806f
C5  g1559_1 gnd 2.080806f
C6  g1559_3 gnd 2.080806f
R1 g1559_0 g1559_3 2.224404
R2 g1559_5 g1559_0 2.224404
C7 1 gnd 2.080806f
R3 g1559_0 1 2.224404
C8 2 gnd 2.080806f
R4 1 2 2.224404
R5 2 g1559_1 2.224404
R6 g1559_1 g1559_4 2.224404
C9 3 gnd 2.080806f
R7 3 g1559_4 2.224404
R8 3 g1559_2 2.224404
.ends

.subckt netx191 x191_1 x191_0 gnd
C1  x191_1 gnd 2.080806f
C2  x191_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x191_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 x191_1 5 2.224404
.ends

.subckt netx372 x372_0 x372_1 gnd
C1  x372_0 gnd 2.080806f
C2  x372_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x372_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 x372_1 5 2.224404
.ends

.subckt netg4456 g4456_4 g4456_6 g4456_5 g4456_2 g4456_1 g4456_3 g4456_0 gnd
C1  g4456_4 gnd 2.080806f
C2  g4456_6 gnd 2.080806f
C3  g4456_5 gnd 2.080806f
C4  g4456_2 gnd 2.080806f
C5  g4456_1 gnd 2.080806f
C6  g4456_3 gnd 2.080806f
C7  g4456_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g4456_0 2.224404
R2 g4456_1 1 2.224404
R3 g4456_6 1 2.224404
C9 2 gnd 2.080806f
R4 2 g4456_1 2.224404
C10 3 gnd 2.080806f
R5 3 2 2.224404
R6 g4456_3 3 2.224404
R7 g4456_2 g4456_3 2.224404
R8 g4456_2 g4456_4 2.224404
C11 4 gnd 2.080806f
R9 g4456_3 4 2.224404
R10 4 g4456_5 2.224404
.ends

.subckt netx431 x431_0 x431_1 gnd
C1  x431_0 gnd 2.080806f
C2  x431_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x431_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 x431_1 5 2.224404
.ends

.subckt netg3484 g3484_0 g3484_1 gnd
C1  g3484_0 gnd 2.080806f
C2  g3484_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3484_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g3484_1 5 2.224404
.ends

.subckt netg4630 g4630_0 g4630_3 g4630_1 g4630_4 g4630_2 gnd
C1  g4630_0 gnd 2.080806f
C2  g4630_3 gnd 2.080806f
C3  g4630_1 gnd 2.080806f
C4  g4630_4 gnd 2.080806f
C5  g4630_2 gnd 2.080806f
R1 g4630_0 g4630_3 2.224404
R2 g4630_2 g4630_3 2.224404
C6 1 gnd 2.080806f
R3 g4630_2 1 2.224404
C7 2 gnd 2.080806f
R4 1 2 2.224404
C8 3 gnd 2.080806f
R5 2 3 2.224404
R6 3 g4630_4 2.224404
R7 g4630_4 g4630_1 2.224404
.ends

.subckt netg1503 g1503_1 g1503_0 gnd
C1  g1503_1 gnd 2.080806f
C2  g1503_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1503_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g1503_1 5 2.224404
.ends

.subckt netg5939 g5939_1 g5939_2 g5939_0 gnd
C1  g5939_1 gnd 2.080806f
C2  g5939_2 gnd 2.080806f
C3  g5939_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5939_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5939_1 2.224404
C7 4 gnd 2.080806f
R5 4 2 2.224404
R6 g5939_2 4 2.224404
.ends

.subckt netg785 g785_6 g785_2 g785_3 g785_0 g785_5 g785_4 gnd
C1  g785_6 gnd 2.080806f
C2  g785_2 gnd 2.080806f
C3  g785_3 gnd 2.080806f
C4  g785_0 gnd 2.080806f
C5  g785_5 gnd 2.080806f
C6  g785_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g785_0 1 2.224404
R2 1 g785_5 2.224404
C8 2 gnd 2.080806f
R3 2 g785_0 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
R5 g785_4 3 2.224404
R6 g785_2 g785_4 2.224404
C10 4 gnd 2.080806f
R7 g785_4 4 2.224404
R8 4 g785_3 2.224404
R9 g785_6 g785_3 2.224404
.ends

.subckt netg5971 g5971_1 g5971_0 gnd
C1  g5971_1 gnd 2.080806f
C2  g5971_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5971_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g5971_1 2.224404
.ends

.subckt netg4146 g4146_0 g4146_1 g4146_2 gnd
C1  g4146_0 gnd 2.080806f
C2  g4146_1 gnd 2.080806f
C3  g4146_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4146_0 1 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 g4146_2 3 2.224404
C7 4 gnd 2.080806f
R5 4 g4146_2 2.224404
R6 g4146_1 4 2.224404
.ends

.subckt netg3144 g3144_2 g3144_1 g3144_0 gnd
C1  g3144_2 gnd 2.080806f
C2  g3144_1 gnd 2.080806f
C3  g3144_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3144_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3144_1 2 2.224404
C6 3 gnd 2.080806f
R4 g3144_0 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g3144_2 2.224404
.ends

.subckt netg1543 g1543_5 g1543_0 g1543_2 g1543_4 g1543_3 g1543_1 gnd
C1  g1543_5 gnd 2.080806f
C2  g1543_0 gnd 2.080806f
C3  g1543_2 gnd 2.080806f
C4  g1543_4 gnd 2.080806f
C5  g1543_3 gnd 2.080806f
C6  g1543_1 gnd 2.080806f
R1 g1543_0 g1543_5 2.224404
C7 1 gnd 2.080806f
R2 g1543_5 1 2.224404
R3 1 g1543_3 2.224404
R4 g1543_3 g1543_2 2.224404
C8 2 gnd 2.080806f
R5 g1543_5 2 2.224404
R6 2 g1543_4 2.224404
C9 3 gnd 2.080806f
R7 3 g1543_3 2.224404
R8 g1543_1 3 2.224404
.ends

.subckt netg1323 g1323_6 g1323_1 g1323_4 g1323_5 g1323_3 gnd
C1  g1323_6 gnd 2.080806f
C2  g1323_1 gnd 2.080806f
C3  g1323_4 gnd 2.080806f
C4  g1323_5 gnd 2.080806f
C5  g1323_3 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g1323_1 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1323_4 2.224404
R4 g1323_4 g1323_6 2.224404
R5 g1323_6 g1323_3 2.224404
R6 g1323_5 g1323_6 2.224404
.ends

.subckt netg7549 g7549_1 g7549_0 gnd
C1  g7549_1 gnd 2.080806f
C2  g7549_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7549_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g7549_1 2.224404
.ends

.subckt netg6840 g6840_2 g6840_0 g6840_1 gnd
C1  g6840_2 gnd 2.080806f
C2  g6840_0 gnd 2.080806f
C3  g6840_1 gnd 2.080806f
R1 g6840_0 g6840_1 2.224404
C4 1 gnd 2.080806f
R2 g6840_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g6840_2 2.224404
.ends

.subckt netg6284 g6284_1 g6284_0 g6284_2 gnd
C1  g6284_1 gnd 2.080806f
C2  g6284_0 gnd 2.080806f
C3  g6284_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6284_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g6284_1 2.224404
R6 g6284_1 g6284_2 2.224404
.ends

.subckt netg4383 g4383_2 g4383_1 g4383_0 gnd
C1  g4383_2 gnd 2.080806f
C2  g4383_1 gnd 2.080806f
C3  g4383_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4383_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g4383_2 2.224404
C7 4 gnd 2.080806f
R5 4 g4383_2 2.224404
R6 g4383_1 4 2.224404
.ends

.subckt netg5933 g5933_1 g5933_2 gnd
C1  g5933_1 gnd 2.080806f
C2  g5933_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5933_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g5933_1 5 2.224404
.ends

.subckt netg1537 g1537_1 g1537_4 g1537_2 g1537_5 g1537_3 g1537_0 gnd
C1  g1537_1 gnd 2.080806f
C2  g1537_4 gnd 2.080806f
C3  g1537_2 gnd 2.080806f
C4  g1537_5 gnd 2.080806f
C5  g1537_3 gnd 2.080806f
C6  g1537_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1537_0 1 2.224404
R2 1 g1537_3 2.224404
R3 g1537_3 g1537_4 2.224404
C8 2 gnd 2.080806f
R4 2 g1537_4 2.224404
R5 g1537_1 2 2.224404
R6 g1537_1 g1537_2 2.224404
C9 3 gnd 2.080806f
R7 3 g1537_1 2.224404
R8 g1537_5 3 2.224404
.ends

.subckt netg4750 g4750_2 g4750_0 g4750_1 gnd
C1  g4750_2 gnd 2.080806f
C2  g4750_0 gnd 2.080806f
C3  g4750_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4750_0 1 2.224404
R2 1 g4750_2 2.224404
C5 2 gnd 2.080806f
R3 2 g4750_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g4750_1 4 2.224404
.ends

.subckt netg7141 g7141_0 g7141_2 g7141_1 gnd
C1  g7141_0 gnd 2.080806f
C2  g7141_2 gnd 2.080806f
C3  g7141_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7141_0 2.224404
R2 g7141_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g7141_0 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g7141_1 2.224404
.ends

.subckt netg5122 g5122_2 g5122_1 g5122_0 gnd
C1  g5122_2 gnd 2.080806f
C2  g5122_1 gnd 2.080806f
C3  g5122_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5122_0 1 2.224404
R2 1 g5122_1 2.224404
C5 2 gnd 2.080806f
R3 2 g5122_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 g5122_2 4 2.224404
.ends

.subckt netg3201 g3201_2 g3201_0 g3201_1 gnd
C1  g3201_2 gnd 2.080806f
C2  g3201_0 gnd 2.080806f
C3  g3201_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3201_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g3201_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 g3201_1 2.224404
R6 g3201_2 4 2.224404
.ends

.subckt netg1493 g1493_0 g1493_1 gnd
C1  g1493_0 gnd 2.080806f
C2  g1493_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1493_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1493_1 2.224404
.ends

.subckt netg6322 g6322_3 g6322_1 g6322_0 g6322_2 gnd
C1  g6322_3 gnd 2.080806f
C2  g6322_1 gnd 2.080806f
C3  g6322_0 gnd 2.080806f
C4  g6322_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g6322_0 1 2.224404
R2 1 g6322_1 2.224404
R3 g6322_1 g6322_3 2.224404
C6 2 gnd 2.080806f
R4 g6322_1 2 2.224404
C7 3 gnd 2.080806f
R5 2 3 2.224404
R6 3 g6322_2 2.224404
.ends

.subckt netg5459 g5459_2 g5459_1 g5459_0 gnd
C1  g5459_2 gnd 2.080806f
C2  g5459_1 gnd 2.080806f
C3  g5459_0 gnd 2.080806f
R1 g5459_0 g5459_1 2.224404
C4 1 gnd 2.080806f
R2 g5459_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g5459_2 2.224404
.ends

.subckt netg5795 g5795_0 g5795_1 g5795_2 g5795_3 gnd
C1  g5795_0 gnd 2.080806f
C2  g5795_1 gnd 2.080806f
C3  g5795_2 gnd 2.080806f
C4  g5795_3 gnd 2.080806f
R1 g5795_2 g5795_0 2.224404
C5 1 gnd 2.080806f
R2 g5795_2 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g5795_3 2.224404
C7 3 gnd 2.080806f
R5 g5795_3 3 2.224404
R6 3 g5795_1 2.224404
.ends

.subckt netg6491 g6491_1 g6491_2 gnd
C1  g6491_1 gnd 2.080806f
C2  g6491_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6491_1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g6491_2 2.224404
.ends

.subckt netg3971 g3971_1 g3971_0 gnd
C1  g3971_1 gnd 2.080806f
C2  g3971_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3971_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g3971_1 5 2.224404
.ends

.subckt netg1153 g1153_1 g1153_0 gnd
C1  g1153_1 gnd 2.080806f
C2  g1153_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1153_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1153_1 2.224404
.ends

.subckt netg1499 g1499_0 g1499_1 gnd
C1  g1499_0 gnd 2.080806f
C2  g1499_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1499_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1499_1 2.224404
.ends

.subckt netg6919 g6919_0 g6919_1 gnd
C1  g6919_0 gnd 2.080806f
C2  g6919_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6919_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g6919_1 5 2.224404
.ends

.subckt netg2456 g2456_1 g2456_2 gnd
C1  g2456_1 gnd 2.080806f
C2  g2456_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2456_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g2456_1 2.224404
.ends

.subckt netg4949 g4949_3 g4949_0 g4949_1 g4949_2 gnd
C1  g4949_3 gnd 2.080806f
C2  g4949_0 gnd 2.080806f
C3  g4949_1 gnd 2.080806f
C4  g4949_2 gnd 2.080806f
R1 g4949_2 g4949_0 2.224404
C5 1 gnd 2.080806f
R2 g4949_0 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g4949_3 2.224404
C7 3 gnd 2.080806f
R5 g4949_3 3 2.224404
R6 3 g4949_1 2.224404
.ends

.subckt netg3153 g3153_0 g3153_2 gnd
C1  g3153_0 gnd 2.080806f
C2  g3153_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3153_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 g3153_2 5 2.224404
.ends

.subckt netg2585 g2585_1 g2585_0 g2585_2 gnd
C1  g2585_1 gnd 2.080806f
C2  g2585_0 gnd 2.080806f
C3  g2585_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2585_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2585_1 2.224404
C7 4 gnd 2.080806f
R5 g2585_1 4 2.224404
R6 4 g2585_2 2.224404
.ends

.subckt netg5177 g5177_1 g5177_0 gnd
C1  g5177_1 gnd 2.080806f
C2  g5177_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5177_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g5177_1 2.224404
.ends

.subckt netg3938 g3938_4 g3938_0 g3938_1 g3938_3 g3938_2 gnd
C1  g3938_4 gnd 2.080806f
C2  g3938_0 gnd 2.080806f
C3  g3938_1 gnd 2.080806f
C4  g3938_3 gnd 2.080806f
C5  g3938_2 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g3938_0 1 2.224404
R2 1 g3938_1 2.224404
R3 g3938_1 g3938_2 2.224404
C7 2 gnd 2.080806f
R4 2 g3938_1 2.224404
R5 g3938_4 2 2.224404
C8 3 gnd 2.080806f
R6 3 g3938_4 2.224404
R7 3 g3938_3 2.224404
.ends

.subckt netg1848 g1848_0 g1848_1 g1848_3 g1848_2 gnd
C1  g1848_0 gnd 2.080806f
C2  g1848_1 gnd 2.080806f
C3  g1848_3 gnd 2.080806f
C4  g1848_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1848_0 2.224404
R2 g1848_2 1 2.224404
C6 2 gnd 2.080806f
R3 2 g1848_2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g1848_1 2.224404
R6 g1848_3 3 2.224404
.ends

.subckt netg5217 g5217_2 g5217_0 gnd
C1  g5217_2 gnd 2.080806f
C2  g5217_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5217_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g5217_2 2.224404
.ends

.subckt netg2223 g2223_1 g2223_0 gnd
C1  g2223_1 gnd 2.080806f
C2  g2223_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2223_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g2223_1 2.224404
.ends

.subckt netg6628 g6628_1 g6628_2 g6628_0 gnd
C1  g6628_1 gnd 2.080806f
C2  g6628_2 gnd 2.080806f
C3  g6628_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6628_0 1 2.224404
R2 1 g6628_2 2.224404
C5 2 gnd 2.080806f
R3 g6628_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
R6 g6628_1 4 2.224404
.ends

.subckt netg4660 g4660_1 g4660_0 gnd
C1  g4660_1 gnd 2.080806f
C2  g4660_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4660_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g4660_1 2.224404
.ends

.subckt netg1961 g1961_3 g1961_1 g1961_0 g1961_2 gnd
C1  g1961_3 gnd 2.080806f
C2  g1961_1 gnd 2.080806f
C3  g1961_0 gnd 2.080806f
C4  g1961_2 gnd 2.080806f
R1 g1961_1 g1961_0 2.224404
C5 1 gnd 2.080806f
R2 1 g1961_1 2.224404
C6 2 gnd 2.080806f
R3 2 1 2.224404
R4 g1961_3 2 2.224404
C7 3 gnd 2.080806f
R5 3 g1961_3 2.224404
R6 g1961_2 3 2.224404
.ends

.subckt netg2004 g2004_1 g2004_3 g2004_0 g2004_2 gnd
C1  g2004_1 gnd 2.080806f
C2  g2004_3 gnd 2.080806f
C3  g2004_0 gnd 2.080806f
C4  g2004_2 gnd 2.080806f
R1 g2004_1 g2004_0 2.224404
R2 g2004_3 g2004_1 2.224404
C5 1 gnd 2.080806f
R3 1 g2004_3 2.224404
C6 2 gnd 2.080806f
R4 2 1 2.224404
C7 3 gnd 2.080806f
R5 3 2 2.224404
R6 g2004_2 3 2.224404
.ends

.subckt netg1423 g1423_1 g1423_0 g1423_4 g1423_3 g1423_2 gnd
C1  g1423_1 gnd 2.080806f
C2  g1423_0 gnd 2.080806f
C3  g1423_4 gnd 2.080806f
C4  g1423_3 gnd 2.080806f
C5  g1423_2 gnd 2.080806f
R1 g1423_2 g1423_0 2.224404
C6 1 gnd 2.080806f
R2 1 g1423_0 2.224404
R3 g1423_3 1 2.224404
C7 2 gnd 2.080806f
R4 2 g1423_2 2.224404
R5 g1423_4 2 2.224404
C8 3 gnd 2.080806f
R6 3 g1423_4 2.224404
C9 4 gnd 2.080806f
R7 4 3 2.224404
R8 g1423_1 4 2.224404
.ends

.subckt netg5388 g5388_2 g5388_1 g5388_0 gnd
C1  g5388_2 gnd 2.080806f
C2  g5388_1 gnd 2.080806f
C3  g5388_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5388_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g5388_2 2.224404
R6 g5388_2 g5388_1 2.224404
.ends

.subckt netg5974 g5974_0 g5974_1 g5974_2 gnd
C1  g5974_0 gnd 2.080806f
C2  g5974_1 gnd 2.080806f
C3  g5974_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5974_0 2.224404
R2 g5974_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g5974_2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g5974_1 4 2.224404
.ends

.subckt netx462 x462_0 x462_1 gnd
C1  x462_0 gnd 2.080806f
C2  x462_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x462_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
R6 x462_1 5 2.224404
.ends

.subckt netg780 g780_3 g780_1 g780_2 g780_0 g780_4 gnd
C1  g780_3 gnd 2.080806f
C2  g780_1 gnd 2.080806f
C3  g780_2 gnd 2.080806f
C4  g780_0 gnd 2.080806f
C5  g780_4 gnd 2.080806f
R1 g780_0 g780_3 2.224404
C6 1 gnd 2.080806f
R2 1 g780_3 2.224404
R3 1 g780_2 2.224404
C7 2 gnd 2.080806f
R4 2 1 2.224404
R5 g780_1 2 2.224404
C8 3 gnd 2.080806f
R6 3 g780_1 2.224404
R7 3 g780_4 2.224404
.ends

.subckt netg7048 g7048_2 g7048_1 g7048_0 gnd
C1  g7048_2 gnd 2.080806f
C2  g7048_1 gnd 2.080806f
C3  g7048_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7048_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
R5 g7048_1 4 2.224404
R6 4 g7048_2 2.224404
.ends

.subckt netg7030 g7030_1 g7030_2 gnd
C1  g7030_1 gnd 2.080806f
C2  g7030_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7030_1 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g7030_2 5 2.224404
.ends

.subckt netg6559 g6559_1 g6559_0 gnd
C1  g6559_1 gnd 2.080806f
C2  g6559_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6559_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g6559_1 5 2.224404
.ends

.subckt netg3698 g3698_3 g3698_0 g3698_2 g3698_1 gnd
C1  g3698_3 gnd 2.080806f
C2  g3698_0 gnd 2.080806f
C3  g3698_2 gnd 2.080806f
C4  g3698_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g3698_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3698_2 2 2.224404
C7 3 gnd 2.080806f
R4 g3698_2 3 2.224404
R5 3 g3698_3 2.224404
C8 4 gnd 2.080806f
R6 g3698_3 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g3698_1 2.224404
.ends

.subckt netg4960 g4960_3 g4960_0 g4960_2 g4960_1 gnd
C1  g4960_3 gnd 2.080806f
C2  g4960_0 gnd 2.080806f
C3  g4960_2 gnd 2.080806f
C4  g4960_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4960_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g4960_3 2.224404
R5 g4960_3 g4960_1 2.224404
R6 g4960_1 g4960_2 2.224404
.ends

.subckt netg4775 g4775_1 g4775_0 g4775_2 gnd
C1  g4775_1 gnd 2.080806f
C2  g4775_0 gnd 2.080806f
C3  g4775_2 gnd 2.080806f
R1 g4775_0 g4775_1 2.224404
C4 1 gnd 2.080806f
R2 1 g4775_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
R6 g4775_2 4 2.224404
.ends

.subckt netg7378 g7378_1 g7378_0 g7378_2 gnd
C1  g7378_1 gnd 2.080806f
C2  g7378_0 gnd 2.080806f
C3  g7378_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7378_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g7378_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 g7378_1 2.224404
R6 g7378_2 4 2.224404
.ends

.subckt netg4006 g4006_1 g4006_0 gnd
C1  g4006_1 gnd 2.080806f
C2  g4006_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4006_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 g4006_1 5 2.224404
.ends

.subckt netg1206 g1206_2 g1206_4 g1206_3 g1206_1 g1206_0 g1206_5 gnd
C1  g1206_2 gnd 2.080806f
C2  g1206_4 gnd 2.080806f
C3  g1206_3 gnd 2.080806f
C4  g1206_1 gnd 2.080806f
C5  g1206_0 gnd 2.080806f
C6  g1206_5 gnd 2.080806f
R1 g1206_0 g1206_3 2.224404
R2 g1206_3 g1206_5 2.224404
R3 g1206_5 g1206_1 2.224404
C7 1 gnd 2.080806f
R4 g1206_1 1 2.224404
R5 1 g1206_4 2.224404
R6 g1206_4 g1206_2 2.224404
.ends

.subckt netx31 x31_1 x31_0 gnd
C1  x31_1 gnd 2.080806f
C2  x31_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x31_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 x31_1 2.224404
.ends

.subckt netg4386 g4386_2 g4386_0 g4386_1 gnd
C1  g4386_2 gnd 2.080806f
C2  g4386_0 gnd 2.080806f
C3  g4386_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4386_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g4386_1 2.224404
C8 5 gnd 2.080806f
R6 5 3 2.224404
R7 g4386_2 5 2.224404
.ends

.subckt netg7420 g7420_0 g7420_1 gnd
C1  g7420_0 gnd 2.080806f
C2  g7420_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7420_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g7420_1 2.224404
.ends

.subckt netg3999 g3999_3 g3999_1 g3999_2 g3999_0 gnd
C1  g3999_3 gnd 2.080806f
C2  g3999_1 gnd 2.080806f
C3  g3999_2 gnd 2.080806f
C4  g3999_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g3999_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3999_1 2.224404
C7 3 gnd 2.080806f
R4 g3999_0 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g3999_2 2.224404
R8 5 g3999_3 2.224404
.ends

.subckt netg5713 g5713_1 g5713_0 g5713_2 gnd
C1  g5713_1 gnd 2.080806f
C2  g5713_0 gnd 2.080806f
C3  g5713_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5713_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5713_1 2 2.224404
C6 3 gnd 2.080806f
R4 g5713_0 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g5713_2 2.224404
.ends

.subckt netg1289 g1289_3 g1289_2 g1289_5 g1289_1 g1289_4 gnd
C1  g1289_3 gnd 2.080806f
C2  g1289_2 gnd 2.080806f
C3  g1289_5 gnd 2.080806f
C4  g1289_1 gnd 2.080806f
C5  g1289_4 gnd 2.080806f
R1 g1289_3 g1289_2 2.224404
R2 g1289_1 g1289_2 2.224404
C6 1 gnd 2.080806f
R3 1 g1289_3 2.224404
C7 2 gnd 2.080806f
R4 2 1 2.224404
R5 g1289_5 2 2.224404
C8 3 gnd 2.080806f
R6 3 g1289_5 2.224404
C9 4 gnd 2.080806f
R7 4 3 2.224404
R8 g1289_4 4 2.224404
.ends

.subckt netg7315 g7315_2 g7315_0 gnd
C1  g7315_2 gnd 2.080806f
C2  g7315_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7315_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
R7 g7315_2 6 2.224404
.ends

.subckt netg95 g95_1 g95_0 gnd
C1  g95_1 gnd 2.080806f
C2  g95_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g95_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
R7 g95_1 6 2.224404
.ends

.subckt netg6263 g6263_0 g6263_2 g6263_1 gnd
C1  g6263_0 gnd 2.080806f
C2  g6263_2 gnd 2.080806f
C3  g6263_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6263_0 2.224404
R2 g6263_2 1 2.224404
C5 2 gnd 2.080806f
R3 g6263_0 2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 g6263_1 6 2.224404
.ends

.subckt netg5680 g5680_2 g5680_1 g5680_0 gnd
C1  g5680_2 gnd 2.080806f
C2  g5680_1 gnd 2.080806f
C3  g5680_0 gnd 2.080806f
R1 g5680_1 g5680_0 2.224404
C4 1 gnd 2.080806f
R2 g5680_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g5680_2 2.224404
.ends

.subckt netg3330 g3330_2 g3330_0 g3330_1 gnd
C1  g3330_2 gnd 2.080806f
C2  g3330_0 gnd 2.080806f
C3  g3330_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3330_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 g3330_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 2 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 g3330_2 5 2.224404
.ends

.subckt netg1716 g1716_2 g1716_0 g1716_1 gnd
C1  g1716_2 gnd 2.080806f
C2  g1716_0 gnd 2.080806f
C3  g1716_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g1716_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1716_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 g1716_2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 g1716_1 5 2.224404
.ends

.subckt netg6881 g6881_0 g6881_1 gnd
C1  g6881_0 gnd 2.080806f
C2  g6881_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6881_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g6881_1 2.224404
.ends

.subckt netg3491 g3491_0 g3491_1 gnd
C1  g3491_0 gnd 2.080806f
C2  g3491_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3491_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g3491_1 2.224404
.ends

.subckt netg3053 g3053_1 g3053_0 gnd
C1  g3053_1 gnd 2.080806f
C2  g3053_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3053_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g3053_1 2.224404
.ends

.subckt netg3705 g3705_2 g3705_0 g3705_3 g3705_1 gnd
C1  g3705_2 gnd 2.080806f
C2  g3705_0 gnd 2.080806f
C3  g3705_3 gnd 2.080806f
C4  g3705_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g3705_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3705_3 2.224404
C7 3 gnd 2.080806f
R4 g3705_3 3 2.224404
R5 3 g3705_1 2.224404
C8 4 gnd 2.080806f
R6 g3705_1 4 2.224404
R7 4 g3705_2 2.224404
.ends

.subckt netg4635 g4635_3 g4635_0 g4635_2 g4635_1 gnd
C1  g4635_3 gnd 2.080806f
C2  g4635_0 gnd 2.080806f
C3  g4635_2 gnd 2.080806f
C4  g4635_1 gnd 2.080806f
R1 g4635_0 g4635_2 2.224404
R2 g4635_1 g4635_2 2.224404
C5 1 gnd 2.080806f
R3 g4635_2 1 2.224404
C6 2 gnd 2.080806f
R4 1 2 2.224404
C7 3 gnd 2.080806f
R5 2 3 2.224404
C8 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g4635_3 2.224404
.ends

.subckt netg2525 g2525_1 g2525_2 g2525_0 gnd
C1  g2525_1 gnd 2.080806f
C2  g2525_2 gnd 2.080806f
C3  g2525_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2525_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2525_2 2.224404
C7 4 gnd 2.080806f
R5 4 1 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 g2525_1 6 2.224404
.ends

.subckt netg115 g115_1 g115_0 gnd
C1  g115_1 gnd 2.080806f
C2  g115_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g115_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
R7 g115_1 6 2.224404
.ends

.subckt netg1246 g1246_1 g1246_3 g1246_2 g1246_0 gnd
C1  g1246_1 gnd 2.080806f
C2  g1246_3 gnd 2.080806f
C3  g1246_2 gnd 2.080806f
C4  g1246_0 gnd 2.080806f
R1 g1246_2 g1246_0 2.224404
R2 g1246_3 g1246_2 2.224404
C5 1 gnd 2.080806f
R3 1 g1246_3 2.224404
C6 2 gnd 2.080806f
R4 2 1 2.224404
C7 3 gnd 2.080806f
R5 3 2 2.224404
C8 4 gnd 2.080806f
R6 3 4 2.224404
R7 g1246_1 4 2.224404
.ends

.subckt netg3637 g3637_5 g3637_1 g3637_6 g3637_4 g3637_0 g3637_3 g3637_2 gnd
C1  g3637_5 gnd 2.080806f
C2  g3637_1 gnd 2.080806f
C3  g3637_6 gnd 2.080806f
C4  g3637_4 gnd 2.080806f
C5  g3637_0 gnd 2.080806f
C6  g3637_3 gnd 2.080806f
C7  g3637_2 gnd 2.080806f
R1 g3637_0 g3637_6 2.224404
R2 g3637_6 g3637_2 2.224404
C8 1 gnd 2.080806f
R3 g3637_2 1 2.224404
R4 1 g3637_5 2.224404
R5 g3637_1 g3637_5 2.224404
R6 g3637_5 g3637_3 2.224404
C9 2 gnd 2.080806f
R7 g3637_1 2 2.224404
R8 2 g3637_4 2.224404
.ends

.subckt netg6760 g6760_4 g6760_3 g6760_2 g6760_1 g6760_0 gnd
C1  g6760_4 gnd 2.080806f
C2  g6760_3 gnd 2.080806f
C3  g6760_2 gnd 2.080806f
C4  g6760_1 gnd 2.080806f
C5  g6760_0 gnd 2.080806f
R1 g6760_2 g6760_0 2.224404
C6 1 gnd 2.080806f
R2 g6760_0 1 2.224404
C7 2 gnd 2.080806f
R3 1 2 2.224404
C8 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g6760_1 2.224404
C9 4 gnd 2.080806f
R6 4 g6760_1 2.224404
R7 4 g6760_4 2.224404
R8 g6760_4 g6760_3 2.224404
.ends

.subckt netg5404 g5404_0 g5404_1 g5404_2 gnd
C1  g5404_0 gnd 2.080806f
C2  g5404_1 gnd 2.080806f
C3  g5404_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5404_0 2.224404
R2 1 g5404_1 2.224404
C5 2 gnd 2.080806f
R3 2 g5404_1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 5 g5404_2 2.224404
.ends

.subckt netg792 g792_1 g792_0 g792_3 g792_2 gnd
C1  g792_1 gnd 2.080806f
C2  g792_0 gnd 2.080806f
C3  g792_3 gnd 2.080806f
C4  g792_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g792_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
R3 g792_2 2 2.224404
C7 3 gnd 2.080806f
R4 3 g792_2 2.224404
R5 g792_3 3 2.224404
C8 4 gnd 2.080806f
R6 4 2 2.224404
R7 g792_1 4 2.224404
.ends

.subckt netg6176 g6176_3 g6176_2 g6176_1 g6176_0 gnd
C1  g6176_3 gnd 2.080806f
C2  g6176_2 gnd 2.080806f
C3  g6176_1 gnd 2.080806f
C4  g6176_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g6176_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g6176_1 2.224404
C9 5 gnd 2.080806f
R6 g6176_1 5 2.224404
R7 5 g6176_3 2.224404
R8 g6176_2 g6176_3 2.224404
.ends

.subckt netg6710 g6710_1 g6710_0 gnd
C1  g6710_1 gnd 2.080806f
C2  g6710_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6710_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 g6710_1 6 2.224404
.ends

.subckt netg4920 g4920_5 g4920_0 g4920_4 g4920_1 g4920_2 g4920_3 gnd
C1  g4920_5 gnd 2.080806f
C2  g4920_0 gnd 2.080806f
C3  g4920_4 gnd 2.080806f
C4  g4920_1 gnd 2.080806f
C5  g4920_2 gnd 2.080806f
C6  g4920_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g4920_0 2.224404
R2 g4920_3 1 2.224404
C8 2 gnd 2.080806f
R3 2 g4920_0 2.224404
R4 g4920_5 2 2.224404
C9 3 gnd 2.080806f
R5 3 g4920_3 2.224404
R6 g4920_4 3 2.224404
C10 4 gnd 2.080806f
R7 4 g4920_5 2.224404
R8 g4920_2 4 2.224404
C11 5 gnd 2.080806f
R9 5 g4920_4 2.224404
C12 6 gnd 2.080806f
R10 6 5 2.224404
R11 g4920_1 6 2.224404
.ends

.subckt netg3132 g3132_2 g3132_0 g3132_1 gnd
C1  g3132_2 gnd 2.080806f
C2  g3132_0 gnd 2.080806f
C3  g3132_1 gnd 2.080806f
R1 g3132_0 g3132_1 2.224404
C4 1 gnd 2.080806f
R2 1 g3132_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 5 g3132_2 2.224404
.ends

.subckt netg2870 g2870_3 g2870_0 g2870_1 gnd
C1  g2870_3 gnd 2.080806f
C2  g2870_0 gnd 2.080806f
C3  g2870_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2870_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
R5 g2870_1 4 2.224404
C8 5 gnd 2.080806f
R6 5 g2870_1 2.224404
R7 g2870_3 5 2.224404
.ends

.subckt netg691 g691_2 g691_0 g691_1 gnd
C1  g691_2 gnd 2.080806f
C2  g691_0 gnd 2.080806f
C3  g691_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g691_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g691_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 1 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 g691_1 5 2.224404
.ends

.subckt netg5211 g5211_2 g5211_1 g5211_0 gnd
C1  g5211_2 gnd 2.080806f
C2  g5211_1 gnd 2.080806f
C3  g5211_0 gnd 2.080806f
R1 g5211_0 g5211_2 2.224404
C4 1 gnd 2.080806f
R2 g5211_0 1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
R7 g5211_1 5 2.224404
.ends

.subckt netg6957 g6957_1 g6957_2 g6957_0 gnd
C1  g6957_1 gnd 2.080806f
C2  g6957_2 gnd 2.080806f
C3  g6957_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6957_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g6957_2 2.224404
C7 4 gnd 2.080806f
R5 4 g6957_2 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 5 g6957_1 2.224404
.ends

.subckt netg1316 g1316_3 g1316_2 g1316_6 g1316_1 g1316_5 g1316_4 gnd
C1  g1316_3 gnd 2.080806f
C2  g1316_2 gnd 2.080806f
C3  g1316_6 gnd 2.080806f
C4  g1316_1 gnd 2.080806f
C5  g1316_5 gnd 2.080806f
C6  g1316_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1316_2 1 2.224404
R2 1 g1316_6 2.224404
C8 2 gnd 2.080806f
R3 g1316_2 2 2.224404
R4 g1316_5 2 2.224404
C9 3 gnd 2.080806f
R5 g1316_6 3 2.224404
C10 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g1316_4 2.224404
R8 g1316_1 g1316_4 2.224404
C11 5 gnd 2.080806f
R9 g1316_5 5 2.224404
C12 6 gnd 2.080806f
R10 5 6 2.224404
R11 g1316_3 6 2.224404
.ends

.subckt netg5948 g5948_0 g5948_1 g5948_2 gnd
C1  g5948_0 gnd 2.080806f
C2  g5948_1 gnd 2.080806f
C3  g5948_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5948_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
R6 5 g5948_2 2.224404
R7 g5948_2 g5948_1 2.224404
.ends

.subckt netg2062 g2062_0 g2062_3 g2062_2 g2062_7 g2062_5 g2062_4 g2062_1 gnd
C1  g2062_0 gnd 2.080806f
C2  g2062_3 gnd 2.080806f
C3  g2062_2 gnd 2.080806f
C4  g2062_7 gnd 2.080806f
C5  g2062_5 gnd 2.080806f
C6  g2062_4 gnd 2.080806f
C7  g2062_1 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g2062_0 1 2.224404
R2 1 g2062_1 2.224404
R3 g2062_4 g2062_1 2.224404
R4 g2062_7 g2062_4 2.224404
R5 g2062_3 g2062_7 2.224404
R6 g2062_5 g2062_3 2.224404
R7 g2062_2 g2062_5 2.224404
.ends

.subckt netg6294 g6294_1 g6294_2 g6294_0 gnd
C1  g6294_1 gnd 2.080806f
C2  g6294_2 gnd 2.080806f
C3  g6294_0 gnd 2.080806f
R1 g6294_2 g6294_0 2.224404
C4 1 gnd 2.080806f
R2 1 g6294_0 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
R7 g6294_1 5 2.224404
.ends

.subckt netg5628 g5628_1 g5628_2 g5628_0 gnd
C1  g5628_1 gnd 2.080806f
C2  g5628_2 gnd 2.080806f
C3  g5628_0 gnd 2.080806f
R1 g5628_2 g5628_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5628_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 g5628_1 5 2.224404
.ends

.subckt netg6372 g6372_1 g6372_0 gnd
C1  g6372_1 gnd 2.080806f
C2  g6372_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6372_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g6372_1 2.224404
.ends

.subckt netg7057 g7057_0 g7057_1 g7057_2 gnd
C1  g7057_0 gnd 2.080806f
C2  g7057_1 gnd 2.080806f
C3  g7057_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7057_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g7057_1 2.224404
C7 4 gnd 2.080806f
R5 4 g7057_0 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
R8 6 g7057_2 2.224404
.ends

.subckt netg3252 g3252_1 g3252_2 g3252_0 gnd
C1  g3252_1 gnd 2.080806f
C2  g3252_2 gnd 2.080806f
C3  g3252_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3252_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g3252_1 2.224404
R7 g3252_2 5 2.224404
.ends

.subckt netg796 g796_2 g796_1 g796_0 gnd
C1  g796_2 gnd 2.080806f
C2  g796_1 gnd 2.080806f
C3  g796_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g796_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g796_2 2.224404
C8 5 gnd 2.080806f
R6 g796_2 5 2.224404
R7 5 g796_1 2.224404
.ends

.subckt netg4648 g4648_1 g4648_3 g4648_0 g4648_4 g4648_2 gnd
C1  g4648_1 gnd 2.080806f
C2  g4648_3 gnd 2.080806f
C3  g4648_0 gnd 2.080806f
C4  g4648_4 gnd 2.080806f
C5  g4648_2 gnd 2.080806f
R1 g4648_2 g4648_0 2.224404
R2 g4648_3 g4648_0 2.224404
C6 1 gnd 2.080806f
R3 g4648_0 1 2.224404
R4 1 g4648_4 2.224404
C7 2 gnd 2.080806f
R5 g4648_4 2 2.224404
C8 3 gnd 2.080806f
R6 2 3 2.224404
R7 3 g4648_1 2.224404
.ends

.subckt netg5752 g5752_0 g5752_2 g5752_1 gnd
C1  g5752_0 gnd 2.080806f
C2  g5752_2 gnd 2.080806f
C3  g5752_1 gnd 2.080806f
R1 g5752_2 g5752_0 2.224404
C4 1 gnd 2.080806f
R2 g5752_2 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
R7 g5752_1 5 2.224404
.ends

.subckt netg4642 g4642_2 g4642_1 g4642_5 g4642_3 g4642_0 g4642_4 gnd
C1  g4642_2 gnd 2.080806f
C2  g4642_1 gnd 2.080806f
C3  g4642_5 gnd 2.080806f
C4  g4642_3 gnd 2.080806f
C5  g4642_0 gnd 2.080806f
C6  g4642_4 gnd 2.080806f
R1 g4642_3 g4642_0 2.224404
C7 1 gnd 2.080806f
R2 g4642_0 1 2.224404
R3 1 g4642_4 2.224404
C8 2 gnd 2.080806f
R4 2 g4642_3 2.224404
R5 g4642_2 2 2.224404
C9 3 gnd 2.080806f
R6 g4642_4 3 2.224404
R7 3 g4642_1 2.224404
R8 g4642_5 3 2.224404
.ends

.subckt netg113 g113_0 g113_1 gnd
C1  g113_0 gnd 2.080806f
C2  g113_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g113_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g113_1 2.224404
.ends

.subckt netg2235 g2235_3 g2235_1 g2235_2 g2235_0 gnd
C1  g2235_3 gnd 2.080806f
C2  g2235_1 gnd 2.080806f
C3  g2235_2 gnd 2.080806f
C4  g2235_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2235_0 2.224404
R2 1 g2235_3 2.224404
C6 2 gnd 2.080806f
R3 g2235_3 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g2235_1 2.224404
C8 4 gnd 2.080806f
R6 g2235_1 4 2.224404
R7 4 g2235_2 2.224404
.ends

.subckt netg5783 g5783_0 g5783_1 gnd
C1  g5783_0 gnd 2.080806f
C2  g5783_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5783_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g5783_1 2.224404
.ends

.subckt netg816 g816_4 g816_0 g816_3 gnd
C1  g816_4 gnd 2.080806f
C2  g816_0 gnd 2.080806f
C3  g816_3 gnd 2.080806f
R1 g816_0 g816_3 2.224404
C4 1 gnd 2.080806f
R2 1 g816_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 g816_4 5 2.224404
.ends

.subckt netg3013 g3013_1 g3013_4 g3013_2 g3013_0 g3013_5 g3013_3 gnd
C1  g3013_1 gnd 2.080806f
C2  g3013_4 gnd 2.080806f
C3  g3013_2 gnd 2.080806f
C4  g3013_0 gnd 2.080806f
C5  g3013_5 gnd 2.080806f
C6  g3013_3 gnd 2.080806f
R1 g3013_4 g3013_0 2.224404
C7 1 gnd 2.080806f
R2 g3013_0 1 2.224404
R3 1 g3013_3 2.224404
C8 2 gnd 2.080806f
R4 2 g3013_4 2.224404
R5 g3013_1 2 2.224404
C9 3 gnd 2.080806f
R6 3 g3013_1 2.224404
R7 g3013_2 3 2.224404
C10 4 gnd 2.080806f
R8 g3013_1 4 2.224404
R9 4 g3013_5 2.224404
.ends

.subckt netg7284 g7284_2 g7284_1 gnd
C1  g7284_2 gnd 2.080806f
C2  g7284_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7284_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 g7284_2 6 2.224404
.ends

.subckt netg6859 g6859_0 g6859_2 g6859_1 gnd
C1  g6859_0 gnd 2.080806f
C2  g6859_2 gnd 2.080806f
C3  g6859_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6859_0 2.224404
R2 g6859_1 1 2.224404
C5 2 gnd 2.080806f
R3 g6859_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g6859_2 2.224404
.ends

.subckt netg1576 g1576_1 g1576_0 gnd
C1  g1576_1 gnd 2.080806f
C2  g1576_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1576_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
R7 g1576_1 6 2.224404
.ends

.subckt netg4884 g4884_2 g4884_0 gnd
C1  g4884_2 gnd 2.080806f
C2  g4884_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4884_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g4884_2 2.224404
.ends

.subckt netg3988 g3988_2 g3988_4 g3988_3 g3988_1 g3988_5 g3988_0 gnd
C1  g3988_2 gnd 2.080806f
C2  g3988_4 gnd 2.080806f
C3  g3988_3 gnd 2.080806f
C4  g3988_1 gnd 2.080806f
C5  g3988_5 gnd 2.080806f
C6  g3988_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g3988_0 2.224404
R2 1 g3988_3 2.224404
C8 2 gnd 2.080806f
R3 g3988_0 2 2.224404
R4 2 g3988_5 2.224404
C9 3 gnd 2.080806f
R5 3 g3988_3 2.224404
R6 g3988_4 3 2.224404
R7 g3988_1 g3988_4 2.224404
C10 4 gnd 2.080806f
R8 4 1 2.224404
R9 g3988_2 4 2.224404
.ends

.subckt netg2896 g2896_1 g2896_0 gnd
C1  g2896_1 gnd 2.080806f
C2  g2896_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2896_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
R7 g2896_1 6 2.224404
.ends

.subckt netg2977 g2977_0 g2977_1 g2977_2 gnd
C1  g2977_0 gnd 2.080806f
C2  g2977_1 gnd 2.080806f
C3  g2977_2 gnd 2.080806f
R1 g2977_2 g2977_0 2.224404
C4 1 gnd 2.080806f
R2 g2977_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
R7 g2977_1 5 2.224404
.ends

.subckt netg3683 g3683_1 g3683_0 g3683_3 gnd
C1  g3683_1 gnd 2.080806f
C2  g3683_0 gnd 2.080806f
C3  g3683_3 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3683_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g3683_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 g3683_1 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
R7 g3683_3 5 2.224404
.ends

.subckt netg4233 g4233_1 g4233_0 gnd
C1  g4233_1 gnd 2.080806f
C2  g4233_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4233_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
R7 g4233_1 6 2.224404
.ends

.subckt netg4771 g4771_3 g4771_2 g4771_1 g4771_0 gnd
C1  g4771_3 gnd 2.080806f
C2  g4771_2 gnd 2.080806f
C3  g4771_1 gnd 2.080806f
C4  g4771_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g4771_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g4771_1 2.224404
C8 4 gnd 2.080806f
R5 g4771_1 4 2.224404
R6 4 g4771_3 2.224404
R7 g4771_3 g4771_2 2.224404
.ends

.subckt netg1363 g1363_0 g1363_1 gnd
C1  g1363_0 gnd 2.080806f
C2  g1363_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1363_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
R7 g1363_1 6 2.224404
.ends

.subckt netg116 g116_1 g116_0 gnd
C1  g116_1 gnd 2.080806f
C2  g116_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g116_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g116_1 7 2.224404
.ends

.subckt netg1909 g1909_1 g1909_0 gnd
C1  g1909_1 gnd 2.080806f
C2  g1909_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1909_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g1909_1 7 2.224404
.ends

.subckt netg1397 g1397_1 g1397_0 gnd
C1  g1397_1 gnd 2.080806f
C2  g1397_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1397_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g1397_1 2.224404
.ends

.subckt netg1914 g1914_0 g1914_1 gnd
C1  g1914_0 gnd 2.080806f
C2  g1914_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1914_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g1914_1 7 2.224404
.ends

.subckt netg1880 g1880_1 g1880_0 g1880_2 gnd
C1  g1880_1 gnd 2.080806f
C2  g1880_0 gnd 2.080806f
C3  g1880_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1880_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1880_1 2.224404
C7 4 gnd 2.080806f
R5 g1880_1 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g1880_2 2.224404
.ends

.subckt netg5197 g5197_2 g5197_1 gnd
C1  g5197_2 gnd 2.080806f
C2  g5197_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5197_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g5197_2 2.224404
.ends

.subckt netg6045 g6045_0 g6045_1 gnd
C1  g6045_0 gnd 2.080806f
C2  g6045_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6045_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g6045_1 2.224404
.ends

.subckt netg5496 g5496_2 g5496_0 g5496_1 gnd
C1  g5496_2 gnd 2.080806f
C2  g5496_0 gnd 2.080806f
C3  g5496_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5496_0 2.224404
R2 g5496_2 1 2.224404
C5 2 gnd 2.080806f
R3 g5496_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g5496_1 2.224404
.ends

.subckt netg4908 g4908_2 g4908_4 g4908_1 g4908_3 g4908_0 gnd
C1  g4908_2 gnd 2.080806f
C2  g4908_4 gnd 2.080806f
C3  g4908_1 gnd 2.080806f
C4  g4908_3 gnd 2.080806f
C5  g4908_0 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g4908_0 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4908_4 2.224404
C8 3 gnd 2.080806f
R4 2 3 2.224404
C9 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g4908_2 2.224404
C10 5 gnd 2.080806f
R7 g4908_2 5 2.224404
R8 5 g4908_3 2.224404
R9 g4908_3 g4908_1 2.224404
.ends

.subckt netg1505 g1505_1 g1505_0 gnd
C1  g1505_1 gnd 2.080806f
C2  g1505_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1505_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g1505_1 2.224404
.ends

.subckt netg5234 g5234_1 g5234_0 gnd
C1  g5234_1 gnd 2.080806f
C2  g5234_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5234_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g5234_1 7 2.224404
.ends

.subckt netg1898 g1898_0 g1898_1 gnd
C1  g1898_0 gnd 2.080806f
C2  g1898_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1898_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g1898_1 2.224404
.ends

.subckt netg1504 g1504_0 g1504_1 gnd
C1  g1504_0 gnd 2.080806f
C2  g1504_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1504_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g1504_1 7 2.224404
.ends

.subckt netg7038 g7038_1 g7038_0 g7038_2 gnd
C1  g7038_1 gnd 2.080806f
C2  g7038_0 gnd 2.080806f
C3  g7038_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7038_0 2.224404
R2 g7038_1 1 2.224404
C5 2 gnd 2.080806f
R3 g7038_0 2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g7038_2 2.224404
.ends

.subckt netg4088 g4088_2 g4088_1 g4088_3 g4088_0 gnd
C1  g4088_2 gnd 2.080806f
C2  g4088_1 gnd 2.080806f
C3  g4088_3 gnd 2.080806f
C4  g4088_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g4088_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g4088_1 2.224404
C8 4 gnd 2.080806f
R5 g4088_1 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g4088_3 2.224404
R8 g4088_3 g4088_2 2.224404
.ends

.subckt netg5235 g5235_0 g5235_1 gnd
C1  g5235_0 gnd 2.080806f
C2  g5235_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5235_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g5235_1 7 2.224404
.ends

.subckt netg1144 g1144_2 g1144_5 g1144_3 g1144_1 g1144_4 g1144_0 gnd
C1  g1144_2 gnd 2.080806f
C2  g1144_5 gnd 2.080806f
C3  g1144_3 gnd 2.080806f
C4  g1144_1 gnd 2.080806f
C5  g1144_4 gnd 2.080806f
C6  g1144_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1144_0 1 2.224404
R2 1 g1144_3 2.224404
C8 2 gnd 2.080806f
R3 2 g1144_0 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
R5 g1144_1 3 2.224404
R6 g1144_1 g1144_2 2.224404
C10 4 gnd 2.080806f
R7 1 4 2.224404
R8 4 g1144_4 2.224404
R9 g1144_5 g1144_4 2.224404
.ends

.subckt netg1580 g1580_1 g1580_0 gnd
C1  g1580_1 gnd 2.080806f
C2  g1580_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1580_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g1580_1 7 2.224404
.ends

.subckt netg4314 g4314_1 g4314_0 gnd
C1  g4314_1 gnd 2.080806f
C2  g4314_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4314_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g4314_1 7 2.224404
.ends

.subckt netg2890 g2890_3 g2890_1 g2890_5 g2890_0 g2890_4 g2890_2 gnd
C1  g2890_3 gnd 2.080806f
C2  g2890_1 gnd 2.080806f
C3  g2890_5 gnd 2.080806f
C4  g2890_0 gnd 2.080806f
C5  g2890_4 gnd 2.080806f
C6  g2890_2 gnd 2.080806f
R1 g2890_1 g2890_0 2.224404
R2 g2890_4 g2890_0 2.224404
C7 1 gnd 2.080806f
R3 1 g2890_1 2.224404
C8 2 gnd 2.080806f
R4 2 1 2.224404
C9 3 gnd 2.080806f
R5 3 2 2.224404
R6 g2890_5 3 2.224404
R7 g2890_2 g2890_5 2.224404
C10 4 gnd 2.080806f
R8 g2890_2 4 2.224404
C11 5 gnd 2.080806f
R9 4 5 2.224404
R10 g2890_3 5 2.224404
.ends

.subckt netg1670 g1670_3 g1670_2 g1670_0 g1670_1 gnd
C1  g1670_3 gnd 2.080806f
C2  g1670_2 gnd 2.080806f
C3  g1670_0 gnd 2.080806f
C4  g1670_1 gnd 2.080806f
R1 g1670_1 g1670_0 2.224404
C5 1 gnd 2.080806f
R2 g1670_0 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g1670_3 2.224404
C8 4 gnd 2.080806f
R6 2 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g1670_2 2.224404
.ends

.subckt netg1495 g1495_0 g1495_1 gnd
C1  g1495_0 gnd 2.080806f
C2  g1495_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1495_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g1495_1 2.224404
.ends

.subckt netg6781 g6781_1 g6781_0 g6781_2 gnd
C1  g6781_1 gnd 2.080806f
C2  g6781_0 gnd 2.080806f
C3  g6781_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6781_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6781_2 2.224404
C7 4 gnd 2.080806f
R5 g6781_2 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g6781_1 2.224404
.ends

.subckt netg3204 g3204_2 g3204_1 gnd
C1  g3204_2 gnd 2.080806f
C2  g3204_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3204_1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g3204_2 7 2.224404
.ends

.subckt netg6757 g6757_2 g6757_1 g6757_0 gnd
C1  g6757_2 gnd 2.080806f
C2  g6757_1 gnd 2.080806f
C3  g6757_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6757_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g6757_2 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g6757_1 2.224404
.ends

.subckt netg1527 g1527_1 g1527_0 gnd
C1  g1527_1 gnd 2.080806f
C2  g1527_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1527_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g1527_1 2.224404
.ends

.subckt netg2922 g2922_0 g2922_1 gnd
C1  g2922_0 gnd 2.080806f
C2  g2922_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2922_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 g2922_1 7 2.224404
.ends

.subckt netg1920 g1920_0 g1920_1 gnd
C1  g1920_0 gnd 2.080806f
C2  g1920_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1920_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g1920_1 7 2.224404
.ends

.subckt netg5755 g5755_2 g5755_1 g5755_0 gnd
C1  g5755_2 gnd 2.080806f
C2  g5755_1 gnd 2.080806f
C3  g5755_0 gnd 2.080806f
R1 g5755_0 g5755_1 2.224404
C4 1 gnd 2.080806f
R2 g5755_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 g5755_2 6 2.224404
.ends

.subckt netg4611 g4611_2 g4611_5 g4611_1 g4611_4 g4611_0 g4611_3 gnd
C1  g4611_2 gnd 2.080806f
C2  g4611_5 gnd 2.080806f
C3  g4611_1 gnd 2.080806f
C4  g4611_4 gnd 2.080806f
C5  g4611_0 gnd 2.080806f
C6  g4611_3 gnd 2.080806f
R1 g4611_2 g4611_0 2.224404
C7 1 gnd 2.080806f
R2 g4611_0 1 2.224404
R3 1 g4611_4 2.224404
R4 g4611_4 g4611_5 2.224404
C8 2 gnd 2.080806f
R5 g4611_4 2 2.224404
C9 3 gnd 2.080806f
R6 2 3 2.224404
R7 3 g4611_1 2.224404
C10 4 gnd 2.080806f
R8 g4611_1 4 2.224404
R9 4 g4611_3 2.224404
.ends

.subckt netg1437 g1437_0 g1437_1 gnd
C1  g1437_0 gnd 2.080806f
C2  g1437_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1437_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g1437_1 2.224404
.ends

.subckt netg1891 g1891_0 g1891_1 gnd
C1  g1891_0 gnd 2.080806f
C2  g1891_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1891_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
R8 g1891_1 7 2.224404
.ends

.subckt netg1915 g1915_1 g1915_0 gnd
C1  g1915_1 gnd 2.080806f
C2  g1915_0 gnd 2.080806f
.ends

.subckt netg2167 g2167_1 g2167_0 g2167_3 g2167_2 gnd
C1  g2167_1 gnd 2.080806f
C2  g2167_0 gnd 2.080806f
C3  g2167_3 gnd 2.080806f
C4  g2167_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2167_0 2.224404
R2 g2167_2 1 2.224404
C6 2 gnd 2.080806f
R3 2 g2167_0 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
R7 g2167_1 5 2.224404
C10 6 gnd 2.080806f
R8 6 g2167_1 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
R10 g2167_3 7 2.224404
.ends

.subckt netg3282 g3282_2 g3282_1 g3282_0 gnd
C1  g3282_2 gnd 2.080806f
C2  g3282_1 gnd 2.080806f
C3  g3282_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3282_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g3282_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 g3282_2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
R9 g3282_1 7 2.224404
.ends

.subckt netg3713 g3713_1 g3713_0 g3713_2 gnd
C1  g3713_1 gnd 2.080806f
C2  g3713_0 gnd 2.080806f
C3  g3713_2 gnd 2.080806f
R1 g3713_1 g3713_0 2.224404
C4 1 gnd 2.080806f
R2 1 g3713_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g3713_2 2.224404
.ends

.subckt netg4124 g4124_2 g4124_3 g4124_1 g4124_0 gnd
C1  g4124_2 gnd 2.080806f
C2  g4124_3 gnd 2.080806f
C3  g4124_1 gnd 2.080806f
C4  g4124_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4124_0 1 2.224404
R2 1 g4124_1 2.224404
C6 2 gnd 2.080806f
R3 g4124_1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g4124_3 2.224404
C8 4 gnd 2.080806f
R6 g4124_3 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g4124_2 2.224404
.ends

.subckt netg117 g117_0 g117_1 gnd
C1  g117_0 gnd 2.080806f
C2  g117_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g117_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g117_1 2.224404
.ends

.subckt netg3725 g3725_9 g3725_8 g3725_6 g3725_5 g3725_10 g3725_0 g3725_2 g3725_3 g3725_7 gnd
C1  g3725_9 gnd 2.080806f
C2  g3725_8 gnd 2.080806f
C3  g3725_6 gnd 2.080806f
C4  g3725_5 gnd 2.080806f
C5  g3725_10 gnd 2.080806f
C6  g3725_0 gnd 2.080806f
C7  g3725_2 gnd 2.080806f
C8  g3725_3 gnd 2.080806f
C9  g3725_7 gnd 2.080806f
R1 g3725_5 g3725_0 2.224404
R2 g3725_8 g3725_5 2.224404
C10 1 gnd 2.080806f
R3 g3725_0 1 2.224404
R4 1 g3725_7 2.224404
C11 2 gnd 2.080806f
R5 g3725_8 2 2.224404
R6 2 g3725_9 2.224404
R7 g3725_2 g3725_9 2.224404
R8 1 g3725_3 2.224404
C12 3 gnd 2.080806f
R9 3 g3725_8 2.224404
R10 g3725_10 3 2.224404
C13 4 gnd 2.080806f
R11 4 g3725_2 2.224404
R12 g3725_6 4 2.224404
.ends

.subckt netg4143 g4143_1 g4143_0 g4143_2 gnd
C1  g4143_1 gnd 2.080806f
C2  g4143_0 gnd 2.080806f
C3  g4143_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4143_0 1 2.224404
R2 1 g4143_2 2.224404
C5 2 gnd 2.080806f
R3 2 g4143_2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
R8 6 g4143_1 2.224404
.ends

.subckt netg1192 g1192_1 g1192_0 g1192_5 g1192_2 g1192_6 g1192_3 gnd
C1  g1192_1 gnd 2.080806f
C2  g1192_0 gnd 2.080806f
C3  g1192_5 gnd 2.080806f
C4  g1192_2 gnd 2.080806f
C5  g1192_6 gnd 2.080806f
C6  g1192_3 gnd 2.080806f
R1 g1192_0 g1192_5 2.224404
C7 1 gnd 2.080806f
R2 1 g1192_0 2.224404
R3 g1192_2 1 2.224404
C8 2 gnd 2.080806f
R4 2 g1192_0 2.224404
C9 3 gnd 2.080806f
R5 3 2 2.224404
R6 g1192_1 3 2.224404
R7 g1192_3 g1192_1 2.224404
C10 4 gnd 2.080806f
R8 4 g1192_3 2.224404
C11 5 gnd 2.080806f
R9 5 4 2.224404
R10 g1192_6 5 2.224404
.ends

.subckt netg6336 g6336_0 g6336_1 g6336_3 g6336_2 gnd
C1  g6336_0 gnd 2.080806f
C2  g6336_1 gnd 2.080806f
C3  g6336_3 gnd 2.080806f
C4  g6336_2 gnd 2.080806f
R1 g6336_0 g6336_3 2.224404
R2 g6336_3 g6336_1 2.224404
C5 1 gnd 2.080806f
R3 g6336_1 1 2.224404
C6 2 gnd 2.080806f
R4 1 2 2.224404
C7 3 gnd 2.080806f
R5 2 3 2.224404
C8 4 gnd 2.080806f
R6 3 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g6336_2 2.224404
.ends

.subckt netg518 g518_1 g518_0 gnd
C1  g518_1 gnd 2.080806f
C2  g518_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g518_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 g518_1 7 2.224404
.ends

.subckt netg1528 g1528_1 g1528_0 gnd
C1  g1528_1 gnd 2.080806f
C2  g1528_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1528_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g1528_1 2.224404
.ends

.subckt netg3797 g3797_2 g3797_5 g3797_0 g3797_4 g3797_3 gnd
C1  g3797_2 gnd 2.080806f
C2  g3797_5 gnd 2.080806f
C3  g3797_0 gnd 2.080806f
C4  g3797_4 gnd 2.080806f
C5  g3797_3 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g3797_0 2.224404
C7 2 gnd 2.080806f
R2 2 1 2.224404
C8 3 gnd 2.080806f
R3 3 2 2.224404
R4 g3797_4 3 2.224404
R5 g3797_3 g3797_4 2.224404
C9 4 gnd 2.080806f
R6 g3797_3 4 2.224404
C10 5 gnd 2.080806f
R7 4 5 2.224404
R8 g3797_5 5 2.224404
C11 6 gnd 2.080806f
R9 6 g3797_5 2.224404
C12 7 gnd 2.080806f
R10 7 6 2.224404
R11 g3797_2 7 2.224404
.ends

.subckt netg85 g85_0 g85_1 gnd
C1  g85_0 gnd 2.080806f
C2  g85_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g85_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
R8 7 g85_1 2.224404
.ends

.subckt netg1990 g1990_2 g1990_0 g1990_3 g1990_1 gnd
C1  g1990_2 gnd 2.080806f
C2  g1990_0 gnd 2.080806f
C3  g1990_3 gnd 2.080806f
C4  g1990_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1990_0 2.224404
R2 g1990_2 1 2.224404
C6 2 gnd 2.080806f
R3 2 1 2.224404
R4 g1990_3 2 2.224404
C7 3 gnd 2.080806f
R5 3 g1990_3 2.224404
C8 4 gnd 2.080806f
R6 4 3 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
R9 g1990_1 6 2.224404
.ends

.subckt netg1515 g1515_0 g1515_1 gnd
C1  g1515_0 gnd 2.080806f
C2  g1515_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1515_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
R9 g1515_1 8 2.224404
.ends

.subckt netg1440 g1440_5 g1440_2 g1440_3 g1440_1 g1440_4 g1440_0 gnd
C1  g1440_5 gnd 2.080806f
C2  g1440_2 gnd 2.080806f
C3  g1440_3 gnd 2.080806f
C4  g1440_1 gnd 2.080806f
C5  g1440_4 gnd 2.080806f
C6  g1440_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1440_0 1 2.224404
R2 1 g1440_2 2.224404
R3 g1440_2 g1440_5 2.224404
R4 g1440_5 g1440_4 2.224404
R5 g1440_3 g1440_4 2.224404
C8 2 gnd 2.080806f
R6 g1440_4 2 2.224404
C9 3 gnd 2.080806f
R7 2 3 2.224404
C10 4 gnd 2.080806f
R8 3 4 2.224404
R9 4 g1440_1 2.224404
.ends

.subckt netg3907 g3907_2 g3907_4 g3907_1 g3907_0 g3907_5 g3907_3 gnd
C1  g3907_2 gnd 2.080806f
C2  g3907_4 gnd 2.080806f
C3  g3907_1 gnd 2.080806f
C4  g3907_0 gnd 2.080806f
C5  g3907_5 gnd 2.080806f
C6  g3907_3 gnd 2.080806f
R1 g3907_0 g3907_3 2.224404
C7 1 gnd 2.080806f
R2 g3907_3 1 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g3907_1 2.224404
C11 5 gnd 2.080806f
R7 g3907_1 5 2.224404
R8 5 g3907_2 2.224404
R9 g3907_2 g3907_5 2.224404
R10 g3907_4 g3907_5 2.224404
.ends

.subckt netg6016 g6016_5 g6016_4 g6016_3 g6016_2 g6016_0 g6016_6 g6016_1 gnd
C1  g6016_5 gnd 2.080806f
C2  g6016_4 gnd 2.080806f
C3  g6016_3 gnd 2.080806f
C4  g6016_2 gnd 2.080806f
C5  g6016_0 gnd 2.080806f
C6  g6016_6 gnd 2.080806f
C7  g6016_1 gnd 2.080806f
R1 g6016_1 g6016_0 2.224404
R2 g6016_6 g6016_0 2.224404
R3 g6016_3 g6016_1 2.224404
R4 g6016_5 g6016_3 2.224404
C8 1 gnd 2.080806f
R5 g6016_1 1 2.224404
C9 2 gnd 2.080806f
R6 1 2 2.224404
R7 2 g6016_2 2.224404
C10 3 gnd 2.080806f
R8 g6016_2 3 2.224404
C11 4 gnd 2.080806f
R9 3 4 2.224404
R10 g6016_4 4 2.224404
.ends

.subckt netg6204 g6204_0 g6204_1 gnd
C1  g6204_0 gnd 2.080806f
C2  g6204_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6204_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
R9 g6204_1 8 2.224404
.ends

.subckt netg7096 g7096_1 g7096_0 g7096_2 gnd
C1  g7096_1 gnd 2.080806f
C2  g7096_0 gnd 2.080806f
C3  g7096_2 gnd 2.080806f
R1 g7096_2 g7096_0 2.224404
C4 1 gnd 2.080806f
R2 1 g7096_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
R9 g7096_1 7 2.224404
.ends

.subckt netg7412 g7412_1 g7412_0 gnd
C1  g7412_1 gnd 2.080806f
C2  g7412_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7412_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
R9 8 g7412_1 2.224404
.ends

.subckt netg1723 g1723_0 g1723_2 g1723_3 g1723_1 gnd
C1  g1723_0 gnd 2.080806f
C2  g1723_2 gnd 2.080806f
C3  g1723_3 gnd 2.080806f
C4  g1723_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1723_0 1 2.224404
R2 1 g1723_1 2.224404
C6 2 gnd 2.080806f
R3 g1723_1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g1723_2 2.224404
C10 6 gnd 2.080806f
R8 6 g1723_2 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g1723_3 2.224404
.ends

.subckt netg5824 g5824_0 g5824_1 g5824_2 gnd
C1  g5824_0 gnd 2.080806f
C2  g5824_1 gnd 2.080806f
C3  g5824_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5824_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5824_2 2.224404
C6 3 gnd 2.080806f
R4 3 g5824_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
R9 7 g5824_1 2.224404
.ends

.subckt netg3004 g3004_3 g3004_2 g3004_0 g3004_1 gnd
C1  g3004_3 gnd 2.080806f
C2  g3004_2 gnd 2.080806f
C3  g3004_0 gnd 2.080806f
C4  g3004_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g3004_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3004_2 2.224404
C7 3 gnd 2.080806f
R4 3 g3004_0 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
R6 g3004_3 4 2.224404
C9 5 gnd 2.080806f
R7 g3004_2 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g3004_1 2.224404
.ends

.subckt netg5156 g5156_2 g5156_3 g5156_0 g5156_1 gnd
C1  g5156_2 gnd 2.080806f
C2  g5156_3 gnd 2.080806f
C3  g5156_0 gnd 2.080806f
C4  g5156_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g5156_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5156_2 2.224404
C7 3 gnd 2.080806f
R4 g5156_2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g5156_3 2.224404
C9 5 gnd 2.080806f
R7 g5156_3 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g5156_1 2.224404
.ends

.subckt netg6939 g6939_1 g6939_0 gnd
C1  g6939_1 gnd 2.080806f
C2  g6939_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6939_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
R9 g6939_1 8 2.224404
.ends

.subckt netg7528 g7528_0 g7528_1 gnd
C1  g7528_0 gnd 2.080806f
C2  g7528_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7528_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
R9 8 g7528_1 2.224404
.ends

.subckt netg6377 g6377_3 g6377_1 g6377_2 g6377_0 gnd
C1  g6377_3 gnd 2.080806f
C2  g6377_1 gnd 2.080806f
C3  g6377_2 gnd 2.080806f
C4  g6377_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g6377_0 1 2.224404
R2 g6377_3 1 2.224404
C6 2 gnd 2.080806f
R3 2 g6377_0 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
R7 g6377_2 5 2.224404
C10 6 gnd 2.080806f
R8 6 g6377_2 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
R11 g6377_1 8 2.224404
.ends

.subckt netg2901 g2901_2 g2901_5 g2901_4 g2901_3 g2901_1 g2901_0 gnd
C1  g2901_2 gnd 2.080806f
C2  g2901_5 gnd 2.080806f
C3  g2901_4 gnd 2.080806f
C4  g2901_3 gnd 2.080806f
C5  g2901_1 gnd 2.080806f
C6  g2901_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g2901_0 1 2.224404
R2 g2901_3 1 2.224404
C8 2 gnd 2.080806f
R3 2 g2901_0 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
R6 g2901_1 4 2.224404
R7 g2901_4 4 2.224404
C11 5 gnd 2.080806f
R8 g2901_4 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
R10 6 g2901_2 2.224404
C13 7 gnd 2.080806f
R11 1 7 2.224404
C14 8 gnd 2.080806f
R12 7 8 2.224404
R13 8 g2901_5 2.224404
.ends

.subckt netg5136 g5136_2 g5136_1 g5136_0 gnd
C1  g5136_2 gnd 2.080806f
C2  g5136_1 gnd 2.080806f
C3  g5136_0 gnd 2.080806f
R1 g5136_0 g5136_1 2.224404
C4 1 gnd 2.080806f
R2 g5136_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
R9 g5136_2 7 2.224404
.ends

.subckt netg1402 g1402_0 g1402_1 gnd
C1  g1402_0 gnd 2.080806f
C2  g1402_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1402_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
R9 8 g1402_1 2.224404
.ends

.subckt netg6359 g6359_1 g6359_0 gnd
C1  g6359_1 gnd 2.080806f
C2  g6359_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6359_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
R9 8 g6359_1 2.224404
.ends

.subckt netg4199 g4199_0 g4199_1 g4199_2 gnd
C1  g4199_0 gnd 2.080806f
C2  g4199_1 gnd 2.080806f
C3  g4199_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4199_0 1 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
R6 g4199_2 5 2.224404
C9 6 gnd 2.080806f
R7 6 g4199_2 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
R9 g4199_1 7 2.224404
.ends

.subckt netg4926 g4926_3 g4926_2 g4926_4 g4926_0 g4926_1 gnd
C1  g4926_3 gnd 2.080806f
C2  g4926_2 gnd 2.080806f
C3  g4926_4 gnd 2.080806f
C4  g4926_0 gnd 2.080806f
C5  g4926_1 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g4926_0 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4926_1 2.224404
C8 3 gnd 2.080806f
R4 g4926_0 3 2.224404
C9 4 gnd 2.080806f
R5 3 4 2.224404
R6 g4926_3 4 2.224404
C10 5 gnd 2.080806f
R7 5 g4926_3 2.224404
R8 g4926_2 5 2.224404
C11 6 gnd 2.080806f
R9 6 g4926_3 2.224404
C12 7 gnd 2.080806f
R10 7 6 2.224404
C13 8 gnd 2.080806f
R11 8 7 2.224404
R12 g4926_4 8 2.224404
.ends

.subckt netg2033 g2033_4 g2033_1 g2033_0 g2033_3 g2033_2 gnd
C1  g2033_4 gnd 2.080806f
C2  g2033_1 gnd 2.080806f
C3  g2033_0 gnd 2.080806f
C4  g2033_3 gnd 2.080806f
C5  g2033_2 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g2033_0 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
C8 3 gnd 2.080806f
R3 2 3 2.224404
C9 4 gnd 2.080806f
R4 3 4 2.224404
C10 5 gnd 2.080806f
R5 4 5 2.224404
R6 g2033_3 5 2.224404
R7 g2033_3 g2033_4 2.224404
C11 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g2033_2 2.224404
R10 g2033_2 g2033_1 2.224404
.ends

.subckt netg5956 g5956_1 g5956_0 gnd
C1  g5956_1 gnd 2.080806f
C2  g5956_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5956_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
R9 g5956_1 8 2.224404
.ends

.subckt netg4863 g4863_4 g4863_5 g4863_2 g4863_1 g4863_3 g4863_0 gnd
C1  g4863_4 gnd 2.080806f
C2  g4863_5 gnd 2.080806f
C3  g4863_2 gnd 2.080806f
C4  g4863_1 gnd 2.080806f
C5  g4863_3 gnd 2.080806f
C6  g4863_0 gnd 2.080806f
R1 g4863_0 g4863_2 2.224404
C7 1 gnd 2.080806f
R2 g4863_0 1 2.224404
R3 1 g4863_3 2.224404
C8 2 gnd 2.080806f
R4 g4863_3 2 2.224404
C9 3 gnd 2.080806f
R5 2 3 2.224404
R6 3 g4863_4 2.224404
C10 4 gnd 2.080806f
R7 4 g4863_3 2.224404
C11 5 gnd 2.080806f
R8 5 4 2.224404
R9 g4863_5 5 2.224404
C12 6 gnd 2.080806f
R10 g4863_5 6 2.224404
C13 7 gnd 2.080806f
R11 6 7 2.224404
R12 7 g4863_1 2.224404
.ends

.subckt netg2897 g2897_3 g2897_2 g2897_1 g2897_0 gnd
C1  g2897_3 gnd 2.080806f
C2  g2897_2 gnd 2.080806f
C3  g2897_1 gnd 2.080806f
C4  g2897_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2897_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
R4 g2897_3 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g2897_2 2.224404
C9 5 gnd 2.080806f
R7 g2897_0 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
R11 8 g2897_1 2.224404
.ends

.subckt netg2881 g2881_3 g2881_2 g2881_0 gnd
C1  g2881_3 gnd 2.080806f
C2  g2881_2 gnd 2.080806f
C3  g2881_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2881_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
R5 g2881_3 4 2.224404
C8 5 gnd 2.080806f
R6 1 5 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
R10 8 g2881_2 2.224404
.ends

.subckt netg2163 g2163_2 g2163_3 g2163_1 gnd
C1  g2163_2 gnd 2.080806f
C2  g2163_3 gnd 2.080806f
C3  g2163_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2163_3 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g2163_2 2.224404
C9 6 gnd 2.080806f
R7 g2163_2 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g2163_1 2.224404
.ends

.subckt netg5770 g5770_3 g5770_2 g5770_1 g5770_0 gnd
C1  g5770_3 gnd 2.080806f
C2  g5770_2 gnd 2.080806f
C3  g5770_1 gnd 2.080806f
C4  g5770_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g5770_0 1 2.224404
R2 g5770_3 1 2.224404
C6 2 gnd 2.080806f
R3 2 g5770_0 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
R8 g5770_2 6 2.224404
C11 7 gnd 2.080806f
R9 7 g5770_2 2.224404
R10 g5770_1 7 2.224404
.ends

.subckt netg5163 g5163_2 g5163_1 g5163_0 gnd
C1  g5163_2 gnd 2.080806f
C2  g5163_1 gnd 2.080806f
C3  g5163_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5163_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5163_2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g5163_1 2.224404
.ends

.subckt netg1401 g1401_1 g1401_0 gnd
C1  g1401_1 gnd 2.080806f
C2  g1401_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1401_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
R9 8 g1401_1 2.224404
.ends

.subckt netg2980 g2980_2 g2980_0 g2980_3 g2980_1 gnd
C1  g2980_2 gnd 2.080806f
C2  g2980_0 gnd 2.080806f
C3  g2980_3 gnd 2.080806f
C4  g2980_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2980_0 2.224404
R2 g2980_1 1 2.224404
R3 g2980_2 1 2.224404
C6 2 gnd 2.080806f
R4 2 g2980_2 2.224404
C7 3 gnd 2.080806f
R5 3 2 2.224404
C8 4 gnd 2.080806f
R6 4 3 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
R9 g2980_3 6 2.224404
.ends

.subckt netg1577 g1577_0 g1577_1 gnd
C1  g1577_0 gnd 2.080806f
C2  g1577_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1577_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
R9 g1577_1 8 2.224404
.ends

.subckt netg835 g835_1 g835_4 g835_3 g835_2 g835_6 g835_5 g835_0 gnd
C1  g835_1 gnd 2.080806f
C2  g835_4 gnd 2.080806f
C3  g835_3 gnd 2.080806f
C4  g835_2 gnd 2.080806f
C5  g835_6 gnd 2.080806f
C6  g835_5 gnd 2.080806f
C7  g835_0 gnd 2.080806f
.ends

.subckt netg3489 g3489_0 g3489_1 gnd
C1  g3489_0 gnd 2.080806f
C2  g3489_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3489_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 9 g3489_1 2.224404
.ends

.subckt netg4532 g4532_5 g4532_4 g4532_2 g4532_6 g4532_1 g4532_3 g4532_0 gnd
C1  g4532_5 gnd 2.080806f
C2  g4532_4 gnd 2.080806f
C3  g4532_2 gnd 2.080806f
C4  g4532_6 gnd 2.080806f
C5  g4532_1 gnd 2.080806f
C6  g4532_3 gnd 2.080806f
C7  g4532_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g4532_0 2.224404
R2 1 g4532_1 2.224404
C9 2 gnd 2.080806f
R3 2 1 2.224404
R4 g4532_6 2 2.224404
C10 3 gnd 2.080806f
R5 g4532_0 3 2.224404
C11 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g4532_5 2.224404
R8 g4532_5 g4532_3 2.224404
C12 5 gnd 2.080806f
R9 4 5 2.224404
R10 5 g4532_2 2.224404
R11 g4532_2 g4532_4 2.224404
.ends

.subckt netg1902 g1902_1 g1902_0 gnd
C1  g1902_1 gnd 2.080806f
C2  g1902_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1902_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
R10 g1902_1 9 2.224404
.ends

.subckt netg6563 g6563_1 g6563_0 gnd
C1  g6563_1 gnd 2.080806f
C2  g6563_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6563_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 g6563_1 9 2.224404
.ends

.subckt netg4622 g4622_0 g4622_1 gnd
C1  g4622_0 gnd 2.080806f
C2  g4622_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4622_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 9 g4622_1 2.224404
.ends

.subckt netg3008 g3008_1 g3008_4 g3008_2 g3008_3 g3008_0 gnd
C1  g3008_1 gnd 2.080806f
C2  g3008_4 gnd 2.080806f
C3  g3008_2 gnd 2.080806f
C4  g3008_3 gnd 2.080806f
C5  g3008_0 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g3008_0 1 2.224404
R2 1 g3008_4 2.224404
C7 2 gnd 2.080806f
R3 g3008_4 2 2.224404
R4 2 g3008_2 2.224404
C8 3 gnd 2.080806f
R5 g3008_4 3 2.224404
C9 4 gnd 2.080806f
R6 3 4 2.224404
C10 5 gnd 2.080806f
R7 4 5 2.224404
C11 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g3008_1 2.224404
C12 7 gnd 2.080806f
R10 g3008_1 7 2.224404
C13 8 gnd 2.080806f
R11 7 8 2.224404
R12 8 g3008_3 2.224404
.ends

.subckt netg4623 g4623_0 g4623_1 gnd
C1  g4623_0 gnd 2.080806f
C2  g4623_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4623_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 9 g4623_1 2.224404
.ends

.subckt netg6833 g6833_3 g6833_2 g6833_0 g6833_1 gnd
C1  g6833_3 gnd 2.080806f
C2  g6833_2 gnd 2.080806f
C3  g6833_0 gnd 2.080806f
C4  g6833_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g6833_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
R7 g6833_1 6 2.224404
C11 7 gnd 2.080806f
R8 g6833_1 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
R10 8 g6833_2 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g6833_3 2.224404
.ends

.subckt netg78 g78_0 g78_1 gnd
C1  g78_0 gnd 2.080806f
C2  g78_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g78_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
R10 g78_1 9 2.224404
.ends

.subckt netg1521 g1521_3 g1521_1 g1521_2 g1521_5 g1521_4 g1521_0 gnd
C1  g1521_3 gnd 2.080806f
C2  g1521_1 gnd 2.080806f
C3  g1521_2 gnd 2.080806f
C4  g1521_5 gnd 2.080806f
C5  g1521_4 gnd 2.080806f
C6  g1521_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1521_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1521_1 2.224404
C9 3 gnd 2.080806f
R4 3 g1521_0 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
R6 g1521_4 4 2.224404
C11 5 gnd 2.080806f
R7 g1521_0 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g1521_5 2.224404
R10 g1521_5 g1521_2 2.224404
C13 7 gnd 2.080806f
R11 g1521_2 7 2.224404
C14 8 gnd 2.080806f
R12 7 8 2.224404
R13 8 g1521_3 2.224404
.ends

.subckt netg5802 g5802_3 g5802_1 g5802_2 g5802_0 gnd
C1  g5802_3 gnd 2.080806f
C2  g5802_1 gnd 2.080806f
C3  g5802_2 gnd 2.080806f
C4  g5802_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g5802_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g5802_3 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
R5 g5802_2 3 2.224404
C8 4 gnd 2.080806f
R6 g5802_0 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
R11 8 g5802_1 2.224404
.ends

.subckt netx511 x511_0 x511_1 gnd
C1  x511_0 gnd 2.080806f
C2  x511_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x511_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 9 x511_1 2.224404
.ends

.subckt netg1892 g1892_1 g1892_0 gnd
C1  g1892_1 gnd 2.080806f
C2  g1892_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1892_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 9 g1892_1 2.224404
.ends

.subckt netg4624 g4624_1 g4624_0 gnd
C1  g4624_1 gnd 2.080806f
C2  g4624_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4624_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 9 g4624_1 2.224404
.ends

.subckt netg3994 g3994_1 g3994_4 g3994_0 g3994_2 g3994_3 gnd
C1  g3994_1 gnd 2.080806f
C2  g3994_4 gnd 2.080806f
C3  g3994_0 gnd 2.080806f
C4  g3994_2 gnd 2.080806f
C5  g3994_3 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g3994_0 1 2.224404
R2 1 g3994_1 2.224404
C7 2 gnd 2.080806f
R3 2 g3994_0 2.224404
C8 3 gnd 2.080806f
R4 3 2 2.224404
R5 3 g3994_4 2.224404
R6 g3994_3 g3994_4 2.224404
C9 4 gnd 2.080806f
R7 g3994_4 4 2.224404
C10 5 gnd 2.080806f
R8 4 5 2.224404
C11 6 gnd 2.080806f
R9 5 6 2.224404
R10 6 g3994_2 2.224404
.ends

.subckt netg1507 g1507_1 g1507_0 gnd
C1  g1507_1 gnd 2.080806f
C2  g1507_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1507_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 g1507_1 9 2.224404
.ends

.subckt netg2984 g2984_1 g2984_3 g2984_0 g2984_4 g2984_2 gnd
C1  g2984_1 gnd 2.080806f
C2  g2984_3 gnd 2.080806f
C3  g2984_0 gnd 2.080806f
C4  g2984_4 gnd 2.080806f
C5  g2984_2 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g2984_0 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2984_1 2.224404
C8 3 gnd 2.080806f
R4 g2984_0 3 2.224404
C9 4 gnd 2.080806f
R5 3 4 2.224404
C10 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g2984_3 2.224404
C11 6 gnd 2.080806f
R8 g2984_3 6 2.224404
C12 7 gnd 2.080806f
R9 6 7 2.224404
C13 8 gnd 2.080806f
R10 7 8 2.224404
R11 8 g2984_2 2.224404
C14 9 gnd 2.080806f
R12 g2984_2 9 2.224404
R13 9 g2984_4 2.224404
.ends

.subckt netg2071 g2071_2 g2071_0 g2071_1 g2071_3 gnd
C1  g2071_2 gnd 2.080806f
C2  g2071_0 gnd 2.080806f
C3  g2071_1 gnd 2.080806f
C4  g2071_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2071_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2071_1 2.224404
R5 g2071_3 3 2.224404
C8 4 gnd 2.080806f
R6 g2071_1 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g2071_2 2.224404
.ends

.subckt netg3675 g3675_1 g3675_0 g3675_3 g3675_6 g3675_2 g3675_5 g3675_4 gnd
C1  g3675_1 gnd 2.080806f
C2  g3675_0 gnd 2.080806f
C3  g3675_3 gnd 2.080806f
C4  g3675_6 gnd 2.080806f
C5  g3675_2 gnd 2.080806f
C6  g3675_5 gnd 2.080806f
C7  g3675_4 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g3675_0 2.224404
R2 g3675_5 1 2.224404
C9 2 gnd 2.080806f
R3 2 g3675_5 2.224404
R4 g3675_3 2 2.224404
R5 g3675_3 g3675_4 2.224404
C10 3 gnd 2.080806f
R6 g3675_4 3 2.224404
C11 4 gnd 2.080806f
R7 3 4 2.224404
C12 5 gnd 2.080806f
R8 4 5 2.224404
R9 5 g3675_6 2.224404
C13 6 gnd 2.080806f
R10 g3675_6 6 2.224404
R11 6 g3675_1 2.224404
C14 7 gnd 2.080806f
R12 g3675_1 7 2.224404
C15 8 gnd 2.080806f
R13 7 8 2.224404
C16 9 gnd 2.080806f
R14 8 9 2.224404
R15 g3675_2 9 2.224404
.ends

.subckt netg1446 g1446_2 g1446_5 g1446_0 g1446_1 g1446_4 g1446_3 gnd
C1  g1446_2 gnd 2.080806f
C2  g1446_5 gnd 2.080806f
C3  g1446_0 gnd 2.080806f
C4  g1446_1 gnd 2.080806f
C5  g1446_4 gnd 2.080806f
C6  g1446_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1446_0 1 2.224404
R2 1 g1446_2 2.224404
R3 g1446_2 g1446_4 2.224404
C8 2 gnd 2.080806f
R4 2 g1446_2 2.224404
R5 g1446_3 2 2.224404
C9 3 gnd 2.080806f
R6 3 g1446_3 2.224404
C10 4 gnd 2.080806f
R7 4 3 2.224404
C11 5 gnd 2.080806f
R8 5 4 2.224404
C12 6 gnd 2.080806f
R9 6 5 2.224404
R10 g1446_5 6 2.224404
C13 7 gnd 2.080806f
R11 7 g1446_5 2.224404
R12 g1446_1 7 2.224404
.ends

.subckt netg3654 g3654_8 g3654_7 g3654_10 g3654_4 g3654_9 g3654_0 g3654_2 g3654_3 g3654_1 g3654_6 g3654_5 gnd
C1  g3654_8 gnd 2.080806f
C2  g3654_7 gnd 2.080806f
C3  g3654_10 gnd 2.080806f
C4  g3654_4 gnd 2.080806f
C5  g3654_9 gnd 2.080806f
C6  g3654_0 gnd 2.080806f
C7  g3654_2 gnd 2.080806f
C8  g3654_3 gnd 2.080806f
C9  g3654_1 gnd 2.080806f
C10  g3654_6 gnd 2.080806f
C11  g3654_5 gnd 2.080806f
R1 g3654_3 g3654_0 2.224404
C12 1 gnd 2.080806f
R2 1 g3654_3 2.224404
R3 g3654_4 1 2.224404
C13 2 gnd 2.080806f
R4 2 g3654_4 2.224404
R5 g3654_2 2 2.224404
R6 g3654_6 g3654_2 2.224404
R7 g3654_5 g3654_6 2.224404
R8 g3654_9 2 2.224404
C14 3 gnd 2.080806f
R9 3 g3654_9 2.224404
R10 g3654_1 3 2.224404
R11 g3654_1 g3654_7 2.224404
C15 4 gnd 2.080806f
R12 g3654_7 4 2.224404
R13 4 g3654_10 2.224404
C16 5 gnd 2.080806f
R14 5 g3654_1 2.224404
C17 6 gnd 2.080806f
R15 6 5 2.224404
R16 g3654_8 6 2.224404
.ends

.subckt netg92 g92_1 g92_0 gnd
C1  g92_1 gnd 2.080806f
C2  g92_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g92_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 9 g92_1 2.224404
.ends

.subckt netg7533 g7533_0 g7533_1 gnd
C1  g7533_0 gnd 2.080806f
C2  g7533_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7533_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
R10 g7533_1 9 2.224404
.ends

.subckt netg2874 g2874_1 g2874_3 g2874_2 g2874_0 g2874_4 gnd
C1  g2874_1 gnd 2.080806f
C2  g2874_3 gnd 2.080806f
C3  g2874_2 gnd 2.080806f
C4  g2874_0 gnd 2.080806f
C5  g2874_4 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g2874_0 2.224404
R2 1 g2874_4 2.224404
C7 2 gnd 2.080806f
R3 g2874_4 2 2.224404
C8 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g2874_1 2.224404
C9 4 gnd 2.080806f
R6 4 g2874_1 2.224404
C10 5 gnd 2.080806f
R7 4 5 2.224404
C11 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g2874_3 2.224404
R10 g2874_2 g2874_3 2.224404
.ends

.subckt netg1199 g1199_2 g1199_0 g1199_5 g1199_3 g1199_1 g1199_6 g1199_4 gnd
C1  g1199_2 gnd 2.080806f
C2  g1199_0 gnd 2.080806f
C3  g1199_5 gnd 2.080806f
C4  g1199_3 gnd 2.080806f
C5  g1199_1 gnd 2.080806f
C6  g1199_6 gnd 2.080806f
C7  g1199_4 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g1199_0 1 2.224404
R2 1 g1199_3 2.224404
C9 2 gnd 2.080806f
R3 g1199_0 2 2.224404
R4 2 g1199_6 2.224404
R5 2 g1199_5 2.224404
C10 3 gnd 2.080806f
R6 3 g1199_3 2.224404
C11 4 gnd 2.080806f
R7 4 3 2.224404
R8 g1199_1 4 2.224404
C12 5 gnd 2.080806f
R9 g1199_6 5 2.224404
C13 6 gnd 2.080806f
R10 5 6 2.224404
R11 g1199_2 6 2.224404
C14 7 gnd 2.080806f
R12 7 g1199_1 2.224404
C15 8 gnd 2.080806f
R13 8 7 2.224404
R14 g1199_4 8 2.224404
.ends

.subckt netg1586 g1586_1 g1586_0 gnd
C1  g1586_1 gnd 2.080806f
C2  g1586_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1586_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
R10 g1586_1 9 2.224404
.ends

.subckt netg1403 g1403_0 g1403_1 gnd
C1  g1403_0 gnd 2.080806f
C2  g1403_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1403_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
R10 g1403_1 9 2.224404
.ends

.subckt netg107 g107_1 g107_0 gnd
C1  g107_1 gnd 2.080806f
C2  g107_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g107_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 g107_1 9 2.224404
.ends

.subckt netg1097 g1097_1 g1097_0 gnd
C1  g1097_1 gnd 2.080806f
C2  g1097_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1097_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
R10 g1097_1 9 2.224404
.ends

.subckt netg2885 g2885_2 g2885_4 g2885_1 g2885_3 g2885_0 gnd
C1  g2885_2 gnd 2.080806f
C2  g2885_4 gnd 2.080806f
C3  g2885_1 gnd 2.080806f
C4  g2885_3 gnd 2.080806f
C5  g2885_0 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g2885_0 2.224404
R2 1 g2885_2 2.224404
C7 2 gnd 2.080806f
R3 g2885_0 2 2.224404
C8 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g2885_3 2.224404
C9 4 gnd 2.080806f
R6 g2885_3 4 2.224404
C10 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g2885_4 2.224404
C11 6 gnd 2.080806f
R9 6 1 2.224404
C12 7 gnd 2.080806f
R10 7 6 2.224404
R11 g2885_1 7 2.224404
.ends

.subckt netx492 x492_1 x492_0 gnd
C1  x492_1 gnd 2.080806f
C2  x492_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x492_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 9 x492_1 2.224404
.ends

.subckt netg6677 g6677_2 g6677_1 g6677_3 g6677_4 g6677_0 gnd
C1  g6677_2 gnd 2.080806f
C2  g6677_1 gnd 2.080806f
C3  g6677_3 gnd 2.080806f
C4  g6677_4 gnd 2.080806f
C5  g6677_0 gnd 2.080806f
R1 g6677_4 g6677_0 2.224404
C6 1 gnd 2.080806f
R2 g6677_4 1 2.224404
C7 2 gnd 2.080806f
R3 2 1 2.224404
C8 3 gnd 2.080806f
R4 2 3 2.224404
R5 g6677_2 3 2.224404
C9 4 gnd 2.080806f
R6 g6677_2 4 2.224404
R7 g6677_3 4 2.224404
C10 5 gnd 2.080806f
R8 g6677_0 5 2.224404
C11 6 gnd 2.080806f
R9 5 6 2.224404
C12 7 gnd 2.080806f
R10 6 7 2.224404
C13 8 gnd 2.080806f
R11 7 8 2.224404
R12 8 g6677_1 2.224404
.ends

.subckt netg5205 g5205_1 g5205_2 g5205_0 gnd
C1  g5205_1 gnd 2.080806f
C2  g5205_2 gnd 2.080806f
C3  g5205_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5205_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
R9 g5205_2 8 2.224404
R10 g5205_1 g5205_2 2.224404
.ends

.subckt netg4742 g4742_5 g4742_3 g4742_4 g4742_2 g4742_0 g4742_6 g4742_1 gnd
C1  g4742_5 gnd 2.080806f
C2  g4742_3 gnd 2.080806f
C3  g4742_4 gnd 2.080806f
C4  g4742_2 gnd 2.080806f
C5  g4742_0 gnd 2.080806f
C6  g4742_6 gnd 2.080806f
C7  g4742_1 gnd 2.080806f
R1 g4742_1 g4742_0 2.224404
C8 1 gnd 2.080806f
R2 g4742_0 1 2.224404
C9 2 gnd 2.080806f
R3 1 2 2.224404
C10 3 gnd 2.080806f
R4 3 2 2.224404
C11 4 gnd 2.080806f
R5 3 4 2.224404
R6 g4742_5 4 2.224404
R7 g4742_2 g4742_5 2.224404
R8 g4742_3 g4742_2 2.224404
R9 g4742_6 g4742_3 2.224404
C12 5 gnd 2.080806f
R10 5 g4742_6 2.224404
R11 g4742_4 5 2.224404
.ends

.subckt netg94 g94_1 g94_0 gnd
C1  g94_1 gnd 2.080806f
C2  g94_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g94_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
R10 g94_1 9 2.224404
.ends

.subckt netg1565 g1565_0 g1565_2 g1565_4 g1565_5 g1565_3 gnd
C1  g1565_0 gnd 2.080806f
C2  g1565_2 gnd 2.080806f
C3  g1565_4 gnd 2.080806f
C4  g1565_5 gnd 2.080806f
C5  g1565_3 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g1565_0 1 2.224404
R2 1 g1565_5 2.224404
C7 2 gnd 2.080806f
R3 2 g1565_0 2.224404
C8 3 gnd 2.080806f
R4 3 2 2.224404
C9 4 gnd 2.080806f
R5 4 3 2.224404
R6 g1565_2 4 2.224404
C10 5 gnd 2.080806f
R7 5 g1565_5 2.224404
C11 6 gnd 2.080806f
R8 6 5 2.224404
C12 7 gnd 2.080806f
R9 7 6 2.224404
R10 g1565_4 7 2.224404
C13 8 gnd 2.080806f
R11 g1565_4 8 2.224404
R12 8 g1565_3 2.224404
.ends

.subckt netg5493 g5493_0 g5493_2 g5493_1 gnd
C1  g5493_0 gnd 2.080806f
C2  g5493_2 gnd 2.080806f
C3  g5493_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5493_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5493_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 g5493_2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
R11 g5493_1 9 2.224404
.ends

.subckt netg767 g767_4 g767_2 g767_0 g767_1 g767_3 gnd
C1  g767_4 gnd 2.080806f
C2  g767_2 gnd 2.080806f
C3  g767_0 gnd 2.080806f
C4  g767_1 gnd 2.080806f
C5  g767_3 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g767_0 2.224404
C7 2 gnd 2.080806f
R2 2 1 2.224404
R3 g767_4 2 2.224404
C8 3 gnd 2.080806f
R4 g767_4 3 2.224404
R5 3 g767_1 2.224404
C9 4 gnd 2.080806f
R6 g767_0 4 2.224404
C10 5 gnd 2.080806f
R7 4 5 2.224404
C11 6 gnd 2.080806f
R8 5 6 2.224404
C12 7 gnd 2.080806f
R9 6 7 2.224404
R10 g767_3 7 2.224404
C13 8 gnd 2.080806f
R11 7 8 2.224404
C14 9 gnd 2.080806f
R12 8 9 2.224404
R13 9 g767_2 2.224404
.ends

.subckt netg1795 g1795_2 g1795_3 g1795_1 gnd
C1  g1795_2 gnd 2.080806f
C2  g1795_3 gnd 2.080806f
C3  g1795_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1795_3 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1795_2 2.224404
C6 3 gnd 2.080806f
R4 g1795_2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
R11 9 g1795_1 2.224404
.ends

.subckt netg5178 g5178_1 g5178_0 g5178_2 gnd
C1  g5178_1 gnd 2.080806f
C2  g5178_0 gnd 2.080806f
C3  g5178_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5178_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
R10 g5178_1 9 2.224404
R11 g5178_1 g5178_2 2.224404
.ends

.subckt netg2959 g2959_1 g2959_3 g2959_0 g2959_2 gnd
C1  g2959_1 gnd 2.080806f
C2  g2959_3 gnd 2.080806f
C3  g2959_0 gnd 2.080806f
C4  g2959_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2959_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2959_2 2 2.224404
C7 3 gnd 2.080806f
R4 3 g2959_2 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
R9 g2959_1 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
R11 8 g2959_3 2.224404
.ends

.subckt netg1766 g1766_3 g1766_2 g1766_1 g1766_0 gnd
C1  g1766_3 gnd 2.080806f
C2  g1766_2 gnd 2.080806f
C3  g1766_1 gnd 2.080806f
C4  g1766_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1766_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1766_3 4 2.224404
C9 5 gnd 2.080806f
R6 5 g1766_0 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
R11 9 g1766_2 2.224404
C14 10 gnd 2.080806f
R12 10 8 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
R14 g1766_1 11 2.224404
.ends

.subckt netg418 g418_3 g418_4 g418_2 g418_0 gnd
C1  g418_3 gnd 2.080806f
C2  g418_4 gnd 2.080806f
C3  g418_2 gnd 2.080806f
C4  g418_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g418_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
R6 g418_2 5 2.224404
C10 6 gnd 2.080806f
R7 6 g418_2 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
R9 g418_4 7 2.224404
C12 8 gnd 2.080806f
R10 8 g418_4 2.224404
R11 g418_3 8 2.224404
.ends

.subckt netg5395 g5395_0 g5395_4 g5395_2 g5395_1 g5395_5 g5395_3 g5395_6 g5395_8 g5395_7 gnd
C1  g5395_0 gnd 2.080806f
C2  g5395_4 gnd 2.080806f
C3  g5395_2 gnd 2.080806f
C4  g5395_1 gnd 2.080806f
C5  g5395_5 gnd 2.080806f
C6  g5395_3 gnd 2.080806f
C7  g5395_6 gnd 2.080806f
C8  g5395_8 gnd 2.080806f
C9  g5395_7 gnd 2.080806f
R1 g5395_0 g5395_2 2.224404
R2 g5395_1 g5395_2 2.224404
R3 g5395_2 g5395_5 2.224404
C10 1 gnd 2.080806f
R4 g5395_0 1 2.224404
R5 1 g5395_8 2.224404
R6 g5395_4 1 2.224404
C11 2 gnd 2.080806f
R7 2 g5395_8 2.224404
R8 2 g5395_7 2.224404
C12 3 gnd 2.080806f
R9 g5395_7 3 2.224404
C13 4 gnd 2.080806f
R10 3 4 2.224404
C14 5 gnd 2.080806f
R11 4 5 2.224404
R12 5 g5395_6 2.224404
C15 6 gnd 2.080806f
R13 5 6 2.224404
R14 6 g5395_3 2.224404
.ends

.subckt netg1295 g1295_4 g1295_2 g1295_1 g1295_6 g1295_0 g1295_5 g1295_3 gnd
C1  g1295_4 gnd 2.080806f
C2  g1295_2 gnd 2.080806f
C3  g1295_1 gnd 2.080806f
C4  g1295_6 gnd 2.080806f
C5  g1295_0 gnd 2.080806f
C6  g1295_5 gnd 2.080806f
C7  g1295_3 gnd 2.080806f
.ends

.subckt netx542 x542_1 x542_0 gnd
C1  x542_1 gnd 2.080806f
C2  x542_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 x542_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
R11 x542_1 10 2.224404
.ends

.subckt netg1778 g1778_0 g1778_3 g1778_1 g1778_2 gnd
C1  g1778_0 gnd 2.080806f
C2  g1778_3 gnd 2.080806f
C3  g1778_1 gnd 2.080806f
C4  g1778_2 gnd 2.080806f
R1 g1778_3 g1778_0 2.224404
C5 1 gnd 2.080806f
R2 g1778_3 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
R7 g1778_1 5 2.224404
C10 6 gnd 2.080806f
R8 6 g1778_1 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
R13 g1778_2 10 2.224404
.ends

.subckt netg2038 g2038_0 g2038_3 g2038_5 g2038_4 g2038_2 g2038_1 gnd
C1  g2038_0 gnd 2.080806f
C2  g2038_3 gnd 2.080806f
C3  g2038_5 gnd 2.080806f
C4  g2038_4 gnd 2.080806f
C5  g2038_2 gnd 2.080806f
C6  g2038_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2038_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2038_3 2 2.224404
C9 3 gnd 2.080806f
R4 g2038_0 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g2038_4 2.224404
C11 5 gnd 2.080806f
R7 1 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g2038_5 2.224404
C14 8 gnd 2.080806f
R11 g2038_5 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
R13 9 g2038_1 2.224404
C16 10 gnd 2.080806f
R14 10 9 2.224404
R15 g2038_2 10 2.224404
.ends

.subckt netg734 g734_1 g734_5 g734_4 g734_2 g734_0 gnd
C1  g734_1 gnd 2.080806f
C2  g734_5 gnd 2.080806f
C3  g734_4 gnd 2.080806f
C4  g734_2 gnd 2.080806f
C5  g734_0 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g734_0 2.224404
C7 2 gnd 2.080806f
R2 2 1 2.224404
C8 3 gnd 2.080806f
R3 3 2 2.224404
R4 g734_1 3 2.224404
R5 3 g734_2 2.224404
C9 4 gnd 2.080806f
R6 g734_0 4 2.224404
C10 5 gnd 2.080806f
R7 4 5 2.224404
C11 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g734_4 2.224404
C12 7 gnd 2.080806f
R10 6 7 2.224404
C13 8 gnd 2.080806f
R11 7 8 2.224404
R12 8 g734_5 2.224404
.ends

.subckt netg1269 g1269_2 g1269_4 g1269_5 g1269_3 g1269_0 g1269_1 gnd
C1  g1269_2 gnd 2.080806f
C2  g1269_4 gnd 2.080806f
C3  g1269_5 gnd 2.080806f
C4  g1269_3 gnd 2.080806f
C5  g1269_0 gnd 2.080806f
C6  g1269_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1269_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1269_2 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g1269_5 2.224404
C11 5 gnd 2.080806f
R7 g1269_5 5 2.224404
R8 5 g1269_3 2.224404
C12 6 gnd 2.080806f
R9 g1269_3 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
R12 8 g1269_4 2.224404
R13 g1269_4 g1269_1 2.224404
.ends

.subckt netg1608 g1608_3 g1608_0 g1608_1 g1608_2 gnd
C1  g1608_3 gnd 2.080806f
C2  g1608_0 gnd 2.080806f
C3  g1608_1 gnd 2.080806f
C4  g1608_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1608_0 2.224404
R2 1 g1608_3 2.224404
C6 2 gnd 2.080806f
R3 g1608_0 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
R10 g1608_2 8 2.224404
R11 g1608_2 g1608_1 2.224404
.ends

.subckt netg1957 g1957_0 g1957_1 g1957_2 gnd
C1  g1957_0 gnd 2.080806f
C2  g1957_1 gnd 2.080806f
C3  g1957_2 gnd 2.080806f
R1 g1957_2 g1957_0 2.224404
C4 1 gnd 2.080806f
R2 1 g1957_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
R11 g1957_1 9 2.224404
.ends

.subckt netg1799 g1799_1 g1799_0 g1799_2 g1799_3 gnd
C1  g1799_1 gnd 2.080806f
C2  g1799_0 gnd 2.080806f
C3  g1799_2 gnd 2.080806f
C4  g1799_3 gnd 2.080806f
R1 g1799_3 g1799_0 2.224404
C5 1 gnd 2.080806f
R2 1 g1799_3 2.224404
C6 2 gnd 2.080806f
R3 2 1 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
R8 g1799_1 6 2.224404
C11 7 gnd 2.080806f
R9 7 g1799_1 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
R11 g1799_2 8 2.224404
.ends

.subckt netg7535 g7535_1 g7535_0 gnd
C1  g7535_1 gnd 2.080806f
C2  g7535_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7535_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
R11 g7535_1 10 2.224404
.ends

.subckt netg1624 g1624_1 g1624_2 g1624_3 g1624_0 gnd
C1  g1624_1 gnd 2.080806f
C2  g1624_2 gnd 2.080806f
C3  g1624_3 gnd 2.080806f
C4  g1624_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1624_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1624_2 3 2.224404
C8 4 gnd 2.080806f
R5 g1624_0 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g1624_1 2.224404
C12 8 gnd 2.080806f
R10 8 g1624_2 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
R15 12 g1624_3 2.224404
.ends

.subckt netg106 g106_0 g106_1 gnd
C1  g106_0 gnd 2.080806f
C2  g106_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g106_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
R11 10 g106_1 2.224404
.ends

.subckt netg1913 g1913_1 g1913_0 gnd
C1  g1913_1 gnd 2.080806f
C2  g1913_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1913_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
R11 10 g1913_1 2.224404
.ends

.subckt netg2029 g2029_3 g2029_2 g2029_1 g2029_0 gnd
C1  g2029_3 gnd 2.080806f
C2  g2029_2 gnd 2.080806f
C3  g2029_1 gnd 2.080806f
C4  g2029_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2029_0 2.224404
R2 g2029_2 1 2.224404
C6 2 gnd 2.080806f
R3 g2029_0 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g2029_1 2.224404
C11 7 gnd 2.080806f
R9 7 g2029_1 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g2029_3 2.224404
.ends

.subckt netg2322 g2322_2 g2322_0 g2322_1 g2322_3 gnd
C1  g2322_2 gnd 2.080806f
C2  g2322_0 gnd 2.080806f
C3  g2322_1 gnd 2.080806f
C4  g2322_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2322_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g2322_3 2.224404
R8 g2322_3 g2322_1 2.224404
C11 7 gnd 2.080806f
R9 g2322_1 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
R11 8 g2322_2 2.224404
.ends

.subckt netg4508 g4508_8 g4508_0 g4508_9 g4508_5 g4508_10 g4508_7 g4508_6 g4508_3 g4508_2 g4508_1 g4508_4 gnd
C1  g4508_8 gnd 2.080806f
C2  g4508_0 gnd 2.080806f
C3  g4508_9 gnd 2.080806f
C4  g4508_5 gnd 2.080806f
C5  g4508_10 gnd 2.080806f
C6  g4508_7 gnd 2.080806f
C7  g4508_6 gnd 2.080806f
C8  g4508_3 gnd 2.080806f
C9  g4508_2 gnd 2.080806f
C10  g4508_1 gnd 2.080806f
C11  g4508_4 gnd 2.080806f
C12 1 gnd 2.080806f
R1 1 g4508_0 2.224404
R2 1 g4508_7 2.224404
C13 2 gnd 2.080806f
R3 g4508_0 2 2.224404
R4 g4508_8 2 2.224404
R5 g4508_10 1 2.224404
C14 3 gnd 2.080806f
R6 g4508_7 3 2.224404
R7 3 g4508_2 2.224404
C15 4 gnd 2.080806f
R8 g4508_0 4 2.224404
R9 4 g4508_9 2.224404
R10 g4508_9 g4508_5 2.224404
C16 5 gnd 2.080806f
R11 5 g4508_0 2.224404
C17 6 gnd 2.080806f
R12 6 5 2.224404
R13 g4508_6 6 2.224404
C18 7 gnd 2.080806f
R14 7 g4508_6 2.224404
R15 g4508_1 7 2.224404
R16 g4508_3 7 2.224404
C19 8 gnd 2.080806f
R17 8 g4508_6 2.224404
R18 g4508_4 8 2.224404
.ends

.subckt netg4669 g4669_0 g4669_2 g4669_5 g4669_3 g4669_4 g4669_1 g4669_6 gnd
C1  g4669_0 gnd 2.080806f
C2  g4669_2 gnd 2.080806f
C3  g4669_5 gnd 2.080806f
C4  g4669_3 gnd 2.080806f
C5  g4669_4 gnd 2.080806f
C6  g4669_1 gnd 2.080806f
C7  g4669_6 gnd 2.080806f
R1 g4669_6 g4669_0 2.224404
C8 1 gnd 2.080806f
R2 1 g4669_6 2.224404
R3 g4669_3 1 2.224404
R4 g4669_4 1 2.224404
C9 2 gnd 2.080806f
R5 g4669_3 2 2.224404
R6 g4669_5 2 2.224404
C10 3 gnd 2.080806f
R7 3 g4669_4 2.224404
C11 4 gnd 2.080806f
R8 4 3 2.224404
C12 5 gnd 2.080806f
R9 4 5 2.224404
C13 6 gnd 2.080806f
R10 5 6 2.224404
R11 6 g4669_1 2.224404
C14 7 gnd 2.080806f
R12 g4669_1 7 2.224404
C15 8 gnd 2.080806f
R13 7 8 2.224404
R14 8 g4669_2 2.224404
.ends

.subckt netg6046 g6046_1 g6046_0 gnd
C1  g6046_1 gnd 2.080806f
C2  g6046_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6046_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
R11 g6046_1 10 2.224404
.ends

.subckt netg3928 g3928_4 g3928_3 g3928_7 g3928_6 g3928_0 g3928_1 g3928_2 g3928_5 gnd
C1  g3928_4 gnd 2.080806f
C2  g3928_3 gnd 2.080806f
C3  g3928_7 gnd 2.080806f
C4  g3928_6 gnd 2.080806f
C5  g3928_0 gnd 2.080806f
C6  g3928_1 gnd 2.080806f
C7  g3928_2 gnd 2.080806f
C8  g3928_5 gnd 2.080806f
R1 g3928_0 g3928_1 2.224404
C9 1 gnd 2.080806f
R2 g3928_0 1 2.224404
R3 g3928_3 1 2.224404
C10 2 gnd 2.080806f
R4 g3928_1 2 2.224404
R5 2 g3928_6 2.224404
C11 3 gnd 2.080806f
R6 3 g3928_3 2.224404
C12 4 gnd 2.080806f
R7 4 3 2.224404
C13 5 gnd 2.080806f
R8 5 4 2.224404
R9 g3928_5 5 2.224404
R10 g3928_2 5 2.224404
C14 6 gnd 2.080806f
R11 1 6 2.224404
C15 7 gnd 2.080806f
R12 6 7 2.224404
R13 7 g3928_4 2.224404
C16 8 gnd 2.080806f
R14 8 g3928_4 2.224404
C17 9 gnd 2.080806f
R15 9 8 2.224404
R16 g3928_7 9 2.224404
.ends

.subckt netg3020 g3020_3 g3020_1 g3020_0 g3020_2 gnd
C1  g3020_3 gnd 2.080806f
C2  g3020_1 gnd 2.080806f
C3  g3020_0 gnd 2.080806f
C4  g3020_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g3020_0 1 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 g3020_1 3 2.224404
C8 4 gnd 2.080806f
R5 4 g3020_1 2.224404
R6 g3020_3 4 2.224404
C9 5 gnd 2.080806f
R7 5 g3020_3 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
R13 g3020_2 10 2.224404
.ends

.subckt netg4324 g4324_0 g4324_2 g4324_3 g4324_1 gnd
C1  g4324_0 gnd 2.080806f
C2  g4324_2 gnd 2.080806f
C3  g4324_3 gnd 2.080806f
C4  g4324_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4324_0 1 2.224404
R2 1 g4324_1 2.224404
C6 2 gnd 2.080806f
R3 2 g4324_0 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
R5 g4324_3 3 2.224404
C8 4 gnd 2.080806f
R6 g4324_3 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
R13 g4324_2 10 2.224404
.ends

.subckt netg6704 g6704_1 g6704_0 gnd
C1  g6704_1 gnd 2.080806f
C2  g6704_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6704_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
R11 g6704_1 10 2.224404
.ends

.subckt netg1117 g1117_0 g1117_1 gnd
C1  g1117_0 gnd 2.080806f
C2  g1117_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1117_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
R11 10 g1117_1 2.224404
.ends

.subckt netg5381 g5381_0 g5381_2 g5381_3 g5381_1 gnd
C1  g5381_0 gnd 2.080806f
C2  g5381_2 gnd 2.080806f
C3  g5381_3 gnd 2.080806f
C4  g5381_1 gnd 2.080806f
R1 g5381_0 g5381_3 2.224404
C5 1 gnd 2.080806f
R2 1 g5381_3 2.224404
C6 2 gnd 2.080806f
R3 2 1 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g5381_1 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
R11 g5381_2 8 2.224404
.ends

.subckt netg1138 g1138_2 g1138_1 g1138_5 g1138_3 g1138_4 g1138_0 gnd
C1  g1138_2 gnd 2.080806f
C2  g1138_1 gnd 2.080806f
C3  g1138_5 gnd 2.080806f
C4  g1138_3 gnd 2.080806f
C5  g1138_4 gnd 2.080806f
C6  g1138_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1138_0 2.224404
R2 g1138_3 1 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g1138_4 2.224404
C10 4 gnd 2.080806f
R6 4 g1138_4 2.224404
C11 5 gnd 2.080806f
R7 5 4 2.224404
C12 6 gnd 2.080806f
R8 6 5 2.224404
R9 g1138_5 6 2.224404
C13 7 gnd 2.080806f
R10 g1138_5 7 2.224404
R11 g1138_1 7 2.224404
C14 8 gnd 2.080806f
R12 8 g1138_3 2.224404
C15 9 gnd 2.080806f
R13 9 8 2.224404
C16 10 gnd 2.080806f
R14 10 9 2.224404
C17 11 gnd 2.080806f
R15 11 10 2.224404
R16 g1138_2 11 2.224404
.ends

.subckt netg6711 g6711_0 g6711_1 gnd
C1  g6711_0 gnd 2.080806f
C2  g6711_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6711_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
R11 g6711_1 10 2.224404
.ends

.subckt netg6240 g6240_1 g6240_0 g6240_2 gnd
C1  g6240_1 gnd 2.080806f
C2  g6240_0 gnd 2.080806f
C3  g6240_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6240_0 1 2.224404
R2 g6240_2 1 2.224404
C5 2 gnd 2.080806f
R3 2 g6240_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
R12 g6240_1 10 2.224404
.ends

.subckt netg2406 g2406_1 g2406_0 g2406_2 gnd
C1  g2406_1 gnd 2.080806f
C2  g2406_0 gnd 2.080806f
C3  g2406_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2406_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2406_2 2.224404
C6 3 gnd 2.080806f
R4 3 g2406_2 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
R13 11 g2406_1 2.224404
.ends

.subckt netg3358 g3358_2 g3358_1 g3358_0 gnd
C1  g3358_2 gnd 2.080806f
C2  g3358_1 gnd 2.080806f
C3  g3358_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3358_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g3358_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 g3358_1 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
R11 g3358_2 9 2.224404
.ends

.subckt netg5253 g5253_0 g5253_3 g5253_4 g5253_2 g5253_1 gnd
C1  g5253_0 gnd 2.080806f
C2  g5253_3 gnd 2.080806f
C3  g5253_4 gnd 2.080806f
C4  g5253_2 gnd 2.080806f
C5  g5253_1 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g5253_0 2.224404
R2 g5253_4 1 2.224404
R3 g5253_4 g5253_1 2.224404
R4 g5253_3 g5253_4 2.224404
C7 2 gnd 2.080806f
R5 2 g5253_3 2.224404
C8 3 gnd 2.080806f
R6 3 2 2.224404
C9 4 gnd 2.080806f
R7 4 3 2.224404
C10 5 gnd 2.080806f
R8 5 4 2.224404
C11 6 gnd 2.080806f
R9 6 5 2.224404
C12 7 gnd 2.080806f
R10 7 6 2.224404
R11 g5253_2 7 2.224404
.ends

.subckt netg2008 g2008_2 g2008_3 g2008_1 g2008_0 g2008_4 gnd
C1  g2008_2 gnd 2.080806f
C2  g2008_3 gnd 2.080806f
C3  g2008_1 gnd 2.080806f
C4  g2008_0 gnd 2.080806f
C5  g2008_4 gnd 2.080806f
R1 g2008_0 g2008_3 2.224404
C6 1 gnd 2.080806f
R2 1 g2008_0 2.224404
C7 2 gnd 2.080806f
R3 2 1 2.224404
R4 g2008_2 2 2.224404
C8 3 gnd 2.080806f
R5 g2008_2 3 2.224404
C9 4 gnd 2.080806f
R6 3 4 2.224404
R7 g2008_4 4 2.224404
C10 5 gnd 2.080806f
R8 g2008_3 5 2.224404
C11 6 gnd 2.080806f
R9 5 6 2.224404
C12 7 gnd 2.080806f
R10 6 7 2.224404
R11 7 g2008_1 2.224404
.ends

.subckt netg1820 g1820_0 g1820_3 g1820_1 g1820_2 gnd
C1  g1820_0 gnd 2.080806f
C2  g1820_3 gnd 2.080806f
C3  g1820_1 gnd 2.080806f
C4  g1820_2 gnd 2.080806f
R1 g1820_0 g1820_2 2.224404
C5 1 gnd 2.080806f
R2 g1820_0 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g1820_1 2.224404
C11 7 gnd 2.080806f
R9 g1820_1 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g1820_3 2.224404
.ends

.subckt netg716 g716_4 g716_1 g716_0 g716_2 g716_3 gnd
C1  g716_4 gnd 2.080806f
C2  g716_1 gnd 2.080806f
C3  g716_0 gnd 2.080806f
C4  g716_2 gnd 2.080806f
C5  g716_3 gnd 2.080806f
R1 g716_3 g716_0 2.224404
R2 g716_0 g716_4 2.224404
C6 1 gnd 2.080806f
R3 g716_4 1 2.224404
C7 2 gnd 2.080806f
R4 1 2 2.224404
C8 3 gnd 2.080806f
R5 2 3 2.224404
R6 3 g716_1 2.224404
C9 4 gnd 2.080806f
R7 4 g716_1 2.224404
C10 5 gnd 2.080806f
R8 5 4 2.224404
C11 6 gnd 2.080806f
R9 6 5 2.224404
C12 7 gnd 2.080806f
R10 7 6 2.224404
C13 8 gnd 2.080806f
R11 8 7 2.224404
R12 8 g716_2 2.224404
.ends

.subckt netg5955 g5955_0 g5955_1 gnd
C1  g5955_0 gnd 2.080806f
C2  g5955_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5955_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g5955_1 2.224404
.ends

.subckt netg4443 g4443_0 g4443_1 g4443_2 gnd
C1  g4443_0 gnd 2.080806f
C2  g4443_1 gnd 2.080806f
C3  g4443_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4443_0 1 2.224404
R2 1 g4443_1 2.224404
C5 2 gnd 2.080806f
R3 2 g4443_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
R12 10 g4443_2 2.224404
.ends

.subckt netg1396 g1396_1 g1396_0 gnd
C1  g1396_1 gnd 2.080806f
C2  g1396_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1396_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
R12 g1396_1 11 2.224404
.ends

.subckt netg6340 g6340_3 g6340_0 g6340_2 g6340_1 gnd
C1  g6340_3 gnd 2.080806f
C2  g6340_0 gnd 2.080806f
C3  g6340_2 gnd 2.080806f
C4  g6340_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g6340_0 1 2.224404
R2 1 g6340_3 2.224404
C6 2 gnd 2.080806f
R3 g6340_3 2 2.224404
R4 2 g6340_2 2.224404
C7 3 gnd 2.080806f
R5 g6340_2 3 2.224404
C8 4 gnd 2.080806f
R6 3 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g6340_1 2.224404
.ends

.subckt netg93 g93_0 g93_1 gnd
C1  g93_0 gnd 2.080806f
C2  g93_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g93_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 g93_1 11 2.224404
.ends

.subckt netg4380 g4380_2 g4380_1 g4380_0 gnd
C1  g4380_2 gnd 2.080806f
C2  g4380_1 gnd 2.080806f
C3  g4380_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4380_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g4380_2 2.224404
C10 7 gnd 2.080806f
R8 g4380_2 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
R12 10 g4380_1 2.224404
.ends

.subckt netg5166 g5166_0 g5166_1 gnd
C1  g5166_0 gnd 2.080806f
C2  g5166_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5166_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
R12 g5166_1 11 2.224404
.ends

.subckt netg1675 g1675_2 g1675_3 g1675_0 g1675_1 gnd
C1  g1675_2 gnd 2.080806f
C2  g1675_3 gnd 2.080806f
C3  g1675_0 gnd 2.080806f
C4  g1675_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1675_0 1 2.224404
R2 1 g1675_1 2.224404
C6 2 gnd 2.080806f
R3 g1675_1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g1675_3 2.224404
C9 5 gnd 2.080806f
R7 g1675_3 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g1675_2 2.224404
.ends

.subckt netg1895 g1895_0 g1895_1 gnd
C1  g1895_0 gnd 2.080806f
C2  g1895_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1895_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
R12 g1895_1 11 2.224404
.ends

.subckt netg84 g84_1 g84_0 gnd
C1  g84_1 gnd 2.080806f
C2  g84_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g84_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
R12 g84_1 11 2.224404
.ends

.subckt netg91 g91_1 g91_0 gnd
C1  g91_1 gnd 2.080806f
C2  g91_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g91_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g91_1 2.224404
.ends

.subckt netg1409 g1409_0 g1409_1 gnd
C1  g1409_0 gnd 2.080806f
C2  g1409_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1409_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g1409_1 2.224404
.ends

.subckt netg2963 g2963_2 g2963_0 g2963_1 g2963_4 g2963_5 gnd
C1  g2963_2 gnd 2.080806f
C2  g2963_0 gnd 2.080806f
C3  g2963_1 gnd 2.080806f
C4  g2963_4 gnd 2.080806f
C5  g2963_5 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g2963_0 2.224404
R2 g2963_4 1 2.224404
C7 2 gnd 2.080806f
R3 2 g2963_0 2.224404
C8 3 gnd 2.080806f
R4 3 2 2.224404
R5 g2963_2 3 2.224404
C9 4 gnd 2.080806f
R6 4 g2963_2 2.224404
C10 5 gnd 2.080806f
R7 5 4 2.224404
C11 6 gnd 2.080806f
R8 5 6 2.224404
R9 g2963_5 6 2.224404
C12 7 gnd 2.080806f
R10 7 g2963_5 2.224404
C13 8 gnd 2.080806f
R11 8 7 2.224404
C14 9 gnd 2.080806f
R12 9 8 2.224404
C15 10 gnd 2.080806f
R13 10 9 2.224404
R14 g2963_1 10 2.224404
.ends

.subckt netg5848 g5848_1 g5848_3 g5848_2 g5848_0 gnd
C1  g5848_1 gnd 2.080806f
C2  g5848_3 gnd 2.080806f
C3  g5848_2 gnd 2.080806f
C4  g5848_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g5848_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5848_2 2 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
R6 g5848_1 4 2.224404
C9 5 gnd 2.080806f
R7 5 g5848_1 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
R13 g5848_3 10 2.224404
.ends

.subckt netg5208 g5208_2 g5208_1 g5208_0 gnd
C1  g5208_2 gnd 2.080806f
C2  g5208_1 gnd 2.080806f
C3  g5208_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5208_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5208_1 2 2.224404
C6 3 gnd 2.080806f
R4 3 g5208_1 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
R13 g5208_2 11 2.224404
.ends

.subckt netg7408 g7408_0 g7408_1 gnd
C1  g7408_0 gnd 2.080806f
C2  g7408_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7408_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g7408_1 2.224404
.ends

.subckt netg2798 g2798_0 g2798_1 gnd
C1  g2798_0 gnd 2.080806f
C2  g2798_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2798_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
R16 g2798_1 15 2.224404
.ends

.subckt netg2969 g2969_4 g2969_1 g2969_2 g2969_6 g2969_3 g2969_5 gnd
C1  g2969_4 gnd 2.080806f
C2  g2969_1 gnd 2.080806f
C3  g2969_2 gnd 2.080806f
C4  g2969_6 gnd 2.080806f
C5  g2969_3 gnd 2.080806f
C6  g2969_5 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2969_2 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2969_3 2 2.224404
C9 3 gnd 2.080806f
R4 3 g2969_3 2.224404
R5 g2969_5 3 2.224404
C10 4 gnd 2.080806f
R6 1 4 2.224404
R7 4 g2969_6 2.224404
C11 5 gnd 2.080806f
R8 5 g2969_5 2.224404
C12 6 gnd 2.080806f
R9 6 5 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
R11 g2969_4 7 2.224404
C14 8 gnd 2.080806f
R12 g2969_4 8 2.224404
R13 g2969_1 8 2.224404
.ends

.subckt netg4485 g4485_2 g4485_5 g4485_0 g4485_4 g4485_1 g4485_3 gnd
C1  g4485_2 gnd 2.080806f
C2  g4485_5 gnd 2.080806f
C3  g4485_0 gnd 2.080806f
C4  g4485_4 gnd 2.080806f
C5  g4485_1 gnd 2.080806f
C6  g4485_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g4485_0 2.224404
R2 g4485_4 1 2.224404
C8 2 gnd 2.080806f
R3 g4485_0 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g4485_2 2.224404
R8 g4485_2 g4485_3 2.224404
C12 6 gnd 2.080806f
R9 g4485_3 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
R12 8 g4485_5 2.224404
C15 9 gnd 2.080806f
R13 9 8 2.224404
C16 10 gnd 2.080806f
R14 10 9 2.224404
R15 g4485_1 10 2.224404
.ends

.subckt netg5809 g5809_3 g5809_1 g5809_0 g5809_2 gnd
C1  g5809_3 gnd 2.080806f
C2  g5809_1 gnd 2.080806f
C3  g5809_0 gnd 2.080806f
C4  g5809_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g5809_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g5809_2 2.224404
C11 7 gnd 2.080806f
R8 g5809_2 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
R11 9 g5809_1 2.224404
R12 g5809_1 g5809_3 2.224404
.ends

.subckt netg1919 g1919_1 g1919_0 gnd
C1  g1919_1 gnd 2.080806f
C2  g1919_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1919_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g1919_1 2.224404
.ends

.subckt netg5471 g5471_1 g5471_2 g5471_0 gnd
C1  g5471_1 gnd 2.080806f
C2  g5471_2 gnd 2.080806f
C3  g5471_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5471_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5471_2 2.224404
C6 3 gnd 2.080806f
R4 g5471_2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
R12 10 g5471_1 2.224404
.ends

.subckt netg2159 g2159_3 g2159_0 g2159_1 g2159_2 gnd
C1  g2159_3 gnd 2.080806f
C2  g2159_0 gnd 2.080806f
C3  g2159_1 gnd 2.080806f
C4  g2159_2 gnd 2.080806f
R1 g2159_0 g2159_3 2.224404
C5 1 gnd 2.080806f
R2 g2159_3 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g2159_1 2.224404
C12 8 gnd 2.080806f
R10 8 g2159_1 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
R12 9 g2159_2 2.224404
.ends

.subckt netg828 g828_6 g828_4 g828_3 g828_0 g828_2 g828_5 g828_1 gnd
C1  g828_6 gnd 2.080806f
C2  g828_4 gnd 2.080806f
C3  g828_3 gnd 2.080806f
C4  g828_0 gnd 2.080806f
C5  g828_2 gnd 2.080806f
C6  g828_5 gnd 2.080806f
C7  g828_1 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g828_0 2.224404
R2 g828_3 1 2.224404
R3 g828_2 g828_3 2.224404
C9 2 gnd 2.080806f
R4 2 g828_3 2.224404
C10 3 gnd 2.080806f
R5 3 2 2.224404
R6 g828_6 3 2.224404
R7 g828_4 g828_6 2.224404
C11 4 gnd 2.080806f
R8 4 g828_4 2.224404
C12 5 gnd 2.080806f
R9 5 4 2.224404
C13 6 gnd 2.080806f
R10 6 5 2.224404
C14 7 gnd 2.080806f
R11 7 6 2.224404
R12 g828_1 7 2.224404
C15 8 gnd 2.080806f
R13 8 g828_2 2.224404
C16 9 gnd 2.080806f
R14 9 8 2.224404
C17 10 gnd 2.080806f
R15 10 9 2.224404
C18 11 gnd 2.080806f
R16 11 10 2.224404
C19 12 gnd 2.080806f
R17 11 12 2.224404
R18 g828_5 12 2.224404
.ends

.subckt netg6565 g6565_0 g6565_1 g6565_2 gnd
C1  g6565_0 gnd 2.080806f
C2  g6565_1 gnd 2.080806f
C3  g6565_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6565_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6565_1 2.224404
C7 4 gnd 2.080806f
R5 g6565_0 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
R13 11 g6565_2 2.224404
.ends

.subckt netg1770 g1770_0 g1770_2 g1770_1 g1770_3 gnd
C1  g1770_0 gnd 2.080806f
C2  g1770_2 gnd 2.080806f
C3  g1770_1 gnd 2.080806f
C4  g1770_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1770_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1770_3 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
R6 g1770_1 4 2.224404
C9 5 gnd 2.080806f
R7 5 g1770_1 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
R13 10 g1770_2 2.224404
.ends

.subckt netg1578 g1578_1 g1578_0 gnd
C1  g1578_1 gnd 2.080806f
C2  g1578_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1578_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g1578_1 2.224404
.ends

.subckt netg114 g114_0 g114_1 gnd
C1  g114_0 gnd 2.080806f
C2  g114_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g114_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 g114_1 11 2.224404
.ends

.subckt netg1411 g1411_6 g1411_1 g1411_5 g1411_8 g1411_4 g1411_0 g1411_9 g1411_2 g1411_7 g1411_3 gnd
C1  g1411_6 gnd 2.080806f
C2  g1411_1 gnd 2.080806f
C3  g1411_5 gnd 2.080806f
C4  g1411_8 gnd 2.080806f
C5  g1411_4 gnd 2.080806f
C6  g1411_0 gnd 2.080806f
C7  g1411_9 gnd 2.080806f
C8  g1411_2 gnd 2.080806f
C9  g1411_7 gnd 2.080806f
C10  g1411_3 gnd 2.080806f
C11 1 gnd 2.080806f
R1 1 g1411_0 2.224404
R2 g1411_7 1 2.224404
R3 g1411_7 g1411_1 2.224404
R4 g1411_6 g1411_7 2.224404
C12 2 gnd 2.080806f
R5 2 g1411_7 2.224404
R6 g1411_9 2 2.224404
C13 3 gnd 2.080806f
R7 3 g1411_9 2.224404
R8 g1411_5 3 2.224404
C14 4 gnd 2.080806f
R9 g1411_1 4 2.224404
C15 5 gnd 2.080806f
R10 4 5 2.224404
R11 5 g1411_2 2.224404
C16 6 gnd 2.080806f
R12 g1411_2 6 2.224404
R13 6 g1411_3 2.224404
R14 6 g1411_4 2.224404
C17 7 gnd 2.080806f
R15 g1411_3 7 2.224404
R16 g1411_8 7 2.224404
.ends

.subckt netg5515 g5515_1 g5515_2 g5515_3 g5515_0 gnd
C1  g5515_1 gnd 2.080806f
C2  g5515_2 gnd 2.080806f
C3  g5515_3 gnd 2.080806f
C4  g5515_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g5515_0 2.224404
R2 g5515_2 1 2.224404
C6 2 gnd 2.080806f
R3 g5515_2 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g5515_3 2.224404
C8 4 gnd 2.080806f
R6 4 g5515_3 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
R12 g5515_1 9 2.224404
.ends

.subckt netg3883 g3883_0 g3883_6 g3883_2 g3883_1 g3883_5 g3883_3 g3883_4 gnd
C1  g3883_0 gnd 2.080806f
C2  g3883_6 gnd 2.080806f
C3  g3883_2 gnd 2.080806f
C4  g3883_1 gnd 2.080806f
C5  g3883_5 gnd 2.080806f
C6  g3883_3 gnd 2.080806f
C7  g3883_4 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g3883_0 2.224404
R2 g3883_1 1 2.224404
C9 2 gnd 2.080806f
R3 g3883_0 2 2.224404
R4 2 g3883_2 2.224404
C10 3 gnd 2.080806f
R5 g3883_1 3 2.224404
C11 4 gnd 2.080806f
R6 3 4 2.224404
C12 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g3883_3 2.224404
C13 6 gnd 2.080806f
R9 6 g3883_0 2.224404
C14 7 gnd 2.080806f
R10 7 6 2.224404
C15 8 gnd 2.080806f
R11 8 7 2.224404
R12 g3883_4 8 2.224404
C16 9 gnd 2.080806f
R13 9 g3883_4 2.224404
R14 g3883_5 9 2.224404
C17 10 gnd 2.080806f
R15 10 g3883_4 2.224404
R16 g3883_6 10 2.224404
.ends

.subckt netg112 g112_1 g112_0 gnd
C1  g112_1 gnd 2.080806f
C2  g112_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g112_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g112_1 2.224404
.ends

.subckt netg1899 g1899_1 g1899_0 gnd
C1  g1899_1 gnd 2.080806f
C2  g1899_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1899_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
R14 g1899_1 13 2.224404
.ends

.subckt netg2405 g2405_0 g2405_1 gnd
C1  g2405_0 gnd 2.080806f
C2  g2405_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2405_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g2405_1 2.224404
.ends

.subckt netg4687 g4687_8 g4687_0 g4687_1 g4687_2 g4687_4 g4687_5 g4687_10 g4687_9 g4687_6 g4687_7 g4687_3 gnd
C1  g4687_8 gnd 2.080806f
C2  g4687_0 gnd 2.080806f
C3  g4687_1 gnd 2.080806f
C4  g4687_2 gnd 2.080806f
C5  g4687_4 gnd 2.080806f
C6  g4687_5 gnd 2.080806f
C7  g4687_10 gnd 2.080806f
C8  g4687_9 gnd 2.080806f
C9  g4687_6 gnd 2.080806f
C10  g4687_7 gnd 2.080806f
C11  g4687_3 gnd 2.080806f
R1 g4687_6 g4687_0 2.224404
R2 g4687_6 g4687_8 2.224404
R3 g4687_8 g4687_9 2.224404
R4 g4687_9 g4687_10 2.224404
C12 1 gnd 2.080806f
R5 g4687_10 1 2.224404
R6 1 g4687_4 2.224404
C13 2 gnd 2.080806f
R7 2 g4687_4 2.224404
C14 3 gnd 2.080806f
R8 3 2 2.224404
R9 g4687_5 3 2.224404
C15 4 gnd 2.080806f
R10 3 4 2.224404
R11 4 g4687_2 2.224404
C16 5 gnd 2.080806f
R12 g4687_2 5 2.224404
C17 6 gnd 2.080806f
R13 5 6 2.224404
R14 6 g4687_1 2.224404
C18 7 gnd 2.080806f
R15 7 g4687_1 2.224404
R16 7 g4687_3 2.224404
R17 g4687_3 g4687_7 2.224404
.ends

.subckt netg2859 g2859_0 g2859_4 g2859_1 g2859_6 g2859_2 g2859_5 g2859_3 gnd
C1  g2859_0 gnd 2.080806f
C2  g2859_4 gnd 2.080806f
C3  g2859_1 gnd 2.080806f
C4  g2859_6 gnd 2.080806f
C5  g2859_2 gnd 2.080806f
C6  g2859_5 gnd 2.080806f
C7  g2859_3 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g2859_0 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
C10 3 gnd 2.080806f
R3 3 2 2.224404
C11 4 gnd 2.080806f
R4 4 3 2.224404
R5 g2859_6 4 2.224404
R6 g2859_2 g2859_6 2.224404
C12 5 gnd 2.080806f
R7 5 g2859_2 2.224404
C13 6 gnd 2.080806f
R8 6 5 2.224404
C14 7 gnd 2.080806f
R9 7 6 2.224404
R10 g2859_1 7 2.224404
R11 g2859_3 7 2.224404
C15 8 gnd 2.080806f
R12 8 g2859_1 2.224404
R13 g2859_4 8 2.224404
C16 9 gnd 2.080806f
R14 9 5 2.224404
C17 10 gnd 2.080806f
R15 10 9 2.224404
R16 g2859_5 10 2.224404
.ends

.subckt netg740 g740_2 g740_5 g740_6 g740_3 g740_0 g740_1 g740_4 gnd
C1  g740_2 gnd 2.080806f
C2  g740_5 gnd 2.080806f
C3  g740_6 gnd 2.080806f
C4  g740_3 gnd 2.080806f
C5  g740_0 gnd 2.080806f
C6  g740_1 gnd 2.080806f
C7  g740_4 gnd 2.080806f
R1 g740_5 g740_0 2.224404
R2 g740_5 g740_4 2.224404
C8 1 gnd 2.080806f
R3 1 g740_5 2.224404
C9 2 gnd 2.080806f
R4 2 1 2.224404
C10 3 gnd 2.080806f
R5 3 2 2.224404
R6 g740_2 3 2.224404
C11 4 gnd 2.080806f
R7 4 g740_2 2.224404
C12 5 gnd 2.080806f
R8 5 4 2.224404
R9 g740_1 5 2.224404
C13 6 gnd 2.080806f
R10 g740_4 6 2.224404
C14 7 gnd 2.080806f
R11 6 7 2.224404
C15 8 gnd 2.080806f
R12 7 8 2.224404
C16 9 gnd 2.080806f
R13 8 9 2.224404
R14 9 g740_6 2.224404
C17 10 gnd 2.080806f
R15 10 g740_6 2.224404
C18 11 gnd 2.080806f
R16 11 10 2.224404
C19 12 gnd 2.080806f
R17 12 11 2.224404
R18 g740_3 12 2.224404
.ends

.subckt netg6202 g6202_1 g6202_0 gnd
C1  g6202_1 gnd 2.080806f
C2  g6202_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6202_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
R13 g6202_1 12 2.224404
.ends

.subckt netg2398 g2398_2 g2398_0 g2398_1 gnd
C1  g2398_2 gnd 2.080806f
C2  g2398_0 gnd 2.080806f
C3  g2398_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2398_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 g2398_2 3 2.224404
C7 4 gnd 2.080806f
R5 4 g2398_2 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
R15 g2398_1 13 2.224404
.ends

.subckt netg1092 g1092_2 g1092_1 g1092_0 g1092_3 gnd
C1  g1092_2 gnd 2.080806f
C2  g1092_1 gnd 2.080806f
C3  g1092_0 gnd 2.080806f
C4  g1092_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1092_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1092_3 2.224404
C8 4 gnd 2.080806f
R5 g1092_0 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
R12 10 g1092_1 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
R18 15 g1092_2 2.224404
.ends

.subckt netg1212 g1212_4 g1212_0 g1212_3 g1212_2 g1212_5 g1212_6 g1212_1 gnd
C1  g1212_4 gnd 2.080806f
C2  g1212_0 gnd 2.080806f
C3  g1212_3 gnd 2.080806f
C4  g1212_2 gnd 2.080806f
C5  g1212_5 gnd 2.080806f
C6  g1212_6 gnd 2.080806f
C7  g1212_1 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g1212_0 2.224404
R2 g1212_2 1 2.224404
C9 2 gnd 2.080806f
R3 g1212_0 2 2.224404
R4 2 g1212_6 2.224404
C10 3 gnd 2.080806f
R5 3 g1212_6 2.224404
R6 g1212_4 3 2.224404
R7 g1212_5 g1212_4 2.224404
C11 4 gnd 2.080806f
R8 g1212_0 4 2.224404
C12 5 gnd 2.080806f
R9 4 5 2.224404
C13 6 gnd 2.080806f
R10 5 6 2.224404
R11 6 g1212_3 2.224404
C14 7 gnd 2.080806f
R12 g1212_3 7 2.224404
C15 8 gnd 2.080806f
R13 7 8 2.224404
C16 9 gnd 2.080806f
R14 8 9 2.224404
C17 10 gnd 2.080806f
R15 9 10 2.224404
R16 10 g1212_1 2.224404
.ends

.subckt netg1918 g1918_1 g1918_0 gnd
C1  g1918_1 gnd 2.080806f
C2  g1918_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1918_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
R13 g1918_1 12 2.224404
.ends

.subckt netg7550 g7550_0 g7550_1 gnd
C1  g7550_0 gnd 2.080806f
C2  g7550_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7550_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
R13 g7550_1 12 2.224404
.ends

.subckt netg6765 g6765_4 g6765_5 g6765_1 g6765_2 g6765_0 g6765_3 gnd
C1  g6765_4 gnd 2.080806f
C2  g6765_5 gnd 2.080806f
C3  g6765_1 gnd 2.080806f
C4  g6765_2 gnd 2.080806f
C5  g6765_0 gnd 2.080806f
C6  g6765_3 gnd 2.080806f
R1 g6765_0 g6765_5 2.224404
C7 1 gnd 2.080806f
R2 1 g6765_0 2.224404
R3 g6765_2 1 2.224404
C8 2 gnd 2.080806f
R4 g6765_5 2 2.224404
C9 3 gnd 2.080806f
R5 2 3 2.224404
R6 3 g6765_3 2.224404
C10 4 gnd 2.080806f
R7 4 g6765_3 2.224404
C11 5 gnd 2.080806f
R8 4 5 2.224404
C12 6 gnd 2.080806f
R9 6 5 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
R12 8 g6765_1 2.224404
C15 9 gnd 2.080806f
R13 9 g6765_1 2.224404
C16 10 gnd 2.080806f
R14 10 9 2.224404
R15 10 g6765_4 2.224404
.ends

.subckt netg4539 g4539_2 g4539_9 g4539_5 g4539_8 g4539_6 g4539_1 g4539_4 g4539_10 g4539_3 g4539_7 g4539_0 gnd
C1  g4539_2 gnd 2.080806f
C2  g4539_9 gnd 2.080806f
C3  g4539_5 gnd 2.080806f
C4  g4539_8 gnd 2.080806f
C5  g4539_6 gnd 2.080806f
C6  g4539_1 gnd 2.080806f
C7  g4539_4 gnd 2.080806f
C8  g4539_10 gnd 2.080806f
C9  g4539_3 gnd 2.080806f
C10  g4539_7 gnd 2.080806f
C11  g4539_0 gnd 2.080806f
C12 1 gnd 2.080806f
R1 1 g4539_0 2.224404
C13 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4539_7 2 2.224404
C14 3 gnd 2.080806f
R4 1 3 2.224404
C15 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g4539_6 2.224404
R7 g4539_6 g4539_4 2.224404
R8 g4539_1 g4539_4 2.224404
C16 5 gnd 2.080806f
R9 g4539_4 5 2.224404
R10 5 g4539_5 2.224404
C17 6 gnd 2.080806f
R11 g4539_5 6 2.224404
R12 6 g4539_9 2.224404
R13 g4539_9 g4539_10 2.224404
R14 g4539_8 g4539_10 2.224404
C18 7 gnd 2.080806f
R15 5 7 2.224404
R16 7 g4539_3 2.224404
C19 8 gnd 2.080806f
R17 g4539_1 8 2.224404
C20 9 gnd 2.080806f
R18 8 9 2.224404
R19 g4539_2 9 2.224404
.ends

.subckt netg1115 g1115_1 g1115_0 gnd
C1  g1115_1 gnd 2.080806f
C2  g1115_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1115_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
R15 g1115_1 14 2.224404
.ends

.subckt netg6002 g6002_3 g6002_2 g6002_1 g6002_0 gnd
C1  g6002_3 gnd 2.080806f
C2  g6002_2 gnd 2.080806f
C3  g6002_1 gnd 2.080806f
C4  g6002_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g6002_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g6002_2 2.224404
C9 5 gnd 2.080806f
R6 g6002_2 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g6002_3 2.224404
C12 8 gnd 2.080806f
R10 g6002_3 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
R13 10 g6002_1 2.224404
.ends

.subckt netg90 g90_0 g90_1 gnd
C1  g90_0 gnd 2.080806f
C2  g90_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g90_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
R13 g90_1 12 2.224404
.ends

.subckt netg6657 g6657_0 g6657_1 gnd
C1  g6657_0 gnd 2.080806f
C2  g6657_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6657_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
R13 12 g6657_1 2.224404
.ends

.subckt netg4704 g4704_6 g4704_1 g4704_0 g4704_2 g4704_5 g4704_4 g4704_3 gnd
C1  g4704_6 gnd 2.080806f
C2  g4704_1 gnd 2.080806f
C3  g4704_0 gnd 2.080806f
C4  g4704_2 gnd 2.080806f
C5  g4704_5 gnd 2.080806f
C6  g4704_4 gnd 2.080806f
C7  g4704_3 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g4704_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4704_1 2.224404
C10 3 gnd 2.080806f
R4 3 g4704_0 2.224404
C11 4 gnd 2.080806f
R5 4 3 2.224404
R6 g4704_3 4 2.224404
C12 5 gnd 2.080806f
R7 5 1 2.224404
R8 g4704_5 5 2.224404
C13 6 gnd 2.080806f
R9 6 g4704_5 2.224404
R10 6 g4704_4 2.224404
C14 7 gnd 2.080806f
R11 7 g4704_3 2.224404
C15 8 gnd 2.080806f
R12 7 8 2.224404
R13 g4704_2 8 2.224404
C16 9 gnd 2.080806f
R14 9 g4704_2 2.224404
R15 g4704_6 9 2.224404
.ends

.subckt netg3817 g3817_9 g3817_5 g3817_4 g3817_7 g3817_10 g3817_8 g3817_1 g3817_2 g3817_6 g3817_3 gnd
C1  g3817_9 gnd 2.080806f
C2  g3817_5 gnd 2.080806f
C3  g3817_4 gnd 2.080806f
C4  g3817_7 gnd 2.080806f
C5  g3817_10 gnd 2.080806f
C6  g3817_8 gnd 2.080806f
C7  g3817_1 gnd 2.080806f
C8  g3817_2 gnd 2.080806f
C9  g3817_6 gnd 2.080806f
C10  g3817_3 gnd 2.080806f
C11 1 gnd 2.080806f
R1 1 g3817_1 2.224404
C12 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3817_2 2.224404
R4 g3817_10 g3817_2 2.224404
C13 3 gnd 2.080806f
R5 3 g3817_10 2.224404
C14 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g3817_8 2.224404
C15 5 gnd 2.080806f
R8 g3817_8 5 2.224404
R9 5 g3817_9 2.224404
C16 6 gnd 2.080806f
R10 g3817_2 6 2.224404
C17 7 gnd 2.080806f
R11 6 7 2.224404
R12 7 g3817_3 2.224404
C18 8 gnd 2.080806f
R13 g3817_3 8 2.224404
R14 8 g3817_5 2.224404
R15 8 g3817_7 2.224404
C19 9 gnd 2.080806f
R16 9 1 2.224404
C20 10 gnd 2.080806f
R17 10 9 2.224404
C21 11 gnd 2.080806f
R18 11 10 2.224404
R19 g3817_6 11 2.224404
C22 12 gnd 2.080806f
R20 12 g3817_9 2.224404
C23 13 gnd 2.080806f
R21 13 12 2.224404
C24 14 gnd 2.080806f
R22 14 13 2.224404
C25 15 gnd 2.080806f
R23 15 14 2.224404
R24 15 g3817_4 2.224404
.ends

.subckt netg4550 g4550_3 g4550_9 g4550_0 g4550_4 g4550_8 g4550_7 g4550_1 g4550_2 g4550_5 g4550_6 gnd
C1  g4550_3 gnd 2.080806f
C2  g4550_9 gnd 2.080806f
C3  g4550_0 gnd 2.080806f
C4  g4550_4 gnd 2.080806f
C5  g4550_8 gnd 2.080806f
C6  g4550_7 gnd 2.080806f
C7  g4550_1 gnd 2.080806f
C8  g4550_2 gnd 2.080806f
C9  g4550_5 gnd 2.080806f
C10  g4550_6 gnd 2.080806f
C11 1 gnd 2.080806f
R1 1 g4550_0 2.224404
R2 g4550_3 1 2.224404
C12 2 gnd 2.080806f
R3 2 g4550_3 2.224404
R4 g4550_2 2 2.224404
C13 3 gnd 2.080806f
R5 g4550_2 3 2.224404
R6 3 g4550_8 2.224404
C14 4 gnd 2.080806f
R7 1 4 2.224404
R8 4 g4550_5 2.224404
C15 5 gnd 2.080806f
R9 g4550_5 5 2.224404
R10 5 g4550_1 2.224404
C16 6 gnd 2.080806f
R11 g4550_1 6 2.224404
C17 7 gnd 2.080806f
R12 6 7 2.224404
R13 7 g4550_4 2.224404
C18 8 gnd 2.080806f
R14 8 6 2.224404
R15 g4550_9 8 2.224404
R16 g4550_7 g4550_9 2.224404
C19 9 gnd 2.080806f
R17 9 g4550_4 2.224404
C20 10 gnd 2.080806f
R18 9 10 2.224404
R19 10 g4550_6 2.224404
.ends

.subckt netg3630 g3630_6 g3630_4 g3630_3 g3630_2 g3630_1 g3630_0 g3630_5 gnd
C1  g3630_6 gnd 2.080806f
C2  g3630_4 gnd 2.080806f
C3  g3630_3 gnd 2.080806f
C4  g3630_2 gnd 2.080806f
C5  g3630_1 gnd 2.080806f
C6  g3630_0 gnd 2.080806f
C7  g3630_5 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g3630_0 2.224404
R2 g3630_4 1 2.224404
R3 g3630_3 g3630_4 2.224404
C9 2 gnd 2.080806f
R4 g3630_0 2 2.224404
C10 3 gnd 2.080806f
R5 2 3 2.224404
C11 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g3630_6 2.224404
C12 5 gnd 2.080806f
R8 5 g3630_3 2.224404
C13 6 gnd 2.080806f
R9 6 5 2.224404
C14 7 gnd 2.080806f
R10 7 6 2.224404
C15 8 gnd 2.080806f
R11 8 7 2.224404
C16 9 gnd 2.080806f
R12 9 8 2.224404
R13 g3630_2 9 2.224404
C17 10 gnd 2.080806f
R14 g3630_2 10 2.224404
C18 11 gnd 2.080806f
R15 10 11 2.224404
R16 11 g3630_1 2.224404
C19 12 gnd 2.080806f
R17 g3630_1 12 2.224404
R18 12 g3630_5 2.224404
.ends

.subckt netg2432 g2432_0 g2432_1 g2432_2 gnd
C1  g2432_0 gnd 2.080806f
C2  g2432_1 gnd 2.080806f
C3  g2432_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2432_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 g2432_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 g2432_1 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
R13 g2432_2 11 2.224404
.ends

.subckt netg4407 g4407_1 g4407_2 g4407_0 gnd
C1  g4407_1 gnd 2.080806f
C2  g4407_2 gnd 2.080806f
C3  g4407_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4407_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
R6 5 g4407_2 2.224404
C9 6 gnd 2.080806f
R7 g4407_2 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
R13 11 g4407_1 2.224404
.ends

.subckt netg1108 g1108_1 g1108_0 g1108_5 g1108_4 g1108_3 g1108_2 gnd
C1  g1108_1 gnd 2.080806f
C2  g1108_0 gnd 2.080806f
C3  g1108_5 gnd 2.080806f
C4  g1108_4 gnd 2.080806f
C5  g1108_3 gnd 2.080806f
C6  g1108_2 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1108_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1108_1 2 2.224404
R4 g1108_3 g1108_1 2.224404
C9 3 gnd 2.080806f
R5 3 g1108_3 2.224404
C10 4 gnd 2.080806f
R6 4 3 2.224404
R7 g1108_2 4 2.224404
C11 5 gnd 2.080806f
R8 g1108_0 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
R13 9 g1108_5 2.224404
C16 10 gnd 2.080806f
R14 10 g1108_5 2.224404
C17 11 gnd 2.080806f
R15 11 10 2.224404
C18 12 gnd 2.080806f
R16 12 11 2.224404
R17 g1108_4 12 2.224404
.ends

.subckt netg1285 g1285_1 g1285_0 gnd
C1  g1285_1 gnd 2.080806f
C2  g1285_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1285_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
R13 12 g1285_1 2.224404
.ends

.subckt netg5334 g5334_4 g5334_2 g5334_6 g5334_1 g5334_3 g5334_0 g5334_5 gnd
C1  g5334_4 gnd 2.080806f
C2  g5334_2 gnd 2.080806f
C3  g5334_6 gnd 2.080806f
C4  g5334_1 gnd 2.080806f
C5  g5334_3 gnd 2.080806f
C6  g5334_0 gnd 2.080806f
C7  g5334_5 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g5334_0 1 2.224404
R2 1 g5334_5 2.224404
C9 2 gnd 2.080806f
R3 2 1 2.224404
C10 3 gnd 2.080806f
R4 3 2 2.224404
R5 g5334_6 3 2.224404
C11 4 gnd 2.080806f
R6 4 g5334_6 2.224404
C12 5 gnd 2.080806f
R7 5 4 2.224404
C13 6 gnd 2.080806f
R8 6 5 2.224404
R9 g5334_4 6 2.224404
C14 7 gnd 2.080806f
R10 7 g5334_4 2.224404
C15 8 gnd 2.080806f
R11 8 7 2.224404
R12 g5334_2 8 2.224404
R13 g5334_3 g5334_2 2.224404
C16 9 gnd 2.080806f
R14 g5334_2 9 2.224404
C17 10 gnd 2.080806f
R15 9 10 2.224404
R16 10 g5334_1 2.224404
.ends

.subckt netg6542 g6542_0 g6542_1 gnd
C1  g6542_0 gnd 2.080806f
C2  g6542_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6542_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
R13 12 g6542_1 2.224404
.ends

.subckt netg3810 g3810_3 g3810_4 g3810_1 g3810_0 g3810_6 g3810_5 g3810_2 gnd
C1  g3810_3 gnd 2.080806f
C2  g3810_4 gnd 2.080806f
C3  g3810_1 gnd 2.080806f
C4  g3810_0 gnd 2.080806f
C5  g3810_6 gnd 2.080806f
C6  g3810_5 gnd 2.080806f
C7  g3810_2 gnd 2.080806f
R1 g3810_3 g3810_0 2.224404
C8 1 gnd 2.080806f
R2 1 g3810_3 2.224404
C9 2 gnd 2.080806f
R3 2 1 2.224404
C10 3 gnd 2.080806f
R4 3 2 2.224404
C11 4 gnd 2.080806f
R5 4 3 2.224404
R6 g3810_5 4 2.224404
R7 g3810_1 g3810_5 2.224404
C12 5 gnd 2.080806f
R8 5 g3810_5 2.224404
C13 6 gnd 2.080806f
R9 6 5 2.224404
R10 g3810_2 6 2.224404
C14 7 gnd 2.080806f
R11 7 g3810_2 2.224404
C15 8 gnd 2.080806f
R12 8 7 2.224404
R13 g3810_4 8 2.224404
C16 9 gnd 2.080806f
R14 6 9 2.224404
R15 9 g3810_6 2.224404
.ends

.subckt netg2200 g2200_1 g2200_2 gnd
C1  g2200_1 gnd 2.080806f
C2  g2200_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2200_2 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
R13 g2200_1 12 2.224404
.ends

.subckt netg127 g127_1 g127_0 gnd
C1  g127_1 gnd 2.080806f
C2  g127_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g127_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
R14 13 g127_1 2.224404
.ends

.subckt netg849 g849_6 g849_4 g849_2 g849_3 g849_0 g849_5 g849_1 gnd
C1  g849_6 gnd 2.080806f
C2  g849_4 gnd 2.080806f
C3  g849_2 gnd 2.080806f
C4  g849_3 gnd 2.080806f
C5  g849_0 gnd 2.080806f
C6  g849_5 gnd 2.080806f
C7  g849_1 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g849_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g849_2 2.224404
R4 g849_2 g849_4 2.224404
C10 3 gnd 2.080806f
R5 g849_2 3 2.224404
C11 4 gnd 2.080806f
R6 3 4 2.224404
C12 5 gnd 2.080806f
R7 4 5 2.224404
C13 6 gnd 2.080806f
R8 5 6 2.224404
C14 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g849_3 2.224404
C15 8 gnd 2.080806f
R11 g849_3 8 2.224404
C16 9 gnd 2.080806f
R12 8 9 2.224404
C17 10 gnd 2.080806f
R13 9 10 2.224404
R14 10 g849_1 2.224404
C18 11 gnd 2.080806f
R15 11 g849_1 2.224404
R16 11 g849_5 2.224404
C19 12 gnd 2.080806f
R17 12 11 2.224404
C20 13 gnd 2.080806f
R18 13 12 2.224404
R19 g849_6 13 2.224404
.ends

.subckt netg3644 g3644_4 g3644_8 g3644_5 g3644_1 g3644_7 g3644_9 g3644_2 g3644_3 g3644_0 gnd
C1  g3644_4 gnd 2.080806f
C2  g3644_8 gnd 2.080806f
C3  g3644_5 gnd 2.080806f
C4  g3644_1 gnd 2.080806f
C5  g3644_7 gnd 2.080806f
C6  g3644_9 gnd 2.080806f
C7  g3644_2 gnd 2.080806f
C8  g3644_3 gnd 2.080806f
C9  g3644_0 gnd 2.080806f
C10 1 gnd 2.080806f
R1 1 g3644_0 2.224404
R2 g3644_1 1 2.224404
C11 2 gnd 2.080806f
R3 2 g3644_1 2.224404
C12 3 gnd 2.080806f
R4 3 2 2.224404
C13 4 gnd 2.080806f
R5 4 3 2.224404
R6 g3644_2 4 2.224404
R7 g3644_2 g3644_5 2.224404
C14 5 gnd 2.080806f
R8 5 g3644_5 2.224404
R9 g3644_9 5 2.224404
R10 g3644_8 g3644_9 2.224404
R11 g3644_3 g3644_8 2.224404
C15 6 gnd 2.080806f
R12 g3644_8 6 2.224404
R13 6 g3644_4 2.224404
C16 7 gnd 2.080806f
R14 7 g3644_3 2.224404
C17 8 gnd 2.080806f
R15 8 7 2.224404
C18 9 gnd 2.080806f
R16 9 8 2.224404
R17 g3644_7 9 2.224404
.ends

.subckt netg2092 g2092_0 g2092_1 g2092_3 g2092_2 gnd
C1  g2092_0 gnd 2.080806f
C2  g2092_1 gnd 2.080806f
C3  g2092_3 gnd 2.080806f
C4  g2092_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2092_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2092_3 2 2.224404
C7 3 gnd 2.080806f
R4 3 g2092_3 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
R12 g2092_1 10 2.224404
C15 11 gnd 2.080806f
R13 11 g2092_1 2.224404
R14 g2092_2 11 2.224404
.ends

.subckt netg4092 g4092_2 g4092_1 g4092_0 gnd
C1  g4092_2 gnd 2.080806f
C2  g4092_1 gnd 2.080806f
C3  g4092_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4092_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g4092_2 2.224404
C9 6 gnd 2.080806f
R7 6 g4092_0 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
R14 g4092_1 12 2.224404
.ends

.subckt netg1792 g1792_2 g1792_0 g1792_1 gnd
C1  g1792_2 gnd 2.080806f
C2  g1792_0 gnd 2.080806f
C3  g1792_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1792_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g1792_2 2.224404
C15 12 gnd 2.080806f
R13 g1792_2 12 2.224404
R14 12 g1792_1 2.224404
.ends

.subckt netg2537 g2537_1 g2537_2 g2537_0 gnd
C1  g2537_1 gnd 2.080806f
C2  g2537_2 gnd 2.080806f
C3  g2537_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2537_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
R12 g2537_1 11 2.224404
C15 12 gnd 2.080806f
R13 12 g2537_1 2.224404
R14 g2537_2 12 2.224404
.ends

.subckt netg2226 g2226_1 g2226_0 gnd
C1  g2226_1 gnd 2.080806f
C2  g2226_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2226_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
R14 g2226_1 13 2.224404
.ends

.subckt netg1803 g1803_1 g1803_3 g1803_0 g1803_2 gnd
C1  g1803_1 gnd 2.080806f
C2  g1803_3 gnd 2.080806f
C3  g1803_0 gnd 2.080806f
C4  g1803_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1803_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1803_3 2.224404
C7 3 gnd 2.080806f
R4 g1803_3 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
R13 11 g1803_2 2.224404
R14 g1803_2 g1803_1 2.224404
.ends

.subckt netg4698 g4698_2 g4698_1 g4698_4 g4698_3 g4698_0 g4698_5 gnd
C1  g4698_2 gnd 2.080806f
C2  g4698_1 gnd 2.080806f
C3  g4698_4 gnd 2.080806f
C4  g4698_3 gnd 2.080806f
C5  g4698_0 gnd 2.080806f
C6  g4698_5 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g4698_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4698_2 2.224404
C9 3 gnd 2.080806f
R4 3 g4698_2 2.224404
R5 3 g4698_4 2.224404
C10 4 gnd 2.080806f
R6 g4698_2 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g4698_1 2.224404
C13 7 gnd 2.080806f
R10 7 1 2.224404
C14 8 gnd 2.080806f
R11 8 7 2.224404
C15 9 gnd 2.080806f
R12 9 8 2.224404
R13 g4698_3 9 2.224404
C16 10 gnd 2.080806f
R14 10 g4698_3 2.224404
C17 11 gnd 2.080806f
R15 11 10 2.224404
C18 12 gnd 2.080806f
R16 12 11 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
R18 13 g4698_5 2.224404
.ends

.subckt netg4732 g4732_9 g4732_5 g4732_6 g4732_2 g4732_4 g4732_0 g4732_8 g4732_3 g4732_7 g4732_1 gnd
C1  g4732_9 gnd 2.080806f
C2  g4732_5 gnd 2.080806f
C3  g4732_6 gnd 2.080806f
C4  g4732_2 gnd 2.080806f
C5  g4732_4 gnd 2.080806f
C6  g4732_0 gnd 2.080806f
C7  g4732_8 gnd 2.080806f
C8  g4732_3 gnd 2.080806f
C9  g4732_7 gnd 2.080806f
C10  g4732_1 gnd 2.080806f
C11 1 gnd 2.080806f
R1 1 g4732_0 2.224404
C12 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4732_4 2 2.224404
C13 3 gnd 2.080806f
R4 3 g4732_4 2.224404
R5 g4732_6 3 2.224404
R6 g4732_8 g4732_6 2.224404
C14 4 gnd 2.080806f
R7 g4732_8 4 2.224404
C15 5 gnd 2.080806f
R8 4 5 2.224404
R9 g4732_3 5 2.224404
C16 6 gnd 2.080806f
R10 6 3 2.224404
R11 g4732_1 6 2.224404
C17 7 gnd 2.080806f
R12 7 g4732_1 2.224404
R13 g4732_5 7 2.224404
R14 g4732_7 g4732_5 2.224404
C18 8 gnd 2.080806f
R15 5 8 2.224404
R16 8 g4732_9 2.224404
C19 9 gnd 2.080806f
R17 g4732_9 9 2.224404
R18 9 g4732_2 2.224404
.ends

.subckt netg2338 g2338_2 g2338_1 g2338_3 g2338_0 gnd
C1  g2338_2 gnd 2.080806f
C2  g2338_1 gnd 2.080806f
C3  g2338_3 gnd 2.080806f
C4  g2338_0 gnd 2.080806f
R1 g2338_1 g2338_0 2.224404
C5 1 gnd 2.080806f
R2 1 g2338_1 2.224404
R3 g2338_3 1 2.224404
C6 2 gnd 2.080806f
R4 2 g2338_3 2.224404
C7 3 gnd 2.080806f
R5 3 2 2.224404
C8 4 gnd 2.080806f
R6 4 3 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
R14 g2338_2 11 2.224404
.ends

.subckt netg2429 g2429_2 g2429_1 g2429_0 gnd
C1  g2429_2 gnd 2.080806f
C2  g2429_1 gnd 2.080806f
C3  g2429_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2429_0 1 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
R13 12 g2429_2 2.224404
R14 g2429_2 g2429_1 2.224404
.ends

.subckt netg805 g805_4 g805_6 g805_2 g805_5 g805_3 g805_0 g805_1 gnd
C1  g805_4 gnd 2.080806f
C2  g805_6 gnd 2.080806f
C3  g805_2 gnd 2.080806f
C4  g805_5 gnd 2.080806f
C5  g805_3 gnd 2.080806f
C6  g805_0 gnd 2.080806f
C7  g805_1 gnd 2.080806f
R1 g805_0 g805_3 2.224404
R2 g805_6 g805_0 2.224404
C8 1 gnd 2.080806f
R3 1 g805_3 2.224404
R4 1 g805_2 2.224404
C9 2 gnd 2.080806f
R5 2 g805_6 2.224404
R6 g805_1 2 2.224404
C10 3 gnd 2.080806f
R7 3 g805_1 2.224404
C11 4 gnd 2.080806f
R8 4 3 2.224404
C12 5 gnd 2.080806f
R9 5 4 2.224404
C13 6 gnd 2.080806f
R10 6 5 2.224404
R11 g805_4 6 2.224404
C14 7 gnd 2.080806f
R12 7 g805_4 2.224404
C15 8 gnd 2.080806f
R13 8 7 2.224404
C16 9 gnd 2.080806f
R14 9 8 2.224404
R15 g805_5 9 2.224404
.ends

.subckt netg3665 g3665_2 g3665_9 g3665_6 g3665_3 g3665_1 g3665_7 g3665_5 g3665_8 g3665_4 g3665_0 gnd
C1  g3665_2 gnd 2.080806f
C2  g3665_9 gnd 2.080806f
C3  g3665_6 gnd 2.080806f
C4  g3665_3 gnd 2.080806f
C5  g3665_1 gnd 2.080806f
C6  g3665_7 gnd 2.080806f
C7  g3665_5 gnd 2.080806f
C8  g3665_8 gnd 2.080806f
C9  g3665_4 gnd 2.080806f
C10  g3665_0 gnd 2.080806f
C11 1 gnd 2.080806f
R1 g3665_0 1 2.224404
R2 1 g3665_1 2.224404
C12 2 gnd 2.080806f
R3 2 g3665_0 2.224404
C13 3 gnd 2.080806f
R4 3 2 2.224404
R5 g3665_5 3 2.224404
R6 g3665_4 g3665_5 2.224404
C14 4 gnd 2.080806f
R7 g3665_5 4 2.224404
R8 4 g3665_6 2.224404
R9 g3665_2 g3665_6 2.224404
C15 5 gnd 2.080806f
R10 5 g3665_4 2.224404
R11 g3665_8 5 2.224404
R12 g3665_7 g3665_8 2.224404
C16 6 gnd 2.080806f
R13 6 g3665_2 2.224404
R14 g3665_9 6 2.224404
C17 7 gnd 2.080806f
R15 g3665_1 7 2.224404
C18 8 gnd 2.080806f
R16 7 8 2.224404
C19 9 gnd 2.080806f
R17 8 9 2.224404
C20 10 gnd 2.080806f
R18 9 10 2.224404
R19 10 g3665_3 2.224404
.ends

.subckt netg5380 g5380_0 g5380_1 gnd
C1  g5380_0 gnd 2.080806f
C2  g5380_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5380_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
R14 g5380_1 13 2.224404
.ends

.subckt netg2101 g2101_2 g2101_3 g2101_0 g2101_5 g2101_4 g2101_1 gnd
C1  g2101_2 gnd 2.080806f
C2  g2101_3 gnd 2.080806f
C3  g2101_0 gnd 2.080806f
C4  g2101_5 gnd 2.080806f
C5  g2101_4 gnd 2.080806f
C6  g2101_1 gnd 2.080806f
R1 g2101_0 g2101_2 2.224404
C7 1 gnd 2.080806f
R2 g2101_0 1 2.224404
R3 1 g2101_4 2.224404
C8 2 gnd 2.080806f
R4 g2101_4 2 2.224404
C9 3 gnd 2.080806f
R5 2 3 2.224404
C10 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g2101_1 2.224404
C11 5 gnd 2.080806f
R8 g2101_1 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
R13 9 g2101_5 2.224404
C16 10 gnd 2.080806f
R14 10 g2101_5 2.224404
C17 11 gnd 2.080806f
R15 10 11 2.224404
R16 11 g2101_3 2.224404
.ends

.subckt netg4519 g4519_6 g4519_5 g4519_4 g4519_8 g4519_2 g4519_9 g4519_3 g4519_1 g4519_7 g4519_0 gnd
C1  g4519_6 gnd 2.080806f
C2  g4519_5 gnd 2.080806f
C3  g4519_4 gnd 2.080806f
C4  g4519_8 gnd 2.080806f
C5  g4519_2 gnd 2.080806f
C6  g4519_9 gnd 2.080806f
C7  g4519_3 gnd 2.080806f
C8  g4519_1 gnd 2.080806f
C9  g4519_7 gnd 2.080806f
C10  g4519_0 gnd 2.080806f
C11 1 gnd 2.080806f
R1 1 g4519_0 2.224404
R2 g4519_4 1 2.224404
C12 2 gnd 2.080806f
R3 2 g4519_0 2.224404
R4 g4519_6 2 2.224404
R5 1 g4519_8 2.224404
C13 3 gnd 2.080806f
R6 3 g4519_6 2.224404
R7 g4519_7 3 2.224404
R8 g4519_9 3 2.224404
C14 4 gnd 2.080806f
R9 4 g4519_7 2.224404
R10 g4519_2 4 2.224404
C15 5 gnd 2.080806f
R11 5 g4519_2 2.224404
R12 g4519_5 5 2.224404
C16 6 gnd 2.080806f
R13 6 g4519_4 2.224404
C17 7 gnd 2.080806f
R14 7 6 2.224404
R15 g4519_1 7 2.224404
C18 8 gnd 2.080806f
R16 g4519_0 8 2.224404
C19 9 gnd 2.080806f
R17 8 9 2.224404
C20 10 gnd 2.080806f
R18 9 10 2.224404
R19 10 g4519_3 2.224404
.ends

.subckt netg1978 g1978_4 g1978_1 g1978_5 g1978_6 g1978_2 g1978_7 g1978_0 g1978_3 gnd
C1  g1978_4 gnd 2.080806f
C2  g1978_1 gnd 2.080806f
C3  g1978_5 gnd 2.080806f
C4  g1978_6 gnd 2.080806f
C5  g1978_2 gnd 2.080806f
C6  g1978_7 gnd 2.080806f
C7  g1978_0 gnd 2.080806f
C8  g1978_3 gnd 2.080806f
R1 g1978_6 g1978_0 2.224404
C9 1 gnd 2.080806f
R2 1 g1978_6 2.224404
R3 1 g1978_4 2.224404
R4 g1978_4 g1978_3 2.224404
C10 2 gnd 2.080806f
R5 2 g1978_3 2.224404
R6 g1978_2 2 2.224404
C11 3 gnd 2.080806f
R7 g1978_3 3 2.224404
C12 4 gnd 2.080806f
R8 3 4 2.224404
C13 5 gnd 2.080806f
R9 4 5 2.224404
R10 5 g1978_1 2.224404
C14 6 gnd 2.080806f
R11 g1978_0 6 2.224404
C15 7 gnd 2.080806f
R12 6 7 2.224404
C16 8 gnd 2.080806f
R13 7 8 2.224404
R14 8 g1978_5 2.224404
C17 9 gnd 2.080806f
R15 9 g1978_2 2.224404
C18 10 gnd 2.080806f
R16 10 9 2.224404
C19 11 gnd 2.080806f
R17 11 10 2.224404
C20 12 gnd 2.080806f
R18 12 11 2.224404
R19 g1978_7 12 2.224404
.ends

.subckt netg4956 g4956_2 g4956_1 g4956_0 g4956_3 gnd
C1  g4956_2 gnd 2.080806f
C2  g4956_1 gnd 2.080806f
C3  g4956_0 gnd 2.080806f
C4  g4956_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4956_0 1 2.224404
R2 1 g4956_2 2.224404
C6 2 gnd 2.080806f
R3 g4956_2 2 2.224404
R4 2 g4956_1 2.224404
C7 3 gnd 2.080806f
R5 3 g4956_0 2.224404
C8 4 gnd 2.080806f
R6 4 3 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
R14 g4956_3 11 2.224404
.ends

.subckt netg1240 g1240_5 g1240_3 g1240_4 g1240_2 g1240_1 g1240_0 gnd
C1  g1240_5 gnd 2.080806f
C2  g1240_3 gnd 2.080806f
C3  g1240_4 gnd 2.080806f
C4  g1240_2 gnd 2.080806f
C5  g1240_1 gnd 2.080806f
C6  g1240_0 gnd 2.080806f
R1 g1240_0 g1240_2 2.224404
C7 1 gnd 2.080806f
R2 1 g1240_2 2.224404
C8 2 gnd 2.080806f
R3 2 1 2.224404
R4 2 g1240_4 2.224404
R5 g1240_4 g1240_1 2.224404
R6 g1240_1 g1240_3 2.224404
C9 3 gnd 2.080806f
R7 3 2 2.224404
C10 4 gnd 2.080806f
R8 4 3 2.224404
C11 5 gnd 2.080806f
R9 5 4 2.224404
C12 6 gnd 2.080806f
R10 6 5 2.224404
C13 7 gnd 2.080806f
R11 7 6 2.224404
C14 8 gnd 2.080806f
R12 8 7 2.224404
C15 9 gnd 2.080806f
R13 9 8 2.224404
C16 10 gnd 2.080806f
R14 10 9 2.224404
R15 g1240_5 10 2.224404
.ends

.subckt netg1281 g1281_1 g1281_0 gnd
C1  g1281_1 gnd 2.080806f
C2  g1281_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1281_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
R14 g1281_1 13 2.224404
.ends

.subckt netg5264 g5264_1 g5264_0 gnd
C1  g5264_1 gnd 2.080806f
C2  g5264_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5264_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
R16 g5264_1 15 2.224404
.ends

.subckt netg5341 g5341_2 g5341_3 g5341_1 g5341_0 gnd
C1  g5341_2 gnd 2.080806f
C2  g5341_3 gnd 2.080806f
C3  g5341_1 gnd 2.080806f
C4  g5341_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g5341_0 1 2.224404
R2 1 g5341_1 2.224404
C6 2 gnd 2.080806f
R3 g5341_1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g5341_3 2.224404
C9 5 gnd 2.080806f
R7 g5341_3 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
R14 11 g5341_2 2.224404
.ends

.subckt netg1099 g1099_0 g1099_1 gnd
C1  g1099_0 gnd 2.080806f
C2  g1099_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1099_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
R14 13 g1099_1 2.224404
.ends

.subckt netg7526 g7526_1 g7526_0 gnd
C1  g7526_1 gnd 2.080806f
C2  g7526_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7526_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
R14 13 g7526_1 2.224404
.ends

.subckt netg4676 g4676_6 g4676_3 g4676_1 g4676_2 g4676_4 g4676_9 g4676_7 g4676_8 g4676_10 g4676_5 gnd
C1  g4676_6 gnd 2.080806f
C2  g4676_3 gnd 2.080806f
C3  g4676_1 gnd 2.080806f
C4  g4676_2 gnd 2.080806f
C5  g4676_4 gnd 2.080806f
C6  g4676_9 gnd 2.080806f
C7  g4676_7 gnd 2.080806f
C8  g4676_8 gnd 2.080806f
C9  g4676_10 gnd 2.080806f
C10  g4676_5 gnd 2.080806f
R1 g4676_9 g4676_6 2.224404
R2 g4676_6 g4676_7 2.224404
R3 g4676_7 g4676_8 2.224404
C11 1 gnd 2.080806f
R4 g4676_7 1 2.224404
R5 1 g4676_4 2.224404
C12 2 gnd 2.080806f
R6 g4676_8 2 2.224404
R7 2 g4676_3 2.224404
C13 3 gnd 2.080806f
R8 3 g4676_3 2.224404
R9 3 g4676_2 2.224404
C14 4 gnd 2.080806f
R10 g4676_2 4 2.224404
R11 4 g4676_10 2.224404
R12 g4676_10 g4676_1 2.224404
C15 5 gnd 2.080806f
R13 g4676_4 5 2.224404
C16 6 gnd 2.080806f
R14 5 6 2.224404
C17 7 gnd 2.080806f
R15 6 7 2.224404
C18 8 gnd 2.080806f
R16 7 8 2.224404
R17 g4676_5 8 2.224404
.ends

.subckt netg4491 g4491_4 g4491_5 g4491_3 g4491_2 g4491_1 g4491_6 g4491_0 gnd
C1  g4491_4 gnd 2.080806f
C2  g4491_5 gnd 2.080806f
C3  g4491_3 gnd 2.080806f
C4  g4491_2 gnd 2.080806f
C5  g4491_1 gnd 2.080806f
C6  g4491_6 gnd 2.080806f
C7  g4491_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g4491_0 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
C10 3 gnd 2.080806f
R3 3 2 2.224404
C11 4 gnd 2.080806f
R4 4 3 2.224404
R5 g4491_4 4 2.224404
C12 5 gnd 2.080806f
R6 5 g4491_4 2.224404
C13 6 gnd 2.080806f
R7 6 5 2.224404
C14 7 gnd 2.080806f
R8 7 6 2.224404
C15 8 gnd 2.080806f
R9 8 7 2.224404
C16 9 gnd 2.080806f
R10 9 8 2.224404
R11 g4491_1 9 2.224404
C17 10 gnd 2.080806f
R12 10 g4491_1 2.224404
R13 g4491_5 10 2.224404
R14 10 g4491_6 2.224404
R15 g4491_6 g4491_2 2.224404
C18 11 gnd 2.080806f
R16 11 g4491_2 2.224404
C19 12 gnd 2.080806f
R17 12 11 2.224404
R18 12 g4491_3 2.224404
.ends

.subckt netg772 g772_2 g772_3 g772_0 g772_1 g772_4 gnd
C1  g772_2 gnd 2.080806f
C2  g772_3 gnd 2.080806f
C3  g772_0 gnd 2.080806f
C4  g772_1 gnd 2.080806f
C5  g772_4 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g772_0 2.224404
C7 2 gnd 2.080806f
R2 2 1 2.224404
C8 3 gnd 2.080806f
R3 3 2 2.224404
C9 4 gnd 2.080806f
R4 4 3 2.224404
R5 g772_3 4 2.224404
C10 5 gnd 2.080806f
R6 3 5 2.224404
C11 6 gnd 2.080806f
R7 6 5 2.224404
R8 g772_4 6 2.224404
C12 7 gnd 2.080806f
R9 g772_4 7 2.224404
C13 8 gnd 2.080806f
R10 7 8 2.224404
C14 9 gnd 2.080806f
R11 8 9 2.224404
C15 10 gnd 2.080806f
R12 9 10 2.224404
R13 10 g772_1 2.224404
C16 11 gnd 2.080806f
R14 g772_0 11 2.224404
C17 12 gnd 2.080806f
R15 11 12 2.224404
C18 13 gnd 2.080806f
R16 12 13 2.224404
C19 14 gnd 2.080806f
R17 13 14 2.224404
C20 15 gnd 2.080806f
R18 14 15 2.224404
R19 15 g772_2 2.224404
.ends

.subckt netg77 g77_1 g77_0 gnd
C1  g77_1 gnd 2.080806f
C2  g77_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g77_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
R14 13 g77_1 2.224404
.ends

.subckt netg7529 g7529_0 g7529_1 gnd
C1  g7529_0 gnd 2.080806f
C2  g7529_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7529_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
R14 g7529_1 13 2.224404
.ends

.subckt netg6351 g6351_0 g6351_1 g6351_3 g6351_2 gnd
C1  g6351_0 gnd 2.080806f
C2  g6351_1 gnd 2.080806f
C3  g6351_3 gnd 2.080806f
C4  g6351_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g6351_0 1 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 g6351_2 3 2.224404
R5 g6351_2 g6351_1 2.224404
C8 4 gnd 2.080806f
R6 g6351_0 4 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
R15 12 g6351_3 2.224404
.ends

.subckt netg1456 g1456_0 g1456_1 gnd
C1  g1456_0 gnd 2.080806f
C2  g1456_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1456_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
R15 g1456_1 14 2.224404
.ends

.subckt netg2318 g2318_1 g2318_3 g2318_2 gnd
C1  g2318_1 gnd 2.080806f
C2  g2318_3 gnd 2.080806f
C3  g2318_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2318_3 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
R11 g2318_2 10 2.224404
C14 11 gnd 2.080806f
R12 11 g2318_2 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
R15 g2318_1 13 2.224404
.ends

.subckt netg753 g753_5 g753_6 g753_0 g753_2 g753_3 g753_1 gnd
C1  g753_5 gnd 2.080806f
C2  g753_6 gnd 2.080806f
C3  g753_0 gnd 2.080806f
C4  g753_2 gnd 2.080806f
C5  g753_3 gnd 2.080806f
C6  g753_1 gnd 2.080806f
R1 g753_5 g753_0 2.224404
C7 1 gnd 2.080806f
R2 1 g753_5 2.224404
C8 2 gnd 2.080806f
R3 2 1 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
R6 g753_1 4 2.224404
C11 5 gnd 2.080806f
R7 g753_0 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g753_2 2.224404
C16 10 gnd 2.080806f
R13 10 g753_2 2.224404
C17 11 gnd 2.080806f
R14 11 10 2.224404
C18 12 gnd 2.080806f
R15 12 11 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
R17 13 g753_6 2.224404
R18 g753_6 g753_3 2.224404
.ends

.subckt netg4802 g4802_6 g4802_9 g4802_7 g4802_3 g4802_1 g4802_5 g4802_0 g4802_8 g4802_2 g4802_4 gnd
C1  g4802_6 gnd 2.080806f
C2  g4802_9 gnd 2.080806f
C3  g4802_7 gnd 2.080806f
C4  g4802_3 gnd 2.080806f
C5  g4802_1 gnd 2.080806f
C6  g4802_5 gnd 2.080806f
C7  g4802_0 gnd 2.080806f
C8  g4802_8 gnd 2.080806f
C9  g4802_2 gnd 2.080806f
C10  g4802_4 gnd 2.080806f
R1 g4802_0 g4802_5 2.224404
C11 1 gnd 2.080806f
R2 g4802_5 1 2.224404
R3 1 g4802_1 2.224404
R4 g4802_1 g4802_2 2.224404
C12 2 gnd 2.080806f
R5 g4802_2 2 2.224404
R6 2 g4802_8 2.224404
C13 3 gnd 2.080806f
R7 3 g4802_8 2.224404
R8 g4802_6 3 2.224404
C14 4 gnd 2.080806f
R9 g4802_8 4 2.224404
R10 4 g4802_9 2.224404
C15 5 gnd 2.080806f
R11 5 g4802_2 2.224404
C16 6 gnd 2.080806f
R12 6 5 2.224404
R13 6 g4802_7 2.224404
C17 7 gnd 2.080806f
R14 7 g4802_0 2.224404
C18 8 gnd 2.080806f
R15 8 7 2.224404
C19 9 gnd 2.080806f
R16 9 8 2.224404
R17 g4802_4 9 2.224404
C20 10 gnd 2.080806f
R18 10 g4802_6 2.224404
C21 11 gnd 2.080806f
R19 11 10 2.224404
C22 12 gnd 2.080806f
R20 12 11 2.224404
C23 13 gnd 2.080806f
R21 13 12 2.224404
C24 14 gnd 2.080806f
R22 14 13 2.224404
C25 15 gnd 2.080806f
R23 15 14 2.224404
C26 16 gnd 2.080806f
R24 15 16 2.224404
R25 g4802_3 16 2.224404
.ends

.subckt netg1965 g1965_4 g1965_5 g1965_0 g1965_3 g1965_1 g1965_2 gnd
C1  g1965_4 gnd 2.080806f
C2  g1965_5 gnd 2.080806f
C3  g1965_0 gnd 2.080806f
C4  g1965_3 gnd 2.080806f
C5  g1965_1 gnd 2.080806f
C6  g1965_2 gnd 2.080806f
R1 g1965_0 g1965_2 2.224404
C7 1 gnd 2.080806f
R2 g1965_2 1 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g1965_5 2.224404
C10 4 gnd 2.080806f
R6 g1965_5 4 2.224404
R7 4 g1965_3 2.224404
C11 5 gnd 2.080806f
R8 g1965_3 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 7 6 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 10 9 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
R15 g1965_1 11 2.224404
C18 12 gnd 2.080806f
R16 12 g1965_1 2.224404
C19 13 gnd 2.080806f
R17 13 12 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
R19 g1965_4 14 2.224404
.ends

.subckt netg695 g695_1 g695_0 gnd
C1  g695_1 gnd 2.080806f
C2  g695_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g695_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
R15 g695_1 14 2.224404
.ends

.subckt netg2001 g2001_1 g2001_0 g2001_2 gnd
C1  g2001_1 gnd 2.080806f
C2  g2001_0 gnd 2.080806f
C3  g2001_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2001_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
R12 g2001_2 11 2.224404
C15 12 gnd 2.080806f
R13 12 g2001_2 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
R15 g2001_1 13 2.224404
.ends

.subckt netg4177 g4177_0 g4177_1 gnd
C1  g4177_0 gnd 2.080806f
C2  g4177_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g4177_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
R15 g4177_1 14 2.224404
.ends

.subckt netg608 g608_2 g608_1 g608_5 g608_3 g608_0 g608_4 gnd
C1  g608_2 gnd 2.080806f
C2  g608_1 gnd 2.080806f
C3  g608_5 gnd 2.080806f
C4  g608_3 gnd 2.080806f
C5  g608_0 gnd 2.080806f
C6  g608_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g608_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g608_1 2.224404
C9 3 gnd 2.080806f
R4 g608_0 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g608_5 2.224404
C12 6 gnd 2.080806f
R8 g608_5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g608_4 2.224404
C14 8 gnd 2.080806f
R11 6 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
R13 9 g608_3 2.224404
C16 10 gnd 2.080806f
R14 g608_3 10 2.224404
C17 11 gnd 2.080806f
R15 10 11 2.224404
C18 12 gnd 2.080806f
R16 11 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
C21 15 gnd 2.080806f
R19 14 15 2.224404
R20 15 g608_2 2.224404
.ends

.subckt netg68 g68_0 g68_1 gnd
C1  g68_0 gnd 2.080806f
C2  g68_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g68_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
R15 g68_1 14 2.224404
.ends

.subckt netg507 g507_1 g507_3 g507_4 g507_0 g507_2 gnd
C1  g507_1 gnd 2.080806f
C2  g507_3 gnd 2.080806f
C3  g507_4 gnd 2.080806f
C4  g507_0 gnd 2.080806f
C5  g507_2 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g507_0 1 2.224404
R2 1 g507_3 2.224404
C7 2 gnd 2.080806f
R3 g507_3 2 2.224404
R4 2 g507_2 2.224404
C8 3 gnd 2.080806f
R5 g507_3 3 2.224404
R6 3 g507_4 2.224404
C9 4 gnd 2.080806f
R7 g507_2 4 2.224404
C10 5 gnd 2.080806f
R8 4 5 2.224404
C11 6 gnd 2.080806f
R9 5 6 2.224404
C12 7 gnd 2.080806f
R10 6 7 2.224404
C13 8 gnd 2.080806f
R11 7 8 2.224404
C14 9 gnd 2.080806f
R12 8 9 2.224404
C15 10 gnd 2.080806f
R13 9 10 2.224404
C16 11 gnd 2.080806f
R14 10 11 2.224404
C17 12 gnd 2.080806f
R15 11 12 2.224404
C18 13 gnd 2.080806f
R16 12 13 2.224404
R17 13 g507_1 2.224404
.ends

.subckt netg2907 g2907_6 g2907_4 g2907_1 g2907_0 g2907_5 g2907_3 g2907_2 gnd
C1  g2907_6 gnd 2.080806f
C2  g2907_4 gnd 2.080806f
C3  g2907_1 gnd 2.080806f
C4  g2907_0 gnd 2.080806f
C5  g2907_5 gnd 2.080806f
C6  g2907_3 gnd 2.080806f
C7  g2907_2 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g2907_0 1 2.224404
R2 g2907_4 1 2.224404
C9 2 gnd 2.080806f
R3 1 2 2.224404
C10 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g2907_6 2.224404
C11 4 gnd 2.080806f
R6 1 4 2.224404
C12 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g2907_1 2.224404
R9 g2907_1 g2907_3 2.224404
C13 6 gnd 2.080806f
R10 6 g2907_1 2.224404
C14 7 gnd 2.080806f
R11 7 6 2.224404
C15 8 gnd 2.080806f
R12 8 7 2.224404
R13 g2907_2 8 2.224404
C16 9 gnd 2.080806f
R14 g2907_3 9 2.224404
C17 10 gnd 2.080806f
R15 9 10 2.224404
C18 11 gnd 2.080806f
R16 10 11 2.224404
C19 12 gnd 2.080806f
R17 11 12 2.224404
R18 12 g2907_5 2.224404
.ends

.subckt netg5280 g5280_5 g5280_4 g5280_6 g5280_0 g5280_1 g5280_3 g5280_2 gnd
C1  g5280_5 gnd 2.080806f
C2  g5280_4 gnd 2.080806f
C3  g5280_6 gnd 2.080806f
C4  g5280_0 gnd 2.080806f
C5  g5280_1 gnd 2.080806f
C6  g5280_3 gnd 2.080806f
C7  g5280_2 gnd 2.080806f
R1 g5280_0 g5280_4 2.224404
C8 1 gnd 2.080806f
R2 1 g5280_0 2.224404
R3 g5280_3 1 2.224404
C9 2 gnd 2.080806f
R4 g5280_0 2 2.224404
R5 g5280_1 2 2.224404
C10 3 gnd 2.080806f
R6 g5280_3 3 2.224404
R7 3 g5280_5 2.224404
C11 4 gnd 2.080806f
R8 4 g5280_3 2.224404
C12 5 gnd 2.080806f
R9 5 4 2.224404
R10 g5280_6 5 2.224404
C13 6 gnd 2.080806f
R11 6 g5280_5 2.224404
C14 7 gnd 2.080806f
R12 7 6 2.224404
C15 8 gnd 2.080806f
R13 8 7 2.224404
C16 9 gnd 2.080806f
R14 9 8 2.224404
C17 10 gnd 2.080806f
R15 10 9 2.224404
C18 11 gnd 2.080806f
R16 11 10 2.224404
C19 12 gnd 2.080806f
R17 12 11 2.224404
C20 13 gnd 2.080806f
R18 13 12 2.224404
R19 g5280_2 13 2.224404
.ends

.subckt netg3718 g3718_4 g3718_6 g3718_5 g3718_1 g3718_0 g3718_2 g3718_3 gnd
C1  g3718_4 gnd 2.080806f
C2  g3718_6 gnd 2.080806f
C3  g3718_5 gnd 2.080806f
C4  g3718_1 gnd 2.080806f
C5  g3718_0 gnd 2.080806f
C6  g3718_2 gnd 2.080806f
C7  g3718_3 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g3718_0 1 2.224404
R2 1 g3718_2 2.224404
R3 g3718_2 g3718_4 2.224404
C9 2 gnd 2.080806f
R4 g3718_2 2 2.224404
R5 2 g3718_6 2.224404
C10 3 gnd 2.080806f
R6 3 g3718_6 2.224404
C11 4 gnd 2.080806f
R7 4 3 2.224404
C12 5 gnd 2.080806f
R8 5 4 2.224404
C13 6 gnd 2.080806f
R9 5 6 2.224404
R10 g3718_5 6 2.224404
C14 7 gnd 2.080806f
R11 7 g3718_5 2.224404
C15 8 gnd 2.080806f
R12 8 7 2.224404
C16 9 gnd 2.080806f
R13 9 8 2.224404
C17 10 gnd 2.080806f
R14 10 9 2.224404
C18 11 gnd 2.080806f
R15 11 10 2.224404
C19 12 gnd 2.080806f
R16 12 11 2.224404
R17 g3718_1 12 2.224404
R18 g3718_3 g3718_1 2.224404
.ends

.subckt netg1840 g1840_3 g1840_1 g1840_0 g1840_2 gnd
C1  g1840_3 gnd 2.080806f
C2  g1840_1 gnd 2.080806f
C3  g1840_0 gnd 2.080806f
C4  g1840_2 gnd 2.080806f
R1 g1840_3 g1840_0 2.224404
C5 1 gnd 2.080806f
R2 1 g1840_3 2.224404
C6 2 gnd 2.080806f
R3 2 1 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
R13 g1840_2 11 2.224404
C16 12 gnd 2.080806f
R14 12 g1840_2 2.224404
R15 g1840_1 12 2.224404
.ends

.subckt netg4626 g4626_0 g4626_1 gnd
C1  g4626_0 gnd 2.080806f
C2  g4626_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g4626_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
R15 14 g4626_1 2.224404
.ends

.subckt netg6446 g6446_1 g6446_0 gnd
C1  g6446_1 gnd 2.080806f
C2  g6446_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6446_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
R15 14 g6446_1 2.224404
.ends

.subckt netg1275 g1275_5 g1275_4 g1275_0 g1275_3 g1275_1 g1275_2 gnd
C1  g1275_5 gnd 2.080806f
C2  g1275_4 gnd 2.080806f
C3  g1275_0 gnd 2.080806f
C4  g1275_3 gnd 2.080806f
C5  g1275_1 gnd 2.080806f
C6  g1275_2 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1275_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g1275_5 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
R8 g1275_2 6 2.224404
C13 7 gnd 2.080806f
R9 7 6 2.224404
C14 8 gnd 2.080806f
R10 8 7 2.224404
R11 g1275_4 8 2.224404
C15 9 gnd 2.080806f
R12 9 g1275_4 2.224404
C16 10 gnd 2.080806f
R13 10 9 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 13 12 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
R18 g1275_3 14 2.224404
R19 g1275_3 g1275_1 2.224404
.ends

.subckt netg108 g108_0 g108_1 gnd
C1  g108_0 gnd 2.080806f
C2  g108_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g108_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
R15 14 g108_1 2.224404
.ends

.subckt netg4395 g4395_1 g4395_0 g4395_2 gnd
C1  g4395_1 gnd 2.080806f
C2  g4395_0 gnd 2.080806f
C3  g4395_2 gnd 2.080806f
R1 g4395_2 g4395_0 2.224404
C4 1 gnd 2.080806f
R2 1 g4395_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
R15 g4395_1 13 2.224404
.ends

.subckt netg3736 g3736_8 g3736_6 g3736_5 g3736_9 g3736_1 g3736_4 g3736_7 g3736_0 g3736_3 g3736_2 gnd
C1  g3736_8 gnd 2.080806f
C2  g3736_6 gnd 2.080806f
C3  g3736_5 gnd 2.080806f
C4  g3736_9 gnd 2.080806f
C5  g3736_1 gnd 2.080806f
C6  g3736_4 gnd 2.080806f
C7  g3736_7 gnd 2.080806f
C8  g3736_0 gnd 2.080806f
C9  g3736_3 gnd 2.080806f
C10  g3736_2 gnd 2.080806f
R1 g3736_0 g3736_1 2.224404
C11 1 gnd 2.080806f
R2 1 g3736_0 2.224404
R3 g3736_6 1 2.224404
C12 2 gnd 2.080806f
R4 2 g3736_1 2.224404
C13 3 gnd 2.080806f
R5 3 2 2.224404
R6 g3736_3 3 2.224404
C14 4 gnd 2.080806f
R7 4 g3736_6 2.224404
C15 5 gnd 2.080806f
R8 5 4 2.224404
R9 g3736_4 5 2.224404
C16 6 gnd 2.080806f
R10 6 g3736_6 2.224404
C17 7 gnd 2.080806f
R11 7 6 2.224404
R12 g3736_9 7 2.224404
C18 8 gnd 2.080806f
R13 5 8 2.224404
C19 9 gnd 2.080806f
R14 9 8 2.224404
R15 g3736_7 9 2.224404
C20 10 gnd 2.080806f
R16 10 g3736_9 2.224404
C21 11 gnd 2.080806f
R17 11 10 2.224404
C22 12 gnd 2.080806f
R18 12 11 2.224404
C23 13 gnd 2.080806f
R19 13 12 2.224404
C24 14 gnd 2.080806f
R20 14 13 2.224404
R21 g3736_8 14 2.224404
C25 15 gnd 2.080806f
R22 g3736_8 15 2.224404
C26 16 gnd 2.080806f
R23 15 16 2.224404
R24 16 g3736_2 2.224404
C27 17 gnd 2.080806f
R25 17 g3736_8 2.224404
C28 18 gnd 2.080806f
R26 18 17 2.224404
R27 g3736_5 18 2.224404
.ends

.subckt netg1455 g1455_1 g1455_0 gnd
C1  g1455_1 gnd 2.080806f
C2  g1455_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1455_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
R17 16 g1455_1 2.224404
.ends

.subckt netg1100 g1100_0 g1100_1 gnd
C1  g1100_0 gnd 2.080806f
C2  g1100_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1100_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
R15 g1100_1 14 2.224404
.ends

.subckt netg3839 g3839_0 g3839_5 g3839_4 g3839_2 g3839_1 g3839_3 gnd
C1  g3839_0 gnd 2.080806f
C2  g3839_5 gnd 2.080806f
C3  g3839_4 gnd 2.080806f
C4  g3839_2 gnd 2.080806f
C5  g3839_1 gnd 2.080806f
C6  g3839_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g3839_0 1 2.224404
R2 g3839_1 1 2.224404
C8 2 gnd 2.080806f
R3 2 g3839_0 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
R6 g3839_3 4 2.224404
C11 5 gnd 2.080806f
R7 5 g3839_3 2.224404
C12 6 gnd 2.080806f
R8 6 5 2.224404
C13 7 gnd 2.080806f
R9 7 6 2.224404
C14 8 gnd 2.080806f
R10 8 7 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
R12 g3839_4 9 2.224404
C16 10 gnd 2.080806f
R13 g3839_4 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
R18 g3839_5 14 2.224404
C21 15 gnd 2.080806f
R19 g3839_5 15 2.224404
R20 15 g3839_2 2.224404
.ends

.subckt netg4084 g4084_2 g4084_1 g4084_0 g4084_3 gnd
C1  g4084_2 gnd 2.080806f
C2  g4084_1 gnd 2.080806f
C3  g4084_0 gnd 2.080806f
C4  g4084_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g4084_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g4084_2 2.224404
C7 3 gnd 2.080806f
R4 3 g4084_2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
R7 5 g4084_1 2.224404
C10 6 gnd 2.080806f
R8 g4084_1 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
R15 12 g4084_3 2.224404
.ends

.subckt netg3746 g3746_3 g3746_0 g3746_1 g3746_6 g3746_7 g3746_4 g3746_2 g3746_5 gnd
C1  g3746_3 gnd 2.080806f
C2  g3746_0 gnd 2.080806f
C3  g3746_1 gnd 2.080806f
C4  g3746_6 gnd 2.080806f
C5  g3746_7 gnd 2.080806f
C6  g3746_4 gnd 2.080806f
C7  g3746_2 gnd 2.080806f
C8  g3746_5 gnd 2.080806f
R1 g3746_5 g3746_0 2.224404
C9 1 gnd 2.080806f
R2 g3746_0 1 2.224404
C10 2 gnd 2.080806f
R3 1 2 2.224404
C11 3 gnd 2.080806f
R4 2 3 2.224404
C12 4 gnd 2.080806f
R5 3 4 2.224404
C13 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g3746_1 2.224404
C14 6 gnd 2.080806f
R8 g3746_1 6 2.224404
C15 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g3746_4 2.224404
C16 8 gnd 2.080806f
R11 g3746_4 8 2.224404
C17 9 gnd 2.080806f
R12 8 9 2.224404
R13 9 g3746_3 2.224404
R14 g3746_3 g3746_2 2.224404
C18 10 gnd 2.080806f
R15 g3746_3 10 2.224404
R16 10 g3746_7 2.224404
C19 11 gnd 2.080806f
R17 1 11 2.224404
C20 12 gnd 2.080806f
R18 11 12 2.224404
C21 13 gnd 2.080806f
R19 12 13 2.224404
C22 14 gnd 2.080806f
R20 13 14 2.224404
C23 15 gnd 2.080806f
R21 14 15 2.224404
R22 15 g3746_6 2.224404
.ends

.subckt netg2849 g2849_1 g2849_2 g2849_0 g2849_3 gnd
C1  g2849_1 gnd 2.080806f
C2  g2849_2 gnd 2.080806f
C3  g2849_0 gnd 2.080806f
C4  g2849_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2849_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2849_2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g2849_3 2.224404
C11 7 gnd 2.080806f
R9 g2849_3 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
R18 15 g2849_1 2.224404
.ends

.subckt netg3103 g3103_0 g3103_2 g3103_1 gnd
C1  g3103_0 gnd 2.080806f
C2  g3103_2 gnd 2.080806f
C3  g3103_1 gnd 2.080806f
.ends

.subckt netg2075 g2075_3 g2075_5 g2075_4 g2075_2 g2075_1 g2075_0 gnd
C1  g2075_3 gnd 2.080806f
C2  g2075_5 gnd 2.080806f
C3  g2075_4 gnd 2.080806f
C4  g2075_2 gnd 2.080806f
C5  g2075_1 gnd 2.080806f
C6  g2075_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2075_0 2.224404
R2 g2075_5 1 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g2075_4 2.224404
C9 3 gnd 2.080806f
R5 3 g2075_5 2.224404
C10 4 gnd 2.080806f
R6 4 3 2.224404
R7 g2075_2 4 2.224404
C11 5 gnd 2.080806f
R8 5 g2075_4 2.224404
C12 6 gnd 2.080806f
R9 6 5 2.224404
C13 7 gnd 2.080806f
R10 7 6 2.224404
C14 8 gnd 2.080806f
R11 8 7 2.224404
C15 9 gnd 2.080806f
R12 9 8 2.224404
R13 9 g2075_3 2.224404
C16 10 gnd 2.080806f
R14 g2075_3 10 2.224404
C17 11 gnd 2.080806f
R15 10 11 2.224404
C18 12 gnd 2.080806f
R16 11 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
R19 14 g2075_1 2.224404
.ends

.subckt netg6573 g6573_4 g6573_0 g6573_2 g6573_1 g6573_5 g6573_3 gnd
C1  g6573_4 gnd 2.080806f
C2  g6573_0 gnd 2.080806f
C3  g6573_2 gnd 2.080806f
C4  g6573_1 gnd 2.080806f
C5  g6573_5 gnd 2.080806f
C6  g6573_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g6573_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6573_5 2.224404
C10 4 gnd 2.080806f
R5 4 g6573_5 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g6573_3 2.224404
C13 7 gnd 2.080806f
R9 g6573_0 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
R13 10 g6573_1 2.224404
C17 11 gnd 2.080806f
R14 11 5 2.224404
C18 12 gnd 2.080806f
R15 12 11 2.224404
R16 g6573_2 12 2.224404
C19 13 gnd 2.080806f
R17 g6573_2 13 2.224404
C20 14 gnd 2.080806f
R18 14 13 2.224404
C21 15 gnd 2.080806f
R19 14 15 2.224404
R20 g6573_4 15 2.224404
.ends

.subckt netg1086 g1086_3 g1086_5 g1086_1 g1086_4 gnd
C1  g1086_3 gnd 2.080806f
C2  g1086_5 gnd 2.080806f
C3  g1086_1 gnd 2.080806f
C4  g1086_4 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1086_1 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 g1086_4 3 2.224404
C8 4 gnd 2.080806f
R5 4 g1086_1 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
R11 g1086_5 9 2.224404
C14 10 gnd 2.080806f
R12 10 g1086_5 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
R22 g1086_3 19 2.224404
.ends

.subckt netg2540 g2540_1 g2540_2 g2540_0 gnd
C1  g2540_1 gnd 2.080806f
C2  g2540_2 gnd 2.080806f
C3  g2540_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2540_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
R9 g2540_2 8 2.224404
C12 9 gnd 2.080806f
R10 g2540_2 9 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
R16 g2540_1 14 2.224404
.ends

.subckt netg2096 g2096_4 g2096_2 g2096_1 g2096_3 g2096_0 gnd
C1  g2096_4 gnd 2.080806f
C2  g2096_2 gnd 2.080806f
C3  g2096_1 gnd 2.080806f
C4  g2096_3 gnd 2.080806f
C5  g2096_0 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g2096_0 1 2.224404
R2 1 g2096_1 2.224404
C7 2 gnd 2.080806f
R3 g2096_1 2 2.224404
C8 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g2096_2 2.224404
C9 4 gnd 2.080806f
R6 g2096_1 4 2.224404
C10 5 gnd 2.080806f
R7 4 5 2.224404
C11 6 gnd 2.080806f
R8 5 6 2.224404
C12 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g2096_4 2.224404
C13 8 gnd 2.080806f
R11 8 g2096_0 2.224404
C14 9 gnd 2.080806f
R12 9 8 2.224404
C15 10 gnd 2.080806f
R13 10 9 2.224404
C16 11 gnd 2.080806f
R14 11 10 2.224404
C17 12 gnd 2.080806f
R15 12 11 2.224404
C18 13 gnd 2.080806f
R16 13 12 2.224404
R17 g2096_3 13 2.224404
.ends

.subckt netg1337 g1337_3 g1337_1 g1337_2 g1337_5 g1337_0 g1337_6 g1337_4 gnd
C1  g1337_3 gnd 2.080806f
C2  g1337_1 gnd 2.080806f
C3  g1337_2 gnd 2.080806f
C4  g1337_5 gnd 2.080806f
C5  g1337_0 gnd 2.080806f
C6  g1337_6 gnd 2.080806f
C7  g1337_4 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g1337_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
R3 g1337_5 2 2.224404
C10 3 gnd 2.080806f
R4 1 3 2.224404
C11 4 gnd 2.080806f
R5 3 4 2.224404
C12 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g1337_6 2.224404
R8 g1337_6 g1337_3 2.224404
C13 6 gnd 2.080806f
R9 g1337_3 6 2.224404
R10 6 g1337_2 2.224404
C14 7 gnd 2.080806f
R11 7 g1337_2 2.224404
R12 g1337_4 7 2.224404
C15 8 gnd 2.080806f
R13 7 8 2.224404
C16 9 gnd 2.080806f
R14 8 9 2.224404
C17 10 gnd 2.080806f
R15 9 10 2.224404
C18 11 gnd 2.080806f
R16 10 11 2.224404
C19 12 gnd 2.080806f
R17 11 12 2.224404
C20 13 gnd 2.080806f
R18 12 13 2.224404
R19 13 g1337_1 2.224404
.ends

.subckt netg6090 g6090_2 g6090_1 g6090_0 gnd
C1  g6090_2 gnd 2.080806f
C2  g6090_1 gnd 2.080806f
C3  g6090_0 gnd 2.080806f
R1 g6090_0 g6090_1 2.224404
C4 1 gnd 2.080806f
R2 1 g6090_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
R16 g6090_2 14 2.224404
.ends

.subckt netg1592 g1592_3 g1592_1 g1592_0 g1592_2 gnd
C1  g1592_3 gnd 2.080806f
C2  g1592_1 gnd 2.080806f
C3  g1592_0 gnd 2.080806f
C4  g1592_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1592_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
C11 7 gnd 2.080806f
R7 6 7 2.224404
C12 8 gnd 2.080806f
R8 7 8 2.224404
C13 9 gnd 2.080806f
R9 8 9 2.224404
C14 10 gnd 2.080806f
R10 9 10 2.224404
C15 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g1592_3 2.224404
C16 12 gnd 2.080806f
R13 12 g1592_3 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
C20 16 gnd 2.080806f
R17 15 16 2.224404
R18 16 g1592_2 2.224404
R19 g1592_1 g1592_2 2.224404
.ends

.subckt netg570 g570_1 g570_5 g570_0 g570_4 g570_3 g570_2 gnd
C1  g570_1 gnd 2.080806f
C2  g570_5 gnd 2.080806f
C3  g570_0 gnd 2.080806f
C4  g570_4 gnd 2.080806f
C5  g570_3 gnd 2.080806f
C6  g570_2 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g570_0 2.224404
R2 g570_1 1 2.224404
C8 2 gnd 2.080806f
R3 g570_1 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
R5 g570_3 3 2.224404
C10 4 gnd 2.080806f
R6 g570_3 4 2.224404
R7 4 g570_2 2.224404
C11 5 gnd 2.080806f
R8 g570_2 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
R15 11 g570_4 2.224404
C18 12 gnd 2.080806f
R16 g570_4 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
R19 14 g570_5 2.224404
.ends

.subckt netg7147 g7147_2 g7147_1 g7147_0 gnd
C1  g7147_2 gnd 2.080806f
C2  g7147_1 gnd 2.080806f
C3  g7147_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7147_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7147_1 2 2.224404
C6 3 gnd 2.080806f
R4 g7147_0 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
R16 14 g7147_2 2.224404
.ends

.subckt netg5514 g5514_0 g5514_1 gnd
C1  g5514_0 gnd 2.080806f
C2  g5514_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g5514_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
R16 15 g5514_1 2.224404
.ends

.subckt netg4598 g4598_5 g4598_3 g4598_12 g4598_8 g4598_6 g4598_0 g4598_9 g4598_4 g4598_1 g4598_2 g4598_10 g4598_7 g4598_11 gnd
C1  g4598_5 gnd 2.080806f
C2  g4598_3 gnd 2.080806f
C3  g4598_12 gnd 2.080806f
C4  g4598_8 gnd 2.080806f
C5  g4598_6 gnd 2.080806f
C6  g4598_0 gnd 2.080806f
C7  g4598_9 gnd 2.080806f
C8  g4598_4 gnd 2.080806f
C9  g4598_1 gnd 2.080806f
C10  g4598_2 gnd 2.080806f
C11  g4598_10 gnd 2.080806f
C12  g4598_7 gnd 2.080806f
C13  g4598_11 gnd 2.080806f
C14 1 gnd 2.080806f
R1 1 g4598_0 2.224404
C15 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4598_11 2 2.224404
R4 g4598_8 g4598_11 2.224404
R5 g4598_2 g4598_8 2.224404
R6 g4598_6 g4598_8 2.224404
C16 3 gnd 2.080806f
R7 3 g4598_11 2.224404
R8 g4598_4 3 2.224404
C17 4 gnd 2.080806f
R9 g4598_11 4 2.224404
C18 5 gnd 2.080806f
R10 4 5 2.224404
C19 6 gnd 2.080806f
R11 5 6 2.224404
R12 6 g4598_3 2.224404
C20 7 gnd 2.080806f
R13 7 g4598_3 2.224404
R14 7 g4598_12 2.224404
R15 g4598_1 g4598_12 2.224404
R16 g4598_1 g4598_9 2.224404
C21 8 gnd 2.080806f
R17 8 g4598_9 2.224404
R18 8 g4598_7 2.224404
C22 9 gnd 2.080806f
R19 g4598_12 9 2.224404
C23 10 gnd 2.080806f
R20 9 10 2.224404
C24 11 gnd 2.080806f
R21 10 11 2.224404
R22 11 g4598_5 2.224404
C25 12 gnd 2.080806f
R23 g4598_9 12 2.224404
C26 13 gnd 2.080806f
R24 12 13 2.224404
C27 14 gnd 2.080806f
R25 13 14 2.224404
C28 15 gnd 2.080806f
R26 14 15 2.224404
R27 15 g4598_10 2.224404
.ends

.subckt netg5258 g5258_0 g5258_1 g5258_4 g5258_3 g5258_2 gnd
C1  g5258_0 gnd 2.080806f
C2  g5258_1 gnd 2.080806f
C3  g5258_4 gnd 2.080806f
C4  g5258_3 gnd 2.080806f
C5  g5258_2 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g5258_0 2.224404
R2 g5258_1 1 2.224404
R3 g5258_2 g5258_1 2.224404
R4 g5258_4 1 2.224404
C7 2 gnd 2.080806f
R5 2 g5258_2 2.224404
C8 3 gnd 2.080806f
R6 3 2 2.224404
C9 4 gnd 2.080806f
R7 4 3 2.224404
C10 5 gnd 2.080806f
R8 5 4 2.224404
C11 6 gnd 2.080806f
R9 6 5 2.224404
C12 7 gnd 2.080806f
R10 7 6 2.224404
C13 8 gnd 2.080806f
R11 8 7 2.224404
C14 9 gnd 2.080806f
R12 9 8 2.224404
C15 10 gnd 2.080806f
R13 10 9 2.224404
C16 11 gnd 2.080806f
R14 11 10 2.224404
C17 12 gnd 2.080806f
R15 12 11 2.224404
C18 13 gnd 2.080806f
R16 12 13 2.224404
R17 g5258_3 13 2.224404
.ends

.subckt netg70 g70_0 g70_1 g70_2 gnd
C1  g70_0 gnd 2.080806f
C2  g70_1 gnd 2.080806f
C3  g70_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g70_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g70_2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
R16 g70_1 14 2.224404
.ends

.subckt netg1971 g1971_4 g1971_0 g1971_2 g1971_6 g1971_5 g1971_3 g1971_1 gnd
C1  g1971_4 gnd 2.080806f
C2  g1971_0 gnd 2.080806f
C3  g1971_2 gnd 2.080806f
C4  g1971_6 gnd 2.080806f
C5  g1971_5 gnd 2.080806f
C6  g1971_3 gnd 2.080806f
C7  g1971_1 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g1971_0 2.224404
R2 g1971_6 1 2.224404
C9 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g1971_2 2.224404
C10 3 gnd 2.080806f
R5 3 g1971_6 2.224404
C11 4 gnd 2.080806f
R6 4 3 2.224404
C12 5 gnd 2.080806f
R7 5 4 2.224404
R8 g1971_3 5 2.224404
C13 6 gnd 2.080806f
R9 g1971_3 6 2.224404
C14 7 gnd 2.080806f
R10 6 7 2.224404
C15 8 gnd 2.080806f
R11 7 8 2.224404
C16 9 gnd 2.080806f
R12 8 9 2.224404
C17 10 gnd 2.080806f
R13 9 10 2.224404
R14 g1971_4 10 2.224404
C18 11 gnd 2.080806f
R15 10 11 2.224404
C19 12 gnd 2.080806f
R16 11 12 2.224404
R17 12 g1971_5 2.224404
C20 13 gnd 2.080806f
R18 g1971_4 13 2.224404
C21 14 gnd 2.080806f
R19 13 14 2.224404
C22 15 gnd 2.080806f
R20 14 15 2.224404
C23 16 gnd 2.080806f
R21 15 16 2.224404
R22 g1971_1 16 2.224404
.ends

.subckt netx491 x491_1 x491_0 gnd
C1  x491_1 gnd 2.080806f
C2  x491_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x491_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
R16 15 x491_1 2.224404
.ends

.subckt netg423 g423_4 g423_1 g423_0 g423_3 g423_2 gnd
C1  g423_4 gnd 2.080806f
C2  g423_1 gnd 2.080806f
C3  g423_0 gnd 2.080806f
C4  g423_3 gnd 2.080806f
C5  g423_2 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g423_0 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g423_1 2.224404
C8 3 gnd 2.080806f
R4 3 g423_1 2.224404
C9 4 gnd 2.080806f
R5 3 4 2.224404
C10 5 gnd 2.080806f
R6 4 5 2.224404
C11 6 gnd 2.080806f
R7 5 6 2.224404
C12 7 gnd 2.080806f
R8 7 6 2.224404
C13 8 gnd 2.080806f
R9 7 8 2.224404
C14 9 gnd 2.080806f
R10 8 9 2.224404
R11 9 g423_3 2.224404
R12 g423_3 g423_2 2.224404
C15 10 gnd 2.080806f
R13 g423_2 10 2.224404
C16 11 gnd 2.080806f
R14 10 11 2.224404
C17 12 gnd 2.080806f
R15 11 12 2.224404
C18 13 gnd 2.080806f
R16 12 13 2.224404
C19 14 gnd 2.080806f
R17 13 14 2.224404
R18 14 g423_4 2.224404
.ends

.subckt netg760 g760_1 g760_4 g760_2 g760_0 g760_6 g760_3 g760_5 gnd
C1  g760_1 gnd 2.080806f
C2  g760_4 gnd 2.080806f
C3  g760_2 gnd 2.080806f
C4  g760_0 gnd 2.080806f
C5  g760_6 gnd 2.080806f
C6  g760_3 gnd 2.080806f
C7  g760_5 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g760_0 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
R3 g760_6 2 2.224404
R4 g760_6 g760_2 2.224404
C10 3 gnd 2.080806f
R5 3 g760_0 2.224404
C11 4 gnd 2.080806f
R6 4 3 2.224404
C12 5 gnd 2.080806f
R7 4 5 2.224404
C13 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g760_4 2.224404
C14 7 gnd 2.080806f
R10 7 g760_4 2.224404
C15 8 gnd 2.080806f
R11 7 8 2.224404
R12 8 g760_1 2.224404
C16 9 gnd 2.080806f
R13 9 g760_1 2.224404
C17 10 gnd 2.080806f
R14 10 9 2.224404
C18 11 gnd 2.080806f
R15 11 10 2.224404
R16 g760_5 11 2.224404
C19 12 gnd 2.080806f
R17 12 g760_5 2.224404
C20 13 gnd 2.080806f
R18 13 12 2.224404
C21 14 gnd 2.080806f
R19 14 13 2.224404
R20 g760_3 14 2.224404
.ends

.subckt netg4498 g4498_7 g4498_6 g4498_2 g4498_8 g4498_1 g4498_9 g4498_4 g4498_5 g4498_0 g4498_3 gnd
C1  g4498_7 gnd 2.080806f
C2  g4498_6 gnd 2.080806f
C3  g4498_2 gnd 2.080806f
C4  g4498_8 gnd 2.080806f
C5  g4498_1 gnd 2.080806f
C6  g4498_9 gnd 2.080806f
C7  g4498_4 gnd 2.080806f
C8  g4498_5 gnd 2.080806f
C9  g4498_0 gnd 2.080806f
C10  g4498_3 gnd 2.080806f
C11 1 gnd 2.080806f
R1 1 g4498_0 2.224404
C12 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4498_3 2 2.224404
C13 3 gnd 2.080806f
R4 g4498_0 3 2.224404
C14 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g4498_4 2.224404
C15 5 gnd 2.080806f
R7 3 5 2.224404
R8 5 g4498_5 2.224404
R9 g4498_5 g4498_7 2.224404
R10 g4498_7 g4498_2 2.224404
R11 g4498_2 g4498_9 2.224404
C16 6 gnd 2.080806f
R12 g4498_2 6 2.224404
C17 7 gnd 2.080806f
R13 6 7 2.224404
R14 7 g4498_6 2.224404
C18 8 gnd 2.080806f
R15 g4498_6 8 2.224404
C19 9 gnd 2.080806f
R16 8 9 2.224404
R17 9 g4498_1 2.224404
C20 10 gnd 2.080806f
R18 g4498_1 10 2.224404
R19 10 g4498_8 2.224404
.ends

.subckt netg67 g67_1 g67_0 gnd
C1  g67_1 gnd 2.080806f
C2  g67_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g67_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
R16 g67_1 15 2.224404
.ends

.subckt netg6784 g6784_2 g6784_0 g6784_1 gnd
C1  g6784_2 gnd 2.080806f
C2  g6784_0 gnd 2.080806f
C3  g6784_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6784_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6784_1 2.224404
C6 3 gnd 2.080806f
R4 1 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
R16 14 g6784_2 2.224404
.ends

.subckt netg7436 g7436_1 g7436_0 gnd
C1  g7436_1 gnd 2.080806f
C2  g7436_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7436_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
R16 g7436_1 15 2.224404
.ends

.subckt netg1807 g1807_0 g1807_1 g1807_3 g1807_2 gnd
C1  g1807_0 gnd 2.080806f
C2  g1807_1 gnd 2.080806f
C3  g1807_3 gnd 2.080806f
C4  g1807_2 gnd 2.080806f
.ends

.subckt netg72 g72_0 g72_1 g72_2 gnd
C1  g72_0 gnd 2.080806f
C2  g72_1 gnd 2.080806f
C3  g72_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g72_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
R8 g72_2 7 2.224404
C11 8 gnd 2.080806f
R9 g72_2 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
R17 15 g72_1 2.224404
.ends

.subckt netg602 g602_4 g602_2 g602_1 g602_0 g602_5 g602_3 gnd
C1  g602_4 gnd 2.080806f
C2  g602_2 gnd 2.080806f
C3  g602_1 gnd 2.080806f
C4  g602_0 gnd 2.080806f
C5  g602_5 gnd 2.080806f
C6  g602_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g602_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
R4 g602_4 3 2.224404
C10 4 gnd 2.080806f
R5 4 g602_4 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
R11 g602_1 9 2.224404
C16 10 gnd 2.080806f
R12 10 g602_1 2.224404
R13 g602_3 10 2.224404
C17 11 gnd 2.080806f
R14 11 7 2.224404
C18 12 gnd 2.080806f
R15 12 11 2.224404
R16 g602_5 12 2.224404
R17 g602_2 g602_5 2.224404
.ends

.subckt netg6423 g6423_5 g6423_2 g6423_3 g6423_4 g6423_1 g6423_0 g6423_6 gnd
C1  g6423_5 gnd 2.080806f
C2  g6423_2 gnd 2.080806f
C3  g6423_3 gnd 2.080806f
C4  g6423_4 gnd 2.080806f
C5  g6423_1 gnd 2.080806f
C6  g6423_0 gnd 2.080806f
C7  g6423_6 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g6423_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6423_1 2.224404
C10 3 gnd 2.080806f
R4 1 3 2.224404
C11 4 gnd 2.080806f
R5 3 4 2.224404
C12 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g6423_5 2.224404
C13 6 gnd 2.080806f
R8 6 g6423_5 2.224404
C14 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g6423_4 2.224404
C15 8 gnd 2.080806f
R11 g6423_4 8 2.224404
R12 8 g6423_3 2.224404
C16 9 gnd 2.080806f
R13 g6423_4 9 2.224404
C17 10 gnd 2.080806f
R14 9 10 2.224404
C18 11 gnd 2.080806f
R15 10 11 2.224404
R16 11 g6423_2 2.224404
C19 12 gnd 2.080806f
R17 g6423_2 12 2.224404
C20 13 gnd 2.080806f
R18 12 13 2.224404
C21 14 gnd 2.080806f
R19 13 14 2.224404
C22 15 gnd 2.080806f
R20 14 15 2.224404
R21 g6423_6 15 2.224404
.ends

.subckt netg6942 g6942_3 g6942_4 g6942_5 g6942_0 g6942_2 g6942_1 gnd
C1  g6942_3 gnd 2.080806f
C2  g6942_4 gnd 2.080806f
C3  g6942_5 gnd 2.080806f
C4  g6942_0 gnd 2.080806f
C5  g6942_2 gnd 2.080806f
C6  g6942_1 gnd 2.080806f
R1 g6942_2 g6942_0 2.224404
C7 1 gnd 2.080806f
R2 1 g6942_2 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g6942_3 2.224404
C9 3 gnd 2.080806f
R5 g6942_3 3 2.224404
R6 3 g6942_4 2.224404
C10 4 gnd 2.080806f
R7 4 g6942_3 2.224404
C11 5 gnd 2.080806f
R8 5 4 2.224404
R9 g6942_1 5 2.224404
C12 6 gnd 2.080806f
R10 g6942_0 6 2.224404
C13 7 gnd 2.080806f
R11 6 7 2.224404
C14 8 gnd 2.080806f
R12 7 8 2.224404
C15 9 gnd 2.080806f
R13 8 9 2.224404
C16 10 gnd 2.080806f
R14 9 10 2.224404
C17 11 gnd 2.080806f
R15 10 11 2.224404
C18 12 gnd 2.080806f
R16 11 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
R18 13 g6942_5 2.224404
.ends

.subckt netg3828 g3828_10 g3828_2 g3828_5 g3828_9 g3828_8 g3828_6 g3828_1 g3828_0 g3828_7 g3828_4 g3828_3 gnd
C1  g3828_10 gnd 2.080806f
C2  g3828_2 gnd 2.080806f
C3  g3828_5 gnd 2.080806f
C4  g3828_9 gnd 2.080806f
C5  g3828_8 gnd 2.080806f
C6  g3828_6 gnd 2.080806f
C7  g3828_1 gnd 2.080806f
C8  g3828_0 gnd 2.080806f
C9  g3828_7 gnd 2.080806f
C10  g3828_4 gnd 2.080806f
C11  g3828_3 gnd 2.080806f
C12 1 gnd 2.080806f
R1 g3828_0 1 2.224404
R2 1 g3828_1 2.224404
C13 2 gnd 2.080806f
R3 g3828_0 2 2.224404
R4 2 g3828_7 2.224404
R5 g3828_10 1 2.224404
C14 3 gnd 2.080806f
R6 3 g3828_7 2.224404
R7 3 g3828_8 2.224404
C15 4 gnd 2.080806f
R8 g3828_7 4 2.224404
C16 5 gnd 2.080806f
R9 4 5 2.224404
R10 5 g3828_3 2.224404
R11 g3828_3 g3828_9 2.224404
R12 g3828_9 g3828_5 2.224404
R13 g3828_5 g3828_2 2.224404
C17 6 gnd 2.080806f
R14 6 g3828_2 2.224404
R15 6 g3828_4 2.224404
C18 7 gnd 2.080806f
R16 7 g3828_0 2.224404
C19 8 gnd 2.080806f
R17 8 7 2.224404
C20 9 gnd 2.080806f
R18 9 8 2.224404
C21 10 gnd 2.080806f
R19 10 9 2.224404
C22 11 gnd 2.080806f
R20 11 10 2.224404
R21 g3828_6 11 2.224404
.ends

.subckt netg2045 g2045_3 g2045_1 g2045_0 g2045_2 gnd
C1  g2045_3 gnd 2.080806f
C2  g2045_1 gnd 2.080806f
C3  g2045_0 gnd 2.080806f
C4  g2045_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2045_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
R6 g2045_1 5 2.224404
R7 g2045_2 g2045_1 2.224404
C10 6 gnd 2.080806f
R8 6 2 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
R18 g2045_3 15 2.224404
.ends

.subckt netg103 g103_1 g103_0 gnd
C1  g103_1 gnd 2.080806f
C2  g103_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g103_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
R17 g103_1 16 2.224404
.ends

.subckt netg1816 g1816_3 g1816_2 g1816_1 g1816_0 gnd
C1  g1816_3 gnd 2.080806f
C2  g1816_2 gnd 2.080806f
C3  g1816_1 gnd 2.080806f
C4  g1816_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1816_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
R4 g1816_3 3 2.224404
C8 4 gnd 2.080806f
R5 g1816_0 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
R12 10 g1816_1 2.224404
C15 11 gnd 2.080806f
R13 g1816_1 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
R17 14 g1816_2 2.224404
.ends

.subckt netg1500 g1500_0 g1500_1 gnd
C1  g1500_0 gnd 2.080806f
C2  g1500_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1500_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
R17 16 g1500_1 2.224404
.ends

.subckt netg125 g125_1 g125_0 gnd
C1  g125_1 gnd 2.080806f
C2  g125_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g125_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
R17 g125_1 16 2.224404
.ends

.subckt netg6281 g6281_2 g6281_0 g6281_1 gnd
C1  g6281_2 gnd 2.080806f
C2  g6281_0 gnd 2.080806f
C3  g6281_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6281_0 1 2.224404
R2 1 g6281_1 2.224404
C5 2 gnd 2.080806f
R3 g6281_0 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
R18 16 g6281_2 2.224404
.ends

.subckt netg7144 g7144_1 g7144_2 g7144_0 gnd
C1  g7144_1 gnd 2.080806f
C2  g7144_2 gnd 2.080806f
C3  g7144_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g7144_0 1 2.224404
R2 1 g7144_2 2.224404
C5 2 gnd 2.080806f
R3 g7144_2 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
R17 15 g7144_1 2.224404
.ends

.subckt netg4568 g4568_13 g4568_12 g4568_9 g4568_6 g4568_4 g4568_10 g4568_8 g4568_2 g4568_11 g4568_1 g4568_3 g4568_7 gnd
C1  g4568_13 gnd 2.080806f
C2  g4568_12 gnd 2.080806f
C3  g4568_9 gnd 2.080806f
C4  g4568_6 gnd 2.080806f
C5  g4568_4 gnd 2.080806f
C6  g4568_10 gnd 2.080806f
C7  g4568_8 gnd 2.080806f
C8  g4568_2 gnd 2.080806f
C9  g4568_11 gnd 2.080806f
C10  g4568_1 gnd 2.080806f
C11  g4568_3 gnd 2.080806f
C12  g4568_7 gnd 2.080806f
C13 1 gnd 2.080806f
R1 g4568_8 1 2.224404
C14 2 gnd 2.080806f
R2 1 2 2.224404
C15 3 gnd 2.080806f
R3 2 3 2.224404
C16 4 gnd 2.080806f
R4 3 4 2.224404
C17 5 gnd 2.080806f
R5 4 5 2.224404
C18 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g4568_3 2.224404
C19 7 gnd 2.080806f
R8 g4568_3 7 2.224404
R9 7 g4568_10 2.224404
R10 g4568_10 g4568_12 2.224404
R11 g4568_12 g4568_6 2.224404
C20 8 gnd 2.080806f
R12 g4568_6 8 2.224404
R13 8 g4568_11 2.224404
R14 8 g4568_13 2.224404
C21 9 gnd 2.080806f
R15 9 g4568_12 2.224404
R16 g4568_1 9 2.224404
C22 10 gnd 2.080806f
R17 g4568_13 10 2.224404
R18 10 g4568_4 2.224404
R19 g4568_2 g4568_4 2.224404
C23 11 gnd 2.080806f
R20 g4568_11 11 2.224404
R21 11 g4568_9 2.224404
C24 12 gnd 2.080806f
R22 g4568_11 12 2.224404
R23 12 g4568_7 2.224404
.ends

.subckt netg126 g126_0 g126_1 gnd
C1  g126_0 gnd 2.080806f
C2  g126_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g126_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
R17 16 g126_1 2.224404
.ends

.subckt netg7511 g7511_1 g7511_0 gnd
C1  g7511_1 gnd 2.080806f
C2  g7511_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7511_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
R17 16 g7511_1 2.224404
.ends

.subckt netg2801 g2801_1 g2801_0 gnd
C1  g2801_1 gnd 2.080806f
C2  g2801_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g2801_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
R17 16 g2801_1 2.224404
.ends

.subckt netg105 g105_0 g105_1 gnd
C1  g105_0 gnd 2.080806f
C2  g105_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g105_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
R17 g105_1 16 2.224404
.ends

.subckt netg1282 g1282_1 g1282_0 gnd
C1  g1282_1 gnd 2.080806f
C2  g1282_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1282_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
R17 g1282_1 16 2.224404
.ends

.subckt netg1856 g1856_2 g1856_0 g1856_1 gnd
C1  g1856_2 gnd 2.080806f
C2  g1856_0 gnd 2.080806f
C3  g1856_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1856_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
R14 13 g1856_2 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
R17 15 g1856_1 2.224404
.ends

.subckt netg6366 g6366_3 g6366_2 g6366_0 g6366_1 gnd
C1  g6366_3 gnd 2.080806f
C2  g6366_2 gnd 2.080806f
C3  g6366_0 gnd 2.080806f
C4  g6366_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g6366_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
R3 g6366_2 2 2.224404
C7 3 gnd 2.080806f
R4 3 g6366_2 2.224404
R5 g6366_1 3 2.224404
C8 4 gnd 2.080806f
R6 g6366_0 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
R17 14 g6366_3 2.224404
.ends

.subckt netg73 g73_2 g73_1 g73_0 gnd
C1  g73_2 gnd 2.080806f
C2  g73_1 gnd 2.080806f
C3  g73_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g73_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
R5 g73_1 4 2.224404
C8 5 gnd 2.080806f
R6 g73_0 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
R17 15 g73_2 2.224404
.ends

.subckt netg7534 g7534_1 g7534_0 gnd
C1  g7534_1 gnd 2.080806f
C2  g7534_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7534_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
R17 g7534_1 16 2.224404
.ends

.subckt netg81 g81_1 g81_0 gnd
C1  g81_1 gnd 2.080806f
C2  g81_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g81_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
R17 16 g81_1 2.224404
.ends

.subckt netg6610 g6610_1 g6610_0 gnd
C1  g6610_1 gnd 2.080806f
C2  g6610_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6610_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
R17 g6610_1 16 2.224404
.ends

.subckt netg1600 g1600_2 g1600_3 g1600_1 g1600_0 gnd
C1  g1600_2 gnd 2.080806f
C2  g1600_3 gnd 2.080806f
C3  g1600_1 gnd 2.080806f
C4  g1600_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1600_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1600_2 2 2.224404
C7 3 gnd 2.080806f
R4 g1600_0 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 11 12 2.224404
R14 12 g1600_1 2.224404
C17 13 gnd 2.080806f
R15 g1600_1 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
R17 14 g1600_3 2.224404
.ends

.subckt netg6026 g6026_6 g6026_4 g6026_0 g6026_5 g6026_3 g6026_1 g6026_2 gnd
C1  g6026_6 gnd 2.080806f
C2  g6026_4 gnd 2.080806f
C3  g6026_0 gnd 2.080806f
C4  g6026_5 gnd 2.080806f
C5  g6026_3 gnd 2.080806f
C6  g6026_1 gnd 2.080806f
C7  g6026_2 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g6026_0 1 2.224404
R2 1 g6026_6 2.224404
R3 g6026_6 g6026_1 2.224404
R4 g6026_6 g6026_2 2.224404
R5 g6026_4 g6026_6 2.224404
R6 g6026_2 g6026_3 2.224404
C9 2 gnd 2.080806f
R7 g6026_0 2 2.224404
C10 3 gnd 2.080806f
R8 2 3 2.224404
C11 4 gnd 2.080806f
R9 3 4 2.224404
C12 5 gnd 2.080806f
R10 5 4 2.224404
C13 6 gnd 2.080806f
R11 6 5 2.224404
C14 7 gnd 2.080806f
R12 7 6 2.224404
C15 8 gnd 2.080806f
R13 8 7 2.224404
C16 9 gnd 2.080806f
R14 9 8 2.224404
C17 10 gnd 2.080806f
R15 10 9 2.224404
C18 11 gnd 2.080806f
R16 11 10 2.224404
C19 12 gnd 2.080806f
R17 11 12 2.224404
C20 13 gnd 2.080806f
R18 12 13 2.224404
R19 13 g6026_5 2.224404
.ends

.subckt netg80 g80_0 g80_1 gnd
C1  g80_0 gnd 2.080806f
C2  g80_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g80_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
R17 16 g80_1 2.224404
.ends

.subckt netg1350 g1350_5 g1350_4 g1350_2 g1350_0 g1350_3 g1350_1 gnd
C1  g1350_5 gnd 2.080806f
C2  g1350_4 gnd 2.080806f
C3  g1350_2 gnd 2.080806f
C4  g1350_0 gnd 2.080806f
C5  g1350_3 gnd 2.080806f
C6  g1350_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1350_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1350_3 2.224404
C10 4 gnd 2.080806f
R5 4 g1350_0 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 7 8 2.224404
R10 g1350_5 8 2.224404
C15 9 gnd 2.080806f
R11 9 4 2.224404
C16 10 gnd 2.080806f
R12 10 9 2.224404
C17 11 gnd 2.080806f
R13 11 10 2.224404
C18 12 gnd 2.080806f
R14 12 11 2.224404
C19 13 gnd 2.080806f
R15 13 12 2.224404
R16 g1350_4 13 2.224404
C20 14 gnd 2.080806f
R17 14 g1350_4 2.224404
R18 g1350_1 14 2.224404
C21 15 gnd 2.080806f
R19 g1350_1 15 2.224404
C22 16 gnd 2.080806f
R20 16 15 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 19 18 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
R25 g1350_2 20 2.224404
.ends

.subckt netg2049 g2049_5 g2049_0 g2049_1 g2049_4 g2049_2 g2049_3 gnd
C1  g2049_5 gnd 2.080806f
C2  g2049_0 gnd 2.080806f
C3  g2049_1 gnd 2.080806f
C4  g2049_4 gnd 2.080806f
C5  g2049_2 gnd 2.080806f
C6  g2049_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g2049_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2049_2 2.224404
C10 4 gnd 2.080806f
R5 4 g2049_2 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 8 9 2.224404
C16 10 gnd 2.080806f
R11 9 10 2.224404
R12 10 g2049_3 2.224404
C17 11 gnd 2.080806f
R13 11 9 2.224404
C18 12 gnd 2.080806f
R14 12 11 2.224404
R15 g2049_5 12 2.224404
C19 13 gnd 2.080806f
R16 13 g2049_5 2.224404
C20 14 gnd 2.080806f
R17 14 13 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
R20 16 g2049_1 2.224404
C23 17 gnd 2.080806f
R21 17 14 2.224404
C24 18 gnd 2.080806f
R22 18 17 2.224404
R23 g2049_4 18 2.224404
.ends

.subckt netg71 g71_1 g71_2 g71_0 gnd
C1  g71_1 gnd 2.080806f
C2  g71_2 gnd 2.080806f
C3  g71_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g71_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g71_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 g71_1 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
R17 g71_2 15 2.224404
.ends

.subckt netg4812 g4812_6 g4812_1 g4812_3 g4812_7 g4812_5 g4812_2 g4812_4 gnd
C1  g4812_6 gnd 2.080806f
C2  g4812_1 gnd 2.080806f
C3  g4812_3 gnd 2.080806f
C4  g4812_7 gnd 2.080806f
C5  g4812_5 gnd 2.080806f
C6  g4812_2 gnd 2.080806f
C7  g4812_4 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g4812_2 2.224404
R2 g4812_5 1 2.224404
R3 g4812_6 g4812_5 2.224404
C9 2 gnd 2.080806f
R4 2 g4812_2 2.224404
C10 3 gnd 2.080806f
R5 3 2 2.224404
R6 g4812_3 3 2.224404
C11 4 gnd 2.080806f
R7 4 g4812_3 2.224404
C12 5 gnd 2.080806f
R8 5 4 2.224404
C13 6 gnd 2.080806f
R9 6 5 2.224404
C14 7 gnd 2.080806f
R10 7 6 2.224404
C15 8 gnd 2.080806f
R11 8 7 2.224404
C16 9 gnd 2.080806f
R12 9 8 2.224404
C17 10 gnd 2.080806f
R13 10 9 2.224404
C18 11 gnd 2.080806f
R14 11 10 2.224404
R15 g4812_7 11 2.224404
C19 12 gnd 2.080806f
R16 12 g4812_7 2.224404
C20 13 gnd 2.080806f
R17 13 12 2.224404
R18 g4812_4 13 2.224404
C21 14 gnd 2.080806f
R19 14 g4812_4 2.224404
C22 15 gnd 2.080806f
R20 15 14 2.224404
C23 16 gnd 2.080806f
R21 15 16 2.224404
C24 17 gnd 2.080806f
R22 16 17 2.224404
R23 17 g4812_1 2.224404
.ends

.subckt netg104 g104_0 g104_1 gnd
C1  g104_0 gnd 2.080806f
C2  g104_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g104_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
R17 16 g104_1 2.224404
.ends

.subckt netg6703 g6703_1 g6703_0 gnd
C1  g6703_1 gnd 2.080806f
C2  g6703_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6703_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
R18 17 g6703_1 2.224404
.ends

.subckt netg1616 g1616_3 g1616_2 g1616_0 g1616_1 gnd
C1  g1616_3 gnd 2.080806f
C2  g1616_2 gnd 2.080806f
C3  g1616_0 gnd 2.080806f
C4  g1616_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1616_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
R5 4 g1616_1 2.224404
C9 5 gnd 2.080806f
R6 g1616_1 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
R11 9 g1616_3 2.224404
C14 10 gnd 2.080806f
R12 10 4 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
R21 g1616_2 18 2.224404
.ends

.subckt netg6401 g6401_0 g6401_1 gnd
C1  g6401_0 gnd 2.080806f
C2  g6401_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6401_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
R18 g6401_1 17 2.224404
.ends

.subckt netg3694 g3694_3 g3694_1 g3694_2 g3694_0 gnd
C1  g3694_3 gnd 2.080806f
C2  g3694_1 gnd 2.080806f
C3  g3694_2 gnd 2.080806f
C4  g3694_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g3694_0 1 2.224404
R2 g3694_1 1 2.224404
R3 1 g3694_2 2.224404
C6 2 gnd 2.080806f
R4 2 g3694_1 2.224404
C7 3 gnd 2.080806f
R5 3 2 2.224404
C8 4 gnd 2.080806f
R6 4 3 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
R19 g3694_3 16 2.224404
.ends

.subckt netg1679 g1679_0 g1679_3 g1679_2 g1679_1 gnd
C1  g1679_0 gnd 2.080806f
C2  g1679_3 gnd 2.080806f
C3  g1679_2 gnd 2.080806f
C4  g1679_1 gnd 2.080806f
R1 g1679_0 g1679_2 2.224404
C5 1 gnd 2.080806f
R2 g1679_2 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g1679_3 2.224404
C11 7 gnd 2.080806f
R9 7 g1679_3 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
R21 g1679_1 18 2.224404
.ends

.subckt netg3024 g3024_5 g3024_1 g3024_4 g3024_2 g3024_3 g3024_0 gnd
C1  g3024_5 gnd 2.080806f
C2  g3024_1 gnd 2.080806f
C3  g3024_4 gnd 2.080806f
C4  g3024_2 gnd 2.080806f
C5  g3024_3 gnd 2.080806f
C6  g3024_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g3024_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3024_4 2.224404
C9 3 gnd 2.080806f
R4 3 g3024_4 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g3024_3 2.224404
C12 6 gnd 2.080806f
R8 6 g3024_3 2.224404
C13 7 gnd 2.080806f
R9 7 6 2.224404
C14 8 gnd 2.080806f
R10 8 7 2.224404
R11 8 g3024_2 2.224404
C15 9 gnd 2.080806f
R12 9 8 2.224404
C16 10 gnd 2.080806f
R13 10 9 2.224404
C17 11 gnd 2.080806f
R14 11 10 2.224404
C18 12 gnd 2.080806f
R15 12 11 2.224404
C19 13 gnd 2.080806f
R16 13 12 2.224404
C20 14 gnd 2.080806f
R17 14 13 2.224404
R18 g3024_1 14 2.224404
C21 15 gnd 2.080806f
R19 15 g3024_1 2.224404
C22 16 gnd 2.080806f
R20 16 15 2.224404
C23 17 gnd 2.080806f
R21 17 16 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
R24 19 g3024_5 2.224404
.ends

.subckt netg628 g628_4 g628_2 g628_5 g628_3 g628_1 g628_0 gnd
C1  g628_4 gnd 2.080806f
C2  g628_2 gnd 2.080806f
C3  g628_5 gnd 2.080806f
C4  g628_3 gnd 2.080806f
C5  g628_1 gnd 2.080806f
C6  g628_0 gnd 2.080806f
R1 g628_2 g628_0 2.224404
R2 g628_0 g628_4 2.224404
R3 g628_4 g628_1 2.224404
C7 1 gnd 2.080806f
R4 g628_1 1 2.224404
C8 2 gnd 2.080806f
R5 1 2 2.224404
C9 3 gnd 2.080806f
R6 2 3 2.224404
C10 4 gnd 2.080806f
R7 3 4 2.224404
C11 5 gnd 2.080806f
R8 4 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
R10 6 g628_3 2.224404
C13 7 gnd 2.080806f
R11 7 g628_3 2.224404
C14 8 gnd 2.080806f
R12 8 7 2.224404
C15 9 gnd 2.080806f
R13 9 8 2.224404
C16 10 gnd 2.080806f
R14 10 9 2.224404
C17 11 gnd 2.080806f
R15 11 10 2.224404
C18 12 gnd 2.080806f
R16 12 11 2.224404
C19 13 gnd 2.080806f
R17 13 12 2.224404
C20 14 gnd 2.080806f
R18 14 13 2.224404
R19 g628_5 14 2.224404
.ends

.subckt netg4711 g4711_4 g4711_7 g4711_2 g4711_1 g4711_8 g4711_6 g4711_0 g4711_3 g4711_9 g4711_5 gnd
C1  g4711_4 gnd 2.080806f
C2  g4711_7 gnd 2.080806f
C3  g4711_2 gnd 2.080806f
C4  g4711_1 gnd 2.080806f
C5  g4711_8 gnd 2.080806f
C6  g4711_6 gnd 2.080806f
C7  g4711_0 gnd 2.080806f
C8  g4711_3 gnd 2.080806f
C9  g4711_9 gnd 2.080806f
C10  g4711_5 gnd 2.080806f
C11 1 gnd 2.080806f
R1 g4711_0 1 2.224404
R2 1 g4711_2 2.224404
R3 g4711_2 g4711_7 2.224404
R4 g4711_4 1 2.224404
C12 2 gnd 2.080806f
R5 1 2 2.224404
R6 2 g4711_5 2.224404
C13 3 gnd 2.080806f
R7 3 g4711_0 2.224404
C14 4 gnd 2.080806f
R8 4 3 2.224404
C15 5 gnd 2.080806f
R9 5 4 2.224404
R10 g4711_3 5 2.224404
C16 6 gnd 2.080806f
R11 g4711_3 6 2.224404
R12 g4711_1 6 2.224404
C17 7 gnd 2.080806f
R13 g4711_7 7 2.224404
C18 8 gnd 2.080806f
R14 7 8 2.224404
C19 9 gnd 2.080806f
R15 8 9 2.224404
R16 9 g4711_8 2.224404
C20 10 gnd 2.080806f
R17 10 g4711_1 2.224404
C21 11 gnd 2.080806f
R18 11 10 2.224404
C22 12 gnd 2.080806f
R19 12 11 2.224404
C23 13 gnd 2.080806f
R20 13 12 2.224404
R21 g4711_9 13 2.224404
C24 14 gnd 2.080806f
R22 13 14 2.224404
R23 14 g4711_6 2.224404
.ends

.subckt netg4463 g4463_10 g4463_5 g4463_9 g4463_4 g4463_8 g4463_2 g4463_6 g4463_0 g4463_1 g4463_7 g4463_3 gnd
C1  g4463_10 gnd 2.080806f
C2  g4463_5 gnd 2.080806f
C3  g4463_9 gnd 2.080806f
C4  g4463_4 gnd 2.080806f
C5  g4463_8 gnd 2.080806f
C6  g4463_2 gnd 2.080806f
C7  g4463_6 gnd 2.080806f
C8  g4463_0 gnd 2.080806f
C9  g4463_1 gnd 2.080806f
C10  g4463_7 gnd 2.080806f
C11  g4463_3 gnd 2.080806f
R1 g4463_2 g4463_0 2.224404
C12 1 gnd 2.080806f
R2 1 g4463_2 2.224404
C13 2 gnd 2.080806f
R3 2 1 2.224404
R4 g4463_3 2 2.224404
R5 g4463_5 g4463_3 2.224404
R6 g4463_6 g4463_3 2.224404
R7 2 g4463_10 2.224404
R8 g4463_9 g4463_10 2.224404
C14 3 gnd 2.080806f
R9 g4463_9 3 2.224404
C15 4 gnd 2.080806f
R10 3 4 2.224404
R11 4 g4463_7 2.224404
C16 5 gnd 2.080806f
R12 g4463_0 5 2.224404
C17 6 gnd 2.080806f
R13 5 6 2.224404
C18 7 gnd 2.080806f
R14 6 7 2.224404
R15 g4463_8 7 2.224404
C19 8 gnd 2.080806f
R16 7 8 2.224404
R17 8 g4463_1 2.224404
C20 9 gnd 2.080806f
R18 g4463_7 9 2.224404
C21 10 gnd 2.080806f
R19 9 10 2.224404
C22 11 gnd 2.080806f
R20 10 11 2.224404
C23 12 gnd 2.080806f
R21 11 12 2.224404
C24 13 gnd 2.080806f
R22 12 13 2.224404
C25 14 gnd 2.080806f
R23 13 14 2.224404
R24 14 g4463_4 2.224404
.ends

.subckt netg5799 g5799_1 g5799_2 g5799_0 gnd
C1  g5799_1 gnd 2.080806f
C2  g5799_2 gnd 2.080806f
C3  g5799_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5799_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g5799_1 2.224404
C7 4 gnd 2.080806f
R5 g5799_1 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
R18 16 g5799_2 2.224404
.ends

.subckt netg3517 g3517_1 g3517_0 gnd
C1  g3517_1 gnd 2.080806f
C2  g3517_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3517_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
R20 g3517_1 19 2.224404
.ends

.subckt netg4721 g4721_5 g4721_2 g4721_8 g4721_4 g4721_0 g4721_3 g4721_9 g4721_6 g4721_1 g4721_7 g4721_10 gnd
C1  g4721_5 gnd 2.080806f
C2  g4721_2 gnd 2.080806f
C3  g4721_8 gnd 2.080806f
C4  g4721_4 gnd 2.080806f
C5  g4721_0 gnd 2.080806f
C6  g4721_3 gnd 2.080806f
C7  g4721_9 gnd 2.080806f
C8  g4721_6 gnd 2.080806f
C9  g4721_1 gnd 2.080806f
C10  g4721_7 gnd 2.080806f
C11  g4721_10 gnd 2.080806f
C12 1 gnd 2.080806f
R1 1 g4721_0 2.224404
C13 2 gnd 2.080806f
R2 2 1 2.224404
C14 3 gnd 2.080806f
R3 3 2 2.224404
C15 4 gnd 2.080806f
R4 4 3 2.224404
C16 5 gnd 2.080806f
R5 5 4 2.224404
R6 g4721_4 5 2.224404
C17 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g4721_5 2.224404
C18 7 gnd 2.080806f
R9 g4721_5 7 2.224404
R10 7 g4721_7 2.224404
C19 8 gnd 2.080806f
R11 8 g4721_7 2.224404
R12 g4721_2 8 2.224404
C20 9 gnd 2.080806f
R13 9 g4721_2 2.224404
R14 g4721_6 9 2.224404
C21 10 gnd 2.080806f
R15 10 g4721_6 2.224404
R16 g4721_3 10 2.224404
C22 11 gnd 2.080806f
R17 11 g4721_3 2.224404
R18 g4721_8 11 2.224404
R19 g4721_1 g4721_8 2.224404
C23 12 gnd 2.080806f
R20 12 g4721_4 2.224404
C24 13 gnd 2.080806f
R21 13 12 2.224404
R22 g4721_9 13 2.224404
C25 14 gnd 2.080806f
R23 14 g4721_9 2.224404
C26 15 gnd 2.080806f
R24 15 14 2.224404
R25 g4721_10 15 2.224404
.ends

.subckt netg79 g79_1 g79_0 gnd
C1  g79_1 gnd 2.080806f
C2  g79_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g79_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
R18 17 g79_1 2.224404
.ends

.subckt netg2055 g2055_2 g2055_4 g2055_3 g2055_6 g2055_5 g2055_0 gnd
C1  g2055_2 gnd 2.080806f
C2  g2055_4 gnd 2.080806f
C3  g2055_3 gnd 2.080806f
C4  g2055_6 gnd 2.080806f
C5  g2055_5 gnd 2.080806f
C6  g2055_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g2055_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2055_4 2.224404
C10 4 gnd 2.080806f
R5 4 g2055_4 2.224404
R6 4 g2055_6 2.224404
C11 5 gnd 2.080806f
R7 g2055_6 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g2055_2 2.224404
C14 8 gnd 2.080806f
R11 g2055_4 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 11 10 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
R16 g2055_5 12 2.224404
C19 13 gnd 2.080806f
R17 13 g2055_2 2.224404
C20 14 gnd 2.080806f
R18 14 13 2.224404
C21 15 gnd 2.080806f
R19 15 14 2.224404
C22 16 gnd 2.080806f
R20 15 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
R22 17 g2055_3 2.224404
.ends

.subckt netg7499 g7499_1 g7499_0 gnd
C1  g7499_1 gnd 2.080806f
C2  g7499_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7499_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
R18 17 g7499_1 2.224404
.ends

.subckt netg1395 g1395_1 g1395_0 gnd
C1  g1395_1 gnd 2.080806f
C2  g1395_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1395_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
R20 g1395_1 19 2.224404
.ends

.subckt netg1836 g1836_0 g1836_2 g1836_1 g1836_3 gnd
C1  g1836_0 gnd 2.080806f
C2  g1836_2 gnd 2.080806f
C3  g1836_1 gnd 2.080806f
C4  g1836_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1836_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1836_3 2.224404
C7 3 gnd 2.080806f
R4 3 g1836_0 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
R16 g1836_2 14 2.224404
C19 15 gnd 2.080806f
R17 g1836_2 15 2.224404
R18 g1836_1 15 2.224404
.ends

.subckt netg614 g614_3 g614_0 g614_4 g614_1 g614_5 g614_2 gnd
C1  g614_3 gnd 2.080806f
C2  g614_0 gnd 2.080806f
C3  g614_4 gnd 2.080806f
C4  g614_1 gnd 2.080806f
C5  g614_5 gnd 2.080806f
C6  g614_2 gnd 2.080806f
R1 g614_0 g614_4 2.224404
R2 g614_2 g614_4 2.224404
R3 g614_4 g614_3 2.224404
C7 1 gnd 2.080806f
R4 g614_3 1 2.224404
C8 2 gnd 2.080806f
R5 1 2 2.224404
C9 3 gnd 2.080806f
R6 2 3 2.224404
C10 4 gnd 2.080806f
R7 3 4 2.224404
C11 5 gnd 2.080806f
R8 4 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
R15 11 g614_5 2.224404
C18 12 gnd 2.080806f
R16 12 g614_5 2.224404
C19 13 gnd 2.080806f
R17 13 12 2.224404
C20 14 gnd 2.080806f
R18 14 13 2.224404
C21 15 gnd 2.080806f
R19 15 14 2.224404
R20 g614_1 15 2.224404
.ends

.subckt netg1786 g1786_5 g1786_2 g1786_4 g1786_3 g1786_0 g1786_1 gnd
C1  g1786_5 gnd 2.080806f
C2  g1786_2 gnd 2.080806f
C3  g1786_4 gnd 2.080806f
C4  g1786_3 gnd 2.080806f
C5  g1786_0 gnd 2.080806f
C6  g1786_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1786_0 2.224404
R2 g1786_4 1 2.224404
R3 g1786_2 g1786_4 2.224404
C8 2 gnd 2.080806f
R4 g1786_0 2 2.224404
C9 3 gnd 2.080806f
R5 2 3 2.224404
C10 4 gnd 2.080806f
R6 3 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
R10 7 g1786_3 2.224404
C14 8 gnd 2.080806f
R11 g1786_4 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
R18 14 g1786_1 2.224404
C21 15 gnd 2.080806f
R19 15 g1786_1 2.224404
C22 16 gnd 2.080806f
R20 16 15 2.224404
R21 g1786_5 16 2.224404
.ends

.subckt netg5847 g5847_1 g5847_0 gnd
C1  g5847_1 gnd 2.080806f
C2  g5847_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5847_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
R19 g5847_1 18 2.224404
.ends

.subckt netg5170 g5170_1 g5170_3 g5170_0 g5170_2 gnd
C1  g5170_1 gnd 2.080806f
C2  g5170_3 gnd 2.080806f
C3  g5170_0 gnd 2.080806f
C4  g5170_2 gnd 2.080806f
R1 g5170_1 g5170_0 2.224404
C5 1 gnd 2.080806f
R2 1 g5170_1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
R7 g5170_3 5 2.224404
C10 6 gnd 2.080806f
R8 g5170_0 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
R22 19 g5170_2 2.224404
.ends

.subckt netg6071 g6071_1 g6071_0 gnd
C1  g6071_1 gnd 2.080806f
C2  g6071_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6071_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
R19 g6071_1 18 2.224404
.ends

.subckt netg5287 g5287_1 g5287_6 g5287_5 g5287_0 g5287_4 g5287_3 g5287_2 gnd
C1  g5287_1 gnd 2.080806f
C2  g5287_6 gnd 2.080806f
C3  g5287_5 gnd 2.080806f
C4  g5287_0 gnd 2.080806f
C5  g5287_4 gnd 2.080806f
C6  g5287_3 gnd 2.080806f
C7  g5287_2 gnd 2.080806f
R1 g5287_0 g5287_1 2.224404
R2 g5287_2 g5287_0 2.224404
R3 g5287_1 g5287_4 2.224404
R4 g5287_2 g5287_5 2.224404
R5 g5287_6 g5287_4 2.224404
C8 1 gnd 2.080806f
R6 1 g5287_6 2.224404
C9 2 gnd 2.080806f
R7 2 1 2.224404
C10 3 gnd 2.080806f
R8 3 2 2.224404
C11 4 gnd 2.080806f
R9 4 3 2.224404
C12 5 gnd 2.080806f
R10 5 4 2.224404
C13 6 gnd 2.080806f
R11 6 5 2.224404
C14 7 gnd 2.080806f
R12 7 6 2.224404
C15 8 gnd 2.080806f
R13 8 7 2.224404
C16 9 gnd 2.080806f
R14 9 8 2.224404
C17 10 gnd 2.080806f
R15 10 9 2.224404
C18 11 gnd 2.080806f
R16 11 10 2.224404
C19 12 gnd 2.080806f
R17 12 11 2.224404
C20 13 gnd 2.080806f
R18 13 12 2.224404
C21 14 gnd 2.080806f
R19 14 13 2.224404
C22 15 gnd 2.080806f
R20 14 15 2.224404
R21 15 g5287_3 2.224404
.ends

.subckt netg3516 g3516_1 g3516_0 gnd
C1  g3516_1 gnd 2.080806f
C2  g3516_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3516_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
R21 g3516_1 20 2.224404
.ends

.subckt netg6583 g6583_1 g6583_0 gnd
C1  g6583_1 gnd 2.080806f
C2  g6583_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6583_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
R19 g6583_1 18 2.224404
.ends

.subckt netg1727 g1727_1 g1727_2 g1727_0 g1727_3 gnd
C1  g1727_1 gnd 2.080806f
C2  g1727_2 gnd 2.080806f
C3  g1727_0 gnd 2.080806f
C4  g1727_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1727_0 2.224404
R2 1 g1727_1 2.224404
C6 2 gnd 2.080806f
R3 g1727_1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
R13 11 g1727_3 2.224404
C16 12 gnd 2.080806f
R14 g1727_3 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
R20 17 g1727_2 2.224404
.ends

.subckt netg1596 g1596_1 g1596_2 g1596_0 g1596_3 gnd
C1  g1596_1 gnd 2.080806f
C2  g1596_2 gnd 2.080806f
C3  g1596_0 gnd 2.080806f
C4  g1596_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1596_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g1596_1 2.224404
C8 4 gnd 2.080806f
R5 g1596_1 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
R15 13 g1596_2 2.224404
C18 14 gnd 2.080806f
R16 g1596_2 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
R22 g1596_3 19 2.224404
.ends

.subckt netg124 g124_1 g124_0 gnd
C1  g124_1 gnd 2.080806f
C2  g124_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g124_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
R19 18 g124_1 2.224404
.ends

.subckt netg3768 g3768_1 g3768_8 g3768_3 g3768_0 g3768_13 g3768_2 g3768_10 g3768_12 g3768_11 g3768_6 g3768_7 g3768_9 g3768_5 g3768_4 g3768_15 g3768_14 gnd
C1  g3768_1 gnd 2.080806f
C2  g3768_8 gnd 2.080806f
C3  g3768_3 gnd 2.080806f
C4  g3768_0 gnd 2.080806f
C5  g3768_13 gnd 2.080806f
C6  g3768_2 gnd 2.080806f
C7  g3768_10 gnd 2.080806f
C8  g3768_12 gnd 2.080806f
C9  g3768_11 gnd 2.080806f
C10  g3768_6 gnd 2.080806f
C11  g3768_7 gnd 2.080806f
C12  g3768_9 gnd 2.080806f
C13  g3768_5 gnd 2.080806f
C14  g3768_4 gnd 2.080806f
C15  g3768_15 gnd 2.080806f
C16  g3768_14 gnd 2.080806f
C17 1 gnd 2.080806f
R1 g3768_0 1 2.224404
R2 g3768_12 1 2.224404
C18 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g3768_4 2.224404
R5 g3768_4 g3768_14 2.224404
C19 3 gnd 2.080806f
R6 3 g3768_0 2.224404
C20 4 gnd 2.080806f
R7 3 4 2.224404
R8 4 g3768_6 2.224404
R9 g3768_6 g3768_13 2.224404
R10 g3768_13 g3768_15 2.224404
C21 5 gnd 2.080806f
R11 g3768_13 5 2.224404
R12 5 g3768_1 2.224404
R13 g3768_7 g3768_1 2.224404
R14 g3768_1 g3768_8 2.224404
R15 g3768_8 g3768_2 2.224404
C22 6 gnd 2.080806f
R16 6 g3768_6 2.224404
C23 7 gnd 2.080806f
R17 7 6 2.224404
R18 g3768_5 7 2.224404
C24 8 gnd 2.080806f
R19 8 7 2.224404
C25 9 gnd 2.080806f
R20 9 8 2.224404
C26 10 gnd 2.080806f
R21 10 9 2.224404
R22 g3768_9 10 2.224404
C27 11 gnd 2.080806f
R23 11 g3768_4 2.224404
C28 12 gnd 2.080806f
R24 12 11 2.224404
C29 13 gnd 2.080806f
R25 13 12 2.224404
C30 14 gnd 2.080806f
R26 14 13 2.224404
C31 15 gnd 2.080806f
R27 15 14 2.224404
R28 g3768_10 15 2.224404
C32 16 gnd 2.080806f
R29 16 g3768_10 2.224404
C33 17 gnd 2.080806f
R30 17 16 2.224404
R31 g3768_3 17 2.224404
C34 18 gnd 2.080806f
R32 18 g3768_3 2.224404
R33 g3768_11 18 2.224404
.ends

.subckt netg1687 g1687_1 g1687_0 g1687_2 g1687_3 gnd
C1  g1687_1 gnd 2.080806f
C2  g1687_0 gnd 2.080806f
C3  g1687_2 gnd 2.080806f
C4  g1687_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1687_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g1687_3 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
R6 g1687_2 4 2.224404
C9 5 gnd 2.080806f
R7 g1687_0 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
R20 17 g1687_1 2.224404
.ends

.subckt netg3873 g3873_8 g3873_3 g3873_9 g3873_0 g3873_6 g3873_1 g3873_7 g3873_5 g3873_2 g3873_4 gnd
C1  g3873_8 gnd 2.080806f
C2  g3873_3 gnd 2.080806f
C3  g3873_9 gnd 2.080806f
C4  g3873_0 gnd 2.080806f
C5  g3873_6 gnd 2.080806f
C6  g3873_1 gnd 2.080806f
C7  g3873_7 gnd 2.080806f
C8  g3873_5 gnd 2.080806f
C9  g3873_2 gnd 2.080806f
C10  g3873_4 gnd 2.080806f
R1 g3873_2 g3873_0 2.224404
R2 g3873_6 g3873_2 2.224404
C11 1 gnd 2.080806f
R3 1 g3873_6 2.224404
R4 g3873_9 1 2.224404
R5 g3873_7 g3873_9 2.224404
R6 g3873_5 g3873_7 2.224404
C12 2 gnd 2.080806f
R7 g3873_5 2 2.224404
C13 3 gnd 2.080806f
R8 2 3 2.224404
R9 g3873_4 3 2.224404
C14 4 gnd 2.080806f
R10 g3873_0 4 2.224404
C15 5 gnd 2.080806f
R11 4 5 2.224404
C16 6 gnd 2.080806f
R12 5 6 2.224404
C17 7 gnd 2.080806f
R13 6 7 2.224404
C18 8 gnd 2.080806f
R14 7 8 2.224404
R15 8 g3873_8 2.224404
C19 9 gnd 2.080806f
R16 g3873_0 9 2.224404
C20 10 gnd 2.080806f
R17 9 10 2.224404
C21 11 gnd 2.080806f
R18 10 11 2.224404
C22 12 gnd 2.080806f
R19 11 12 2.224404
C23 13 gnd 2.080806f
R20 12 13 2.224404
R21 13 g3873_1 2.224404
C24 14 gnd 2.080806f
R22 14 g3873_1 2.224404
C25 15 gnd 2.080806f
R23 14 15 2.224404
R24 15 g3873_3 2.224404
.ends

.subckt netg4791 g4791_2 g4791_3 g4791_7 g4791_9 g4791_5 g4791_10 g4791_8 g4791_0 g4791_1 g4791_4 g4791_6 gnd
C1  g4791_2 gnd 2.080806f
C2  g4791_3 gnd 2.080806f
C3  g4791_7 gnd 2.080806f
C4  g4791_9 gnd 2.080806f
C5  g4791_5 gnd 2.080806f
C6  g4791_10 gnd 2.080806f
C7  g4791_8 gnd 2.080806f
C8  g4791_0 gnd 2.080806f
C9  g4791_1 gnd 2.080806f
C10  g4791_4 gnd 2.080806f
C11  g4791_6 gnd 2.080806f
C12 1 gnd 2.080806f
R1 g4791_0 1 2.224404
R2 1 g4791_2 2.224404
C13 2 gnd 2.080806f
R3 2 g4791_0 2.224404
R4 g4791_10 2 2.224404
C14 3 gnd 2.080806f
R5 g4791_2 3 2.224404
R6 3 g4791_3 2.224404
R7 g4791_3 g4791_1 2.224404
R8 g4791_1 g4791_6 2.224404
R9 g4791_6 g4791_9 2.224404
C15 4 gnd 2.080806f
R10 g4791_10 4 2.224404
R11 4 g4791_8 2.224404
C16 5 gnd 2.080806f
R12 g4791_9 5 2.224404
R13 5 g4791_5 2.224404
C17 6 gnd 2.080806f
R14 6 g4791_2 2.224404
C18 7 gnd 2.080806f
R15 7 6 2.224404
C19 8 gnd 2.080806f
R16 8 7 2.224404
C20 9 gnd 2.080806f
R17 9 8 2.224404
R18 9 g4791_4 2.224404
C21 10 gnd 2.080806f
R19 10 g4791_4 2.224404
C22 11 gnd 2.080806f
R20 10 11 2.224404
C23 12 gnd 2.080806f
R21 11 12 2.224404
C24 13 gnd 2.080806f
R22 13 12 2.224404
C25 14 gnd 2.080806f
R23 13 14 2.224404
C26 15 gnd 2.080806f
R24 14 15 2.224404
R25 15 g4791_7 2.224404
.ends

.subckt netg2123 g2123_1 g2123_3 g2123_2 g2123_0 gnd
C1  g2123_1 gnd 2.080806f
C2  g2123_3 gnd 2.080806f
C3  g2123_2 gnd 2.080806f
C4  g2123_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2123_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2123_3 2 2.224404
C7 3 gnd 2.080806f
R4 3 1 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 15 14 2.224404
C20 16 gnd 2.080806f
R17 16 15 2.224404
R18 g2123_2 16 2.224404
C21 17 gnd 2.080806f
R19 17 g2123_2 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
R21 g2123_1 18 2.224404
.ends

.subckt netg4850 g4850_9 g4850_1 g4850_4 g4850_8 g4850_6 g4850_3 g4850_10 g4850_2 g4850_12 g4850_7 g4850_11 g4850_5 gnd
C1  g4850_9 gnd 2.080806f
C2  g4850_1 gnd 2.080806f
C3  g4850_4 gnd 2.080806f
C4  g4850_8 gnd 2.080806f
C5  g4850_6 gnd 2.080806f
C6  g4850_3 gnd 2.080806f
C7  g4850_10 gnd 2.080806f
C8  g4850_2 gnd 2.080806f
C9  g4850_12 gnd 2.080806f
C10  g4850_7 gnd 2.080806f
C11  g4850_11 gnd 2.080806f
C12  g4850_5 gnd 2.080806f
R1 g4850_11 g4850_7 2.224404
R2 g4850_7 g4850_2 2.224404
C13 1 gnd 2.080806f
R3 g4850_7 1 2.224404
R4 1 g4850_12 2.224404
C14 2 gnd 2.080806f
R5 g4850_2 2 2.224404
C15 3 gnd 2.080806f
R6 2 3 2.224404
C16 4 gnd 2.080806f
R7 3 4 2.224404
C17 5 gnd 2.080806f
R8 4 5 2.224404
C18 6 gnd 2.080806f
R9 5 6 2.224404
R10 6 g4850_5 2.224404
C19 7 gnd 2.080806f
R11 7 g4850_5 2.224404
C20 8 gnd 2.080806f
R12 8 7 2.224404
R13 8 g4850_9 2.224404
C21 9 gnd 2.080806f
R14 9 g4850_9 2.224404
C22 10 gnd 2.080806f
R15 10 9 2.224404
R16 g4850_8 10 2.224404
R17 g4850_8 g4850_1 2.224404
C23 11 gnd 2.080806f
R18 11 g4850_8 2.224404
R19 g4850_3 11 2.224404
R20 g4850_4 g4850_3 2.224404
C24 12 gnd 2.080806f
R21 12 g4850_8 2.224404
C25 13 gnd 2.080806f
R22 13 12 2.224404
R23 g4850_6 13 2.224404
C26 14 gnd 2.080806f
R24 14 g4850_4 2.224404
C27 15 gnd 2.080806f
R25 15 14 2.224404
R26 g4850_10 15 2.224404
.ends

.subckt netg3617 g3617_12 g3617_3 g3617_9 g3617_7 g3617_5 g3617_2 g3617_8 g3617_1 g3617_4 g3617_10 g3617_0 g3617_6 g3617_11 gnd
C1  g3617_12 gnd 2.080806f
C2  g3617_3 gnd 2.080806f
C3  g3617_9 gnd 2.080806f
C4  g3617_7 gnd 2.080806f
C5  g3617_5 gnd 2.080806f
C6  g3617_2 gnd 2.080806f
C7  g3617_8 gnd 2.080806f
C8  g3617_1 gnd 2.080806f
C9  g3617_4 gnd 2.080806f
C10  g3617_10 gnd 2.080806f
C11  g3617_0 gnd 2.080806f
C12  g3617_6 gnd 2.080806f
C13  g3617_11 gnd 2.080806f
C14 1 gnd 2.080806f
R1 1 g3617_0 2.224404
R2 g3617_6 1 2.224404
C15 2 gnd 2.080806f
R3 g3617_0 2 2.224404
R4 2 g3617_12 2.224404
C16 3 gnd 2.080806f
R5 g3617_12 3 2.224404
R6 3 g3617_5 2.224404
C17 4 gnd 2.080806f
R7 4 1 2.224404
C18 5 gnd 2.080806f
R8 5 4 2.224404
R9 g3617_3 5 2.224404
C19 6 gnd 2.080806f
R10 g3617_3 6 2.224404
R11 6 g3617_10 2.224404
R12 g3617_1 g3617_10 2.224404
R13 g3617_10 g3617_4 2.224404
C20 7 gnd 2.080806f
R14 7 g3617_3 2.224404
C21 8 gnd 2.080806f
R15 8 7 2.224404
C22 9 gnd 2.080806f
R16 9 8 2.224404
C23 10 gnd 2.080806f
R17 10 9 2.224404
R18 g3617_9 10 2.224404
C24 11 gnd 2.080806f
R19 g3617_9 11 2.224404
C25 12 gnd 2.080806f
R20 12 11 2.224404
C26 13 gnd 2.080806f
R21 12 13 2.224404
R22 g3617_8 13 2.224404
C27 14 gnd 2.080806f
R23 g3617_8 14 2.224404
C28 15 gnd 2.080806f
R24 14 15 2.224404
C29 16 gnd 2.080806f
R25 15 16 2.224404
C30 17 gnd 2.080806f
R26 16 17 2.224404
R27 17 g3617_11 2.224404
C31 18 gnd 2.080806f
R28 18 g3617_11 2.224404
C32 19 gnd 2.080806f
R29 19 18 2.224404
R30 g3617_2 19 2.224404
R31 g3617_7 19 2.224404
.ends

.subckt netg2326 g2326_1 g2326_0 g2326_3 g2326_2 gnd
C1  g2326_1 gnd 2.080806f
C2  g2326_0 gnd 2.080806f
C3  g2326_3 gnd 2.080806f
C4  g2326_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2326_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g2326_1 2.224404
C10 6 gnd 2.080806f
R7 g2326_1 6 2.224404
R8 6 g2326_2 2.224404
C11 7 gnd 2.080806f
R9 7 1 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
R20 g2326_3 17 2.224404
.ends

.subckt netg2330 g2330_3 g2330_1 g2330_0 gnd
C1  g2330_3 gnd 2.080806f
C2  g2330_1 gnd 2.080806f
C3  g2330_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2330_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g2330_3 2 2.224404
C6 3 gnd 2.080806f
R4 3 g2330_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
R20 g2330_1 18 2.224404
.ends

.subckt netg1098 g1098_1 g1098_0 gnd
C1  g1098_1 gnd 2.080806f
C2  g1098_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1098_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
R23 g1098_1 22 2.224404
.ends

.subckt netg7257 g7257_0 g7257_1 g7257_2 gnd
C1  g7257_0 gnd 2.080806f
C2  g7257_1 gnd 2.080806f
C3  g7257_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7257_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7257_1 2 2.224404
C6 3 gnd 2.080806f
R4 3 g7257_1 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
R19 g7257_2 17 2.224404
.ends

.subckt netg134 g134_1 g134_0 gnd
C1  g134_1 gnd 2.080806f
C2  g134_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g134_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
R19 18 g134_1 2.224404
.ends

.subckt netg128 g128_1 g128_0 gnd
C1  g128_1 gnd 2.080806f
C2  g128_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g128_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
R20 19 g128_1 2.224404
.ends

.subckt netg1474 g1474_1 g1474_0 gnd
C1  g1474_1 gnd 2.080806f
C2  g1474_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1474_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
R20 g1474_1 19 2.224404
.ends

.subckt netg4869 g4869_1 g4869_6 g4869_5 g4869_2 g4869_0 g4869_4 g4869_3 gnd
C1  g4869_1 gnd 2.080806f
C2  g4869_6 gnd 2.080806f
C3  g4869_5 gnd 2.080806f
C4  g4869_2 gnd 2.080806f
C5  g4869_0 gnd 2.080806f
C6  g4869_4 gnd 2.080806f
C7  g4869_3 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g4869_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
C10 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g4869_6 2.224404
C11 4 gnd 2.080806f
R5 1 4 2.224404
C12 5 gnd 2.080806f
R6 4 5 2.224404
C13 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g4869_1 2.224404
C14 7 gnd 2.080806f
R9 g4869_1 7 2.224404
C15 8 gnd 2.080806f
R10 7 8 2.224404
C16 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g4869_4 2.224404
C17 10 gnd 2.080806f
R13 10 g4869_1 2.224404
C18 11 gnd 2.080806f
R14 11 10 2.224404
C19 12 gnd 2.080806f
R15 11 12 2.224404
C20 13 gnd 2.080806f
R16 12 13 2.224404
C21 14 gnd 2.080806f
R17 14 13 2.224404
C22 15 gnd 2.080806f
R18 14 15 2.224404
R19 g4869_2 15 2.224404
C23 16 gnd 2.080806f
R20 16 g4869_2 2.224404
R21 g4869_3 16 2.224404
C24 17 gnd 2.080806f
R22 g4869_2 17 2.224404
C25 18 gnd 2.080806f
R23 17 18 2.224404
C26 19 gnd 2.080806f
R24 18 19 2.224404
C27 20 gnd 2.080806f
R25 19 20 2.224404
R26 20 g4869_5 2.224404
.ends

.subckt netg7521 g7521_1 g7521_0 gnd
C1  g7521_1 gnd 2.080806f
C2  g7521_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7521_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
R20 g7521_1 19 2.224404
.ends

.subckt netg727 g727_4 g727_5 g727_6 g727_1 g727_3 gnd
C1  g727_4 gnd 2.080806f
C2  g727_5 gnd 2.080806f
C3  g727_6 gnd 2.080806f
C4  g727_1 gnd 2.080806f
C5  g727_3 gnd 2.080806f
R1 g727_1 g727_4 2.224404
R2 g727_3 g727_4 2.224404
C6 1 gnd 2.080806f
R3 1 g727_1 2.224404
R4 g727_5 1 2.224404
C7 2 gnd 2.080806f
R5 2 g727_5 2.224404
C8 3 gnd 2.080806f
R6 3 2 2.224404
C9 4 gnd 2.080806f
R7 4 3 2.224404
C10 5 gnd 2.080806f
R8 5 4 2.224404
C11 6 gnd 2.080806f
R9 6 5 2.224404
C12 7 gnd 2.080806f
R10 7 6 2.224404
C13 8 gnd 2.080806f
R11 8 7 2.224404
C14 9 gnd 2.080806f
R12 9 8 2.224404
C15 10 gnd 2.080806f
R13 10 9 2.224404
C16 11 gnd 2.080806f
R14 11 10 2.224404
C17 12 gnd 2.080806f
R15 12 11 2.224404
C18 13 gnd 2.080806f
R16 13 12 2.224404
C19 14 gnd 2.080806f
R17 14 13 2.224404
C20 15 gnd 2.080806f
R18 15 14 2.224404
C21 16 gnd 2.080806f
R19 16 15 2.224404
C22 17 gnd 2.080806f
R20 17 16 2.224404
R21 g727_6 17 2.224404
.ends

.subckt netg2531 g2531_2 g2531_0 gnd
C1  g2531_2 gnd 2.080806f
C2  g2531_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2531_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
R22 g2531_2 21 2.224404
.ends

.subckt netg2342 g2342_3 g2342_1 g2342_0 gnd
C1  g2342_3 gnd 2.080806f
C2  g2342_1 gnd 2.080806f
C3  g2342_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2342_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
R12 11 g2342_1 2.224404
C15 12 gnd 2.080806f
R13 g2342_1 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
R20 18 g2342_3 2.224404
.ends

.subckt netg7501 g7501_1 g7501_0 gnd
C1  g7501_1 gnd 2.080806f
C2  g7501_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7501_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
R20 g7501_1 19 2.224404
.ends

.subckt netg7445 g7445_1 g7445_0 gnd
C1  g7445_1 gnd 2.080806f
C2  g7445_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7445_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
R20 g7445_1 19 2.224404
.ends

.subckt netg3803 g3803_3 g3803_0 g3803_6 g3803_4 g3803_2 g3803_1 gnd
C1  g3803_3 gnd 2.080806f
C2  g3803_0 gnd 2.080806f
C3  g3803_6 gnd 2.080806f
C4  g3803_4 gnd 2.080806f
C5  g3803_2 gnd 2.080806f
C6  g3803_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g3803_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
C10 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g3803_6 2.224404
C11 5 gnd 2.080806f
R6 g3803_0 5 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
C16 10 gnd 2.080806f
R11 9 10 2.224404
R12 g3803_1 10 2.224404
C17 11 gnd 2.080806f
R13 11 g3803_1 2.224404
R14 g3803_2 11 2.224404
C18 12 gnd 2.080806f
R15 12 g3803_2 2.224404
C19 13 gnd 2.080806f
R16 13 12 2.224404
C20 14 gnd 2.080806f
R17 14 13 2.224404
C21 15 gnd 2.080806f
R18 15 14 2.224404
C22 16 gnd 2.080806f
R19 16 15 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
R21 g3803_3 17 2.224404
C24 18 gnd 2.080806f
R22 18 g3803_3 2.224404
R23 g3803_4 18 2.224404
.ends

.subckt netg6371 g6371_1 g6371_0 gnd
C1  g6371_1 gnd 2.080806f
C2  g6371_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6371_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
R20 g6371_1 19 2.224404
.ends

.subckt netg7500 g7500_1 g7500_0 gnd
C1  g7500_1 gnd 2.080806f
C2  g7500_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7500_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
R20 19 g7500_1 2.224404
.ends

.subckt netg69 g69_0 g69_2 g69_1 gnd
C1  g69_0 gnd 2.080806f
C2  g69_2 gnd 2.080806f
C3  g69_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g69_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
R13 g69_2 12 2.224404
C16 13 gnd 2.080806f
R14 13 2 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
R23 g69_1 21 2.224404
.ends

.subckt netg4834 g4834_8 g4834_12 g4834_5 g4834_15 g4834_9 g4834_1 g4834_3 g4834_13 g4834_4 g4834_14 g4834_0 g4834_11 g4834_10 g4834_6 g4834_2 gnd
C1  g4834_8 gnd 2.080806f
C2  g4834_12 gnd 2.080806f
C3  g4834_5 gnd 2.080806f
C4  g4834_15 gnd 2.080806f
C5  g4834_9 gnd 2.080806f
C6  g4834_1 gnd 2.080806f
C7  g4834_3 gnd 2.080806f
C8  g4834_13 gnd 2.080806f
C9  g4834_4 gnd 2.080806f
C10  g4834_14 gnd 2.080806f
C11  g4834_0 gnd 2.080806f
C12  g4834_11 gnd 2.080806f
C13  g4834_10 gnd 2.080806f
C14  g4834_6 gnd 2.080806f
C15  g4834_2 gnd 2.080806f
R1 g4834_0 g4834_4 2.224404
R2 g4834_4 g4834_1 2.224404
R3 g4834_1 g4834_14 2.224404
C16 1 gnd 2.080806f
R4 g4834_14 1 2.224404
C17 2 gnd 2.080806f
R5 1 2 2.224404
C18 3 gnd 2.080806f
R6 2 3 2.224404
R7 3 g4834_2 2.224404
C19 4 gnd 2.080806f
R8 4 g4834_2 2.224404
C20 5 gnd 2.080806f
R9 4 5 2.224404
R10 5 g4834_11 2.224404
C21 6 gnd 2.080806f
R11 g4834_11 6 2.224404
R12 6 g4834_13 2.224404
C22 7 gnd 2.080806f
R13 g4834_13 7 2.224404
R14 7 g4834_15 2.224404
C23 8 gnd 2.080806f
R15 8 4 2.224404
C24 9 gnd 2.080806f
R16 9 8 2.224404
C25 10 gnd 2.080806f
R17 10 9 2.224404
C26 11 gnd 2.080806f
R18 11 10 2.224404
R19 g4834_12 11 2.224404
R20 g4834_12 g4834_6 2.224404
R21 g4834_8 g4834_12 2.224404
C27 12 gnd 2.080806f
R22 g4834_6 12 2.224404
R23 12 g4834_5 2.224404
R24 g4834_10 12 2.224404
C28 13 gnd 2.080806f
R25 13 g4834_5 2.224404
R26 g4834_9 13 2.224404
C29 14 gnd 2.080806f
R27 14 g4834_9 2.224404
R28 14 g4834_3 2.224404
.ends

.subckt netg428 g428_4 g428_8 g428_1 g428_5 g428_9 g428_6 g428_7 g428_2 g428_10 g428_3 gnd
C1  g428_4 gnd 2.080806f
C2  g428_8 gnd 2.080806f
C3  g428_1 gnd 2.080806f
C4  g428_5 gnd 2.080806f
C5  g428_9 gnd 2.080806f
C6  g428_6 gnd 2.080806f
C7  g428_7 gnd 2.080806f
C8  g428_2 gnd 2.080806f
C9  g428_10 gnd 2.080806f
C10  g428_3 gnd 2.080806f
C11 1 gnd 2.080806f
R1 g428_9 1 2.224404
C12 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g428_8 2.224404
C13 3 gnd 2.080806f
R4 g428_8 3 2.224404
C14 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g428_10 2.224404
R7 g428_2 g428_10 2.224404
C15 5 gnd 2.080806f
R8 5 g428_8 2.224404
C16 6 gnd 2.080806f
R9 5 6 2.224404
C17 7 gnd 2.080806f
R10 7 6 2.224404
C18 8 gnd 2.080806f
R11 7 8 2.224404
C19 9 gnd 2.080806f
R12 8 9 2.224404
R13 9 g428_3 2.224404
C20 10 gnd 2.080806f
R14 g428_3 10 2.224404
C21 11 gnd 2.080806f
R15 10 11 2.224404
R16 11 g428_1 2.224404
C22 12 gnd 2.080806f
R17 12 g428_9 2.224404
C23 13 gnd 2.080806f
R18 13 12 2.224404
C24 14 gnd 2.080806f
R19 14 13 2.224404
C25 15 gnd 2.080806f
R20 15 14 2.224404
C26 16 gnd 2.080806f
R21 16 15 2.224404
C27 17 gnd 2.080806f
R22 17 16 2.224404
R23 g428_5 17 2.224404
R24 g428_5 g428_4 2.224404
R25 g428_7 g428_4 2.224404
C28 18 gnd 2.080806f
R26 g428_7 18 2.224404
C29 19 gnd 2.080806f
R27 18 19 2.224404
R28 19 g428_6 2.224404
.ends

.subckt netg7532 g7532_0 g7532_1 gnd
C1  g7532_0 gnd 2.080806f
C2  g7532_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7532_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
R20 g7532_1 19 2.224404
.ends

.subckt netg4820 g4820_4 g4820_1 g4820_10 g4820_7 g4820_6 g4820_0 g4820_11 g4820_13 g4820_12 g4820_9 g4820_2 g4820_8 g4820_5 gnd
C1  g4820_4 gnd 2.080806f
C2  g4820_1 gnd 2.080806f
C3  g4820_10 gnd 2.080806f
C4  g4820_7 gnd 2.080806f
C5  g4820_6 gnd 2.080806f
C6  g4820_0 gnd 2.080806f
C7  g4820_11 gnd 2.080806f
C8  g4820_13 gnd 2.080806f
C9  g4820_12 gnd 2.080806f
C10  g4820_9 gnd 2.080806f
C11  g4820_2 gnd 2.080806f
C12  g4820_8 gnd 2.080806f
C13  g4820_5 gnd 2.080806f
C14 1 gnd 2.080806f
R1 g4820_0 1 2.224404
R2 1 g4820_4 2.224404
C15 2 gnd 2.080806f
R3 g4820_0 2 2.224404
R4 2 g4820_7 2.224404
R5 g4820_7 g4820_8 2.224404
C16 3 gnd 2.080806f
R6 3 g4820_0 2.224404
R7 g4820_12 3 2.224404
R8 g4820_6 g4820_12 2.224404
C17 4 gnd 2.080806f
R9 g4820_8 4 2.224404
R10 4 g4820_10 2.224404
C18 5 gnd 2.080806f
R11 g4820_10 5 2.224404
C19 6 gnd 2.080806f
R12 5 6 2.224404
C20 7 gnd 2.080806f
R13 6 7 2.224404
R14 7 g4820_9 2.224404
C21 8 gnd 2.080806f
R15 g4820_9 8 2.224404
R16 8 g4820_11 2.224404
C22 9 gnd 2.080806f
R17 9 8 2.224404
C23 10 gnd 2.080806f
R18 9 10 2.224404
R19 g4820_1 10 2.224404
R20 g4820_5 g4820_1 2.224404
C24 11 gnd 2.080806f
R21 11 g4820_5 2.224404
R22 g4820_2 11 2.224404
C25 12 gnd 2.080806f
R23 12 g4820_2 2.224404
C26 13 gnd 2.080806f
R24 13 12 2.224404
C27 14 gnd 2.080806f
R25 14 13 2.224404
C28 15 gnd 2.080806f
R26 15 14 2.224404
C29 16 gnd 2.080806f
R27 16 15 2.224404
C30 17 gnd 2.080806f
R28 17 16 2.224404
R29 g4820_13 17 2.224404
.ends

.subckt netg5986 g5986_1 g5986_0 g5986_2 gnd
C1  g5986_1 gnd 2.080806f
C2  g5986_0 gnd 2.080806f
C3  g5986_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5986_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g5986_1 2 2.224404
C6 3 gnd 2.080806f
R4 g5986_0 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
R20 18 g5986_2 2.224404
.ends

.subckt netg1900 g1900_0 g1900_1 gnd
C1  g1900_0 gnd 2.080806f
C2  g1900_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1900_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
R24 23 g1900_1 2.224404
.ends

.subckt netg576 g576_1 g576_3 g576_5 g576_2 g576_0 g576_4 gnd
C1  g576_1 gnd 2.080806f
C2  g576_3 gnd 2.080806f
C3  g576_5 gnd 2.080806f
C4  g576_2 gnd 2.080806f
C5  g576_0 gnd 2.080806f
C6  g576_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g576_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g576_3 2.224404
C9 3 gnd 2.080806f
R4 g576_0 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g576_2 2.224404
C14 8 gnd 2.080806f
R10 g576_2 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
C19 13 gnd 2.080806f
R15 12 13 2.224404
R16 13 g576_4 2.224404
C20 14 gnd 2.080806f
R17 14 g576_4 2.224404
C21 15 gnd 2.080806f
R18 15 14 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
R20 g576_1 16 2.224404
C23 17 gnd 2.080806f
R21 g576_4 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
R27 22 g576_5 2.224404
.ends

.subckt netg1664 g1664_0 g1664_3 g1664_2 g1664_5 g1664_4 g1664_1 gnd
C1  g1664_0 gnd 2.080806f
C2  g1664_3 gnd 2.080806f
C3  g1664_2 gnd 2.080806f
C4  g1664_5 gnd 2.080806f
C5  g1664_4 gnd 2.080806f
C6  g1664_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1664_0 2.224404
R2 g1664_1 1 2.224404
C8 2 gnd 2.080806f
R3 g1664_0 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g1664_3 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g1664_4 2.224404
C13 7 gnd 2.080806f
R10 7 g1664_3 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
R14 10 g1664_5 2.224404
C17 11 gnd 2.080806f
R15 g1664_5 11 2.224404
C18 12 gnd 2.080806f
R16 11 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
C21 15 gnd 2.080806f
R19 14 15 2.224404
C22 16 gnd 2.080806f
R20 15 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
R25 20 g1664_2 2.224404
.ends

.subckt netg3030 g3030_5 g3030_4 g3030_1 g3030_3 g3030_0 g3030_6 g3030_2 gnd
C1  g3030_5 gnd 2.080806f
C2  g3030_4 gnd 2.080806f
C3  g3030_1 gnd 2.080806f
C4  g3030_3 gnd 2.080806f
C5  g3030_0 gnd 2.080806f
C6  g3030_6 gnd 2.080806f
C7  g3030_2 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g3030_0 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
C10 3 gnd 2.080806f
R3 3 2 2.224404
C11 4 gnd 2.080806f
R4 3 4 2.224404
C12 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g3030_3 2.224404
C13 6 gnd 2.080806f
R7 g3030_3 6 2.224404
C14 7 gnd 2.080806f
R8 6 7 2.224404
C15 8 gnd 2.080806f
R9 7 8 2.224404
C16 9 gnd 2.080806f
R10 8 9 2.224404
R11 9 g3030_5 2.224404
C17 10 gnd 2.080806f
R12 10 g3030_5 2.224404
C18 11 gnd 2.080806f
R13 10 11 2.224404
C19 12 gnd 2.080806f
R14 12 11 2.224404
C20 13 gnd 2.080806f
R15 12 13 2.224404
C21 14 gnd 2.080806f
R16 13 14 2.224404
R17 14 g3030_4 2.224404
C22 15 gnd 2.080806f
R18 15 g3030_4 2.224404
C23 16 gnd 2.080806f
R19 16 15 2.224404
C24 17 gnd 2.080806f
R20 17 16 2.224404
C25 18 gnd 2.080806f
R21 18 17 2.224404
C26 19 gnd 2.080806f
R22 19 18 2.224404
C27 20 gnd 2.080806f
R23 20 19 2.224404
R24 g3030_1 20 2.224404
R25 g3030_6 g3030_1 2.224404
C28 21 gnd 2.080806f
R26 21 19 2.224404
C29 22 gnd 2.080806f
R27 22 21 2.224404
R28 g3030_2 22 2.224404
.ends

.subckt netx171 x171_0 x171_1 gnd
C1  x171_0 gnd 2.080806f
C2  x171_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 x171_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
R23 22 x171_1 2.224404
.ends

.subckt netg666 g666_4 g666_3 g666_2 g666_5 g666_1 g666_0 gnd
C1  g666_4 gnd 2.080806f
C2  g666_3 gnd 2.080806f
C3  g666_2 gnd 2.080806f
C4  g666_5 gnd 2.080806f
C5  g666_1 gnd 2.080806f
C6  g666_0 gnd 2.080806f
R1 g666_0 g666_1 2.224404
C7 1 gnd 2.080806f
R2 1 g666_1 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g666_5 2.224404
C9 3 gnd 2.080806f
R5 3 g666_0 2.224404
C10 4 gnd 2.080806f
R6 4 3 2.224404
C11 5 gnd 2.080806f
R7 5 4 2.224404
C12 6 gnd 2.080806f
R8 6 5 2.224404
C13 7 gnd 2.080806f
R9 7 6 2.224404
R10 g666_3 7 2.224404
C14 8 gnd 2.080806f
R11 8 g666_3 2.224404
C15 9 gnd 2.080806f
R12 9 8 2.224404
C16 10 gnd 2.080806f
R13 10 9 2.224404
C17 11 gnd 2.080806f
R14 11 10 2.224404
C18 12 gnd 2.080806f
R15 12 11 2.224404
C19 13 gnd 2.080806f
R16 13 12 2.224404
C20 14 gnd 2.080806f
R17 14 13 2.224404
C21 15 gnd 2.080806f
R18 15 14 2.224404
C22 16 gnd 2.080806f
R19 16 15 2.224404
R20 g666_2 16 2.224404
C23 17 gnd 2.080806f
R21 17 g666_2 2.224404
R22 g666_4 17 2.224404
.ends

.subckt netg4560 g4560_6 g4560_5 g4560_4 g4560_3 g4560_0 g4560_7 g4560_2 g4560_1 gnd
C1  g4560_6 gnd 2.080806f
C2  g4560_5 gnd 2.080806f
C3  g4560_4 gnd 2.080806f
C4  g4560_3 gnd 2.080806f
C5  g4560_0 gnd 2.080806f
C6  g4560_7 gnd 2.080806f
C7  g4560_2 gnd 2.080806f
C8  g4560_1 gnd 2.080806f
C9 1 gnd 2.080806f
R1 g4560_0 1 2.224404
R2 1 g4560_4 2.224404
R3 g4560_4 g4560_5 2.224404
R4 g4560_7 g4560_5 2.224404
C10 2 gnd 2.080806f
R5 2 g4560_0 2.224404
C11 3 gnd 2.080806f
R6 3 2 2.224404
C12 4 gnd 2.080806f
R7 4 3 2.224404
R8 g4560_1 4 2.224404
C13 5 gnd 2.080806f
R9 5 g4560_1 2.224404
C14 6 gnd 2.080806f
R10 6 5 2.224404
C15 7 gnd 2.080806f
R11 7 6 2.224404
R12 g4560_2 7 2.224404
C16 8 gnd 2.080806f
R13 8 g4560_2 2.224404
C17 9 gnd 2.080806f
R14 9 8 2.224404
R15 g4560_3 9 2.224404
C18 10 gnd 2.080806f
R16 g4560_5 10 2.224404
C19 11 gnd 2.080806f
R17 10 11 2.224404
C20 12 gnd 2.080806f
R18 11 12 2.224404
C21 13 gnd 2.080806f
R19 12 13 2.224404
C22 14 gnd 2.080806f
R20 13 14 2.224404
C23 15 gnd 2.080806f
R21 14 15 2.224404
R22 15 g4560_6 2.224404
.ends

.subckt netg2334 g2334_3 g2334_1 g2334_2 g2334_0 gnd
C1  g2334_3 gnd 2.080806f
C2  g2334_1 gnd 2.080806f
C3  g2334_2 gnd 2.080806f
C4  g2334_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2334_0 1 2.224404
R2 1 g2334_1 2.224404
C6 2 gnd 2.080806f
R3 2 1 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
R7 g2334_3 5 2.224404
C10 6 gnd 2.080806f
R8 6 g2334_3 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
R22 g2334_2 19 2.224404
.ends

.subckt netg120 g120_1 g120_0 gnd
C1  g120_1 gnd 2.080806f
C2  g120_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g120_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
R21 20 g120_1 2.224404
.ends

.subckt netg2683 g2683_2 g2683_1 g2683_0 gnd
C1  g2683_2 gnd 2.080806f
C2  g2683_1 gnd 2.080806f
C3  g2683_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2683_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
R20 19 g2683_2 2.224404
R21 g2683_2 g2683_1 2.224404
.ends

.subckt netg3862 g3862_8 g3862_0 g3862_7 g3862_6 g3862_9 g3862_2 g3862_10 g3862_3 g3862_1 g3862_5 g3862_4 gnd
C1  g3862_8 gnd 2.080806f
C2  g3862_0 gnd 2.080806f
C3  g3862_7 gnd 2.080806f
C4  g3862_6 gnd 2.080806f
C5  g3862_9 gnd 2.080806f
C6  g3862_2 gnd 2.080806f
C7  g3862_10 gnd 2.080806f
C8  g3862_3 gnd 2.080806f
C9  g3862_1 gnd 2.080806f
C10  g3862_5 gnd 2.080806f
C11  g3862_4 gnd 2.080806f
C12 1 gnd 2.080806f
R1 1 g3862_0 2.224404
R2 g3862_1 1 2.224404
R3 g3862_1 g3862_5 2.224404
R4 g3862_5 g3862_7 2.224404
R5 g3862_7 g3862_3 2.224404
C13 2 gnd 2.080806f
R6 g3862_7 2 2.224404
R7 2 g3862_2 2.224404
C14 3 gnd 2.080806f
R8 g3862_3 3 2.224404
R9 3 g3862_9 2.224404
C15 4 gnd 2.080806f
R10 g3862_9 4 2.224404
C16 5 gnd 2.080806f
R11 4 5 2.224404
R12 5 g3862_4 2.224404
C17 6 gnd 2.080806f
R13 6 g3862_1 2.224404
C18 7 gnd 2.080806f
R14 7 6 2.224404
R15 g3862_10 7 2.224404
C19 8 gnd 2.080806f
R16 8 g3862_10 2.224404
C20 9 gnd 2.080806f
R17 9 8 2.224404
C21 10 gnd 2.080806f
R18 10 9 2.224404
R19 g3862_8 10 2.224404
C22 11 gnd 2.080806f
R20 11 g3862_4 2.224404
C23 12 gnd 2.080806f
R21 11 12 2.224404
C24 13 gnd 2.080806f
R22 12 13 2.224404
C25 14 gnd 2.080806f
R23 13 14 2.224404
C26 15 gnd 2.080806f
R24 15 14 2.224404
C27 16 gnd 2.080806f
R25 15 16 2.224404
C28 17 gnd 2.080806f
R26 16 17 2.224404
R27 17 g3862_6 2.224404
.ends

.subckt netg2853 g2853_5 g2853_2 g2853_3 g2853_4 g2853_1 gnd
C1  g2853_5 gnd 2.080806f
C2  g2853_2 gnd 2.080806f
C3  g2853_3 gnd 2.080806f
C4  g2853_4 gnd 2.080806f
C5  g2853_1 gnd 2.080806f
R1 g2853_1 g2853_4 2.224404
C6 1 gnd 2.080806f
R2 1 g2853_4 2.224404
C7 2 gnd 2.080806f
R3 2 1 2.224404
R4 g2853_5 2 2.224404
C8 3 gnd 2.080806f
R5 3 g2853_5 2.224404
C9 4 gnd 2.080806f
R6 4 3 2.224404
R7 g2853_3 4 2.224404
C10 5 gnd 2.080806f
R8 g2853_4 5 2.224404
C11 6 gnd 2.080806f
R9 5 6 2.224404
C12 7 gnd 2.080806f
R10 6 7 2.224404
C13 8 gnd 2.080806f
R11 7 8 2.224404
C14 9 gnd 2.080806f
R12 8 9 2.224404
C15 10 gnd 2.080806f
R13 9 10 2.224404
C16 11 gnd 2.080806f
R14 10 11 2.224404
C17 12 gnd 2.080806f
R15 11 12 2.224404
C18 13 gnd 2.080806f
R16 12 13 2.224404
C19 14 gnd 2.080806f
R17 13 14 2.224404
C20 15 gnd 2.080806f
R18 14 15 2.224404
C21 16 gnd 2.080806f
R19 15 16 2.224404
C22 17 gnd 2.080806f
R20 16 17 2.224404
C23 18 gnd 2.080806f
R21 17 18 2.224404
R22 18 g2853_2 2.224404
.ends

.subckt netg102 g102_0 g102_1 gnd
C1  g102_0 gnd 2.080806f
C2  g102_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g102_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
R21 20 g102_1 2.224404
.ends

.subckt netg89 g89_0 g89_1 gnd
C1  g89_0 gnd 2.080806f
C2  g89_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g89_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
R21 20 g89_1 2.224404
.ends

.subckt netg44 g44_0 g44_1 gnd
C1  g44_0 gnd 2.080806f
C2  g44_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g44_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
R21 20 g44_1 2.224404
.ends

.subckt netg634 g634_3 g634_1 g634_0 g634_2 g634_5 g634_4 gnd
C1  g634_3 gnd 2.080806f
C2  g634_1 gnd 2.080806f
C3  g634_0 gnd 2.080806f
C4  g634_2 gnd 2.080806f
C5  g634_5 gnd 2.080806f
C6  g634_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g634_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
C10 4 gnd 2.080806f
R4 3 4 2.224404
R5 g634_3 4 2.224404
C11 5 gnd 2.080806f
R6 g634_3 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 8 9 2.224404
R11 g634_1 9 2.224404
C16 10 gnd 2.080806f
R12 10 g634_0 2.224404
C17 11 gnd 2.080806f
R13 11 10 2.224404
C18 12 gnd 2.080806f
R14 12 11 2.224404
C19 13 gnd 2.080806f
R15 13 12 2.224404
C20 14 gnd 2.080806f
R16 14 13 2.224404
C21 15 gnd 2.080806f
R17 15 14 2.224404
C22 16 gnd 2.080806f
R18 15 16 2.224404
R19 16 g634_4 2.224404
R20 g634_2 g634_4 2.224404
R21 g634_2 g634_5 2.224404
.ends

.subckt netg821 g821_0 g821_6 g821_3 g821_1 g821_4 g821_2 g821_5 gnd
C1  g821_0 gnd 2.080806f
C2  g821_6 gnd 2.080806f
C3  g821_3 gnd 2.080806f
C4  g821_1 gnd 2.080806f
C5  g821_4 gnd 2.080806f
C6  g821_2 gnd 2.080806f
C7  g821_5 gnd 2.080806f
R1 g821_0 g821_1 2.224404
R2 g821_5 g821_0 2.224404
C8 1 gnd 2.080806f
R3 g821_1 1 2.224404
C9 2 gnd 2.080806f
R4 1 2 2.224404
C10 3 gnd 2.080806f
R5 2 3 2.224404
C11 4 gnd 2.080806f
R6 3 4 2.224404
C12 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g821_6 2.224404
C13 6 gnd 2.080806f
R9 6 g821_6 2.224404
C14 7 gnd 2.080806f
R10 7 6 2.224404
C15 8 gnd 2.080806f
R11 8 7 2.224404
C16 9 gnd 2.080806f
R12 9 8 2.224404
C17 10 gnd 2.080806f
R13 9 10 2.224404
R14 10 g821_2 2.224404
C18 11 gnd 2.080806f
R15 11 g821_2 2.224404
C19 12 gnd 2.080806f
R16 12 11 2.224404
C20 13 gnd 2.080806f
R17 13 12 2.224404
C21 14 gnd 2.080806f
R18 14 13 2.224404
C22 15 gnd 2.080806f
R19 14 15 2.224404
C23 16 gnd 2.080806f
R20 15 16 2.224404
R21 16 g821_3 2.224404
R22 g821_3 g821_4 2.224404
.ends

.subckt netg1459 g1459_1 g1459_0 gnd
C1  g1459_1 gnd 2.080806f
C2  g1459_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1459_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
R21 g1459_1 20 2.224404
.ends

.subckt netg3784 g3784_3 g3784_2 g3784_0 g3784_9 g3784_12 g3784_8 g3784_7 g3784_6 g3784_4 g3784_1 g3784_11 g3784_10 g3784_5 gnd
C1  g3784_3 gnd 2.080806f
C2  g3784_2 gnd 2.080806f
C3  g3784_0 gnd 2.080806f
C4  g3784_9 gnd 2.080806f
C5  g3784_12 gnd 2.080806f
C6  g3784_8 gnd 2.080806f
C7  g3784_7 gnd 2.080806f
C8  g3784_6 gnd 2.080806f
C9  g3784_4 gnd 2.080806f
C10  g3784_1 gnd 2.080806f
C11  g3784_11 gnd 2.080806f
C12  g3784_10 gnd 2.080806f
C13  g3784_5 gnd 2.080806f
C14 1 gnd 2.080806f
R1 g3784_0 1 2.224404
R2 1 g3784_10 2.224404
C15 2 gnd 2.080806f
R3 g3784_0 2 2.224404
C16 3 gnd 2.080806f
R4 2 3 2.224404
C17 4 gnd 2.080806f
R5 3 4 2.224404
C18 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g3784_6 2.224404
C19 6 gnd 2.080806f
R8 g3784_6 6 2.224404
C20 7 gnd 2.080806f
R9 6 7 2.224404
C21 8 gnd 2.080806f
R10 7 8 2.224404
C22 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g3784_2 2.224404
R13 g3784_2 g3784_5 2.224404
C23 10 gnd 2.080806f
R14 g3784_5 10 2.224404
R15 10 g3784_7 2.224404
R16 g3784_7 g3784_3 2.224404
R17 g3784_3 g3784_9 2.224404
R18 g3784_9 g3784_4 2.224404
R19 g3784_4 g3784_1 2.224404
C24 11 gnd 2.080806f
R20 11 g3784_7 2.224404
C25 12 gnd 2.080806f
R21 12 11 2.224404
R22 g3784_11 12 2.224404
C26 13 gnd 2.080806f
R23 13 g3784_1 2.224404
C27 14 gnd 2.080806f
R24 14 13 2.224404
R25 14 g3784_8 2.224404
C28 15 gnd 2.080806f
R26 g3784_8 15 2.224404
C29 16 gnd 2.080806f
R27 15 16 2.224404
C30 17 gnd 2.080806f
R28 16 17 2.224404
R29 17 g3784_12 2.224404
.ends

.subckt netg3579 g3579_2 g3579_5 g3579_0 g3579_4 g3579_1 g3579_6 g3579_3 g3579_7 gnd
C1  g3579_2 gnd 2.080806f
C2  g3579_5 gnd 2.080806f
C3  g3579_0 gnd 2.080806f
C4  g3579_4 gnd 2.080806f
C5  g3579_1 gnd 2.080806f
C6  g3579_6 gnd 2.080806f
C7  g3579_3 gnd 2.080806f
C8  g3579_7 gnd 2.080806f
R1 g3579_5 g3579_0 2.224404
C9 1 gnd 2.080806f
R2 g3579_0 1 2.224404
C10 2 gnd 2.080806f
R3 2 1 2.224404
C11 3 gnd 2.080806f
R4 2 3 2.224404
C12 4 gnd 2.080806f
R5 3 4 2.224404
C13 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g3579_4 2.224404
C14 6 gnd 2.080806f
R8 6 4 2.224404
C15 7 gnd 2.080806f
R9 7 6 2.224404
C16 8 gnd 2.080806f
R10 8 7 2.224404
R11 g3579_7 8 2.224404
C17 9 gnd 2.080806f
R12 9 g3579_7 2.224404
C18 10 gnd 2.080806f
R13 9 10 2.224404
C19 11 gnd 2.080806f
R14 10 11 2.224404
C20 12 gnd 2.080806f
R15 12 11 2.224404
C21 13 gnd 2.080806f
R16 12 13 2.224404
C22 14 gnd 2.080806f
R17 13 14 2.224404
R18 14 g3579_2 2.224404
C23 15 gnd 2.080806f
R19 g3579_2 15 2.224404
C24 16 gnd 2.080806f
R20 15 16 2.224404
R21 16 g3579_6 2.224404
R22 g3579_1 g3579_6 2.224404
R23 g3579_1 g3579_3 2.224404
.ends

.subckt netg5977 g5977_2 g5977_0 g5977_1 gnd
C1  g5977_2 gnd 2.080806f
C2  g5977_0 gnd 2.080806f
C3  g5977_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5977_0 2.224404
R2 g5977_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
R21 19 g5977_2 2.224404
.ends

.subckt netg5502 g5502_2 g5502_1 g5502_0 gnd
C1  g5502_2 gnd 2.080806f
C2  g5502_1 gnd 2.080806f
C3  g5502_0 gnd 2.080806f
R1 g5502_2 g5502_0 2.224404
C4 1 gnd 2.080806f
R2 1 g5502_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
R21 g5502_1 19 2.224404
.ends

.subckt netg5839 g5839_3 g5839_1 g5839_0 g5839_2 gnd
C1  g5839_3 gnd 2.080806f
C2  g5839_1 gnd 2.080806f
C3  g5839_0 gnd 2.080806f
C4  g5839_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g5839_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g5839_2 2.224404
C10 6 gnd 2.080806f
R7 g5839_2 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
R11 9 g5839_1 2.224404
C14 10 gnd 2.080806f
R12 g5839_1 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
C24 20 gnd 2.080806f
R22 19 20 2.224404
R23 20 g5839_3 2.224404
.ends

.subckt netg2280 g2280_2 g2280_3 g2280_1 g2280_0 gnd
C1  g2280_2 gnd 2.080806f
C2  g2280_3 gnd 2.080806f
C3  g2280_1 gnd 2.080806f
C4  g2280_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2280_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g2280_3 2.224404
C10 6 gnd 2.080806f
R7 6 g2280_0 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
R16 g2280_2 14 2.224404
C19 15 gnd 2.080806f
R17 15 g2280_2 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
R21 g2280_1 18 2.224404
.ends

.subckt netg133 g133_0 g133_1 gnd
C1  g133_0 gnd 2.080806f
C2  g133_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g133_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
R21 g133_1 20 2.224404
.ends

.subckt netg6568 g6568_2 g6568_0 g6568_4 g6568_1 g6568_3 gnd
C1  g6568_2 gnd 2.080806f
C2  g6568_0 gnd 2.080806f
C3  g6568_4 gnd 2.080806f
C4  g6568_1 gnd 2.080806f
C5  g6568_3 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g6568_0 2.224404
C7 2 gnd 2.080806f
R2 2 1 2.224404
C8 3 gnd 2.080806f
R3 3 2 2.224404
C9 4 gnd 2.080806f
R4 4 3 2.224404
C10 5 gnd 2.080806f
R5 5 4 2.224404
C11 6 gnd 2.080806f
R6 6 5 2.224404
C12 7 gnd 2.080806f
R7 7 6 2.224404
C13 8 gnd 2.080806f
R8 8 7 2.224404
C14 9 gnd 2.080806f
R9 9 8 2.224404
C15 10 gnd 2.080806f
R10 10 9 2.224404
C16 11 gnd 2.080806f
R11 11 10 2.224404
C17 12 gnd 2.080806f
R12 12 11 2.224404
C18 13 gnd 2.080806f
R13 13 12 2.224404
R14 g6568_2 13 2.224404
C19 14 gnd 2.080806f
R15 14 g6568_2 2.224404
C20 15 gnd 2.080806f
R16 15 14 2.224404
R17 15 g6568_4 2.224404
C21 16 gnd 2.080806f
R18 g6568_4 16 2.224404
C22 17 gnd 2.080806f
R19 16 17 2.224404
R20 17 g6568_3 2.224404
C23 18 gnd 2.080806f
R21 g6568_3 18 2.224404
C24 19 gnd 2.080806f
R22 18 19 2.224404
C25 20 gnd 2.080806f
R23 19 20 2.224404
C26 21 gnd 2.080806f
R24 20 21 2.224404
R25 21 g6568_1 2.224404
.ends

.subckt netg652 g652_5 g652_4 g652_2 g652_0 g652_1 g652_3 g652_7 g652_6 gnd
C1  g652_5 gnd 2.080806f
C2  g652_4 gnd 2.080806f
C3  g652_2 gnd 2.080806f
C4  g652_0 gnd 2.080806f
C5  g652_1 gnd 2.080806f
C6  g652_3 gnd 2.080806f
C7  g652_7 gnd 2.080806f
C8  g652_6 gnd 2.080806f
R1 g652_1 g652_0 2.224404
C9 1 gnd 2.080806f
R2 g652_0 1 2.224404
R3 g652_2 1 2.224404
C10 2 gnd 2.080806f
R4 g652_2 2 2.224404
C11 3 gnd 2.080806f
R5 2 3 2.224404
C12 4 gnd 2.080806f
R6 3 4 2.224404
C13 5 gnd 2.080806f
R7 4 5 2.224404
C14 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g652_5 2.224404
C15 7 gnd 2.080806f
R10 7 g652_5 2.224404
C16 8 gnd 2.080806f
R11 7 8 2.224404
C17 9 gnd 2.080806f
R12 9 8 2.224404
C18 10 gnd 2.080806f
R13 9 10 2.224404
C19 11 gnd 2.080806f
R14 10 11 2.224404
R15 11 g652_4 2.224404
C20 12 gnd 2.080806f
R16 g652_4 12 2.224404
C21 13 gnd 2.080806f
R17 12 13 2.224404
C22 14 gnd 2.080806f
R18 13 14 2.224404
C23 15 gnd 2.080806f
R19 14 15 2.224404
C24 16 gnd 2.080806f
R20 15 16 2.224404
R21 16 g652_7 2.224404
C25 17 gnd 2.080806f
R22 g652_7 17 2.224404
C26 18 gnd 2.080806f
R23 17 18 2.224404
C27 19 gnd 2.080806f
R24 18 19 2.224404
C28 20 gnd 2.080806f
R25 19 20 2.224404
C29 21 gnd 2.080806f
R26 20 21 2.224404
R27 21 g652_6 2.224404
C30 22 gnd 2.080806f
R28 22 12 2.224404
C31 23 gnd 2.080806f
R29 22 23 2.224404
C32 24 gnd 2.080806f
R30 23 24 2.224404
C33 25 gnd 2.080806f
R31 25 24 2.224404
C34 26 gnd 2.080806f
R32 25 26 2.224404
C35 27 gnd 2.080806f
R33 26 27 2.224404
R34 27 g652_3 2.224404
.ends

.subckt netg7512 g7512_0 g7512_1 gnd
C1  g7512_0 gnd 2.080806f
C2  g7512_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7512_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
R22 21 g7512_1 2.224404
.ends

.subckt netg3037 g3037_0 g3037_6 g3037_5 g3037_3 g3037_1 g3037_2 g3037_7 g3037_4 gnd
C1  g3037_0 gnd 2.080806f
C2  g3037_6 gnd 2.080806f
C3  g3037_5 gnd 2.080806f
C4  g3037_3 gnd 2.080806f
C5  g3037_1 gnd 2.080806f
C6  g3037_2 gnd 2.080806f
C7  g3037_7 gnd 2.080806f
C8  g3037_4 gnd 2.080806f
R1 g3037_6 g3037_0 2.224404
C9 1 gnd 2.080806f
R2 1 g3037_6 2.224404
R3 g3037_3 1 2.224404
C10 2 gnd 2.080806f
R4 2 g3037_6 2.224404
C11 3 gnd 2.080806f
R5 3 2 2.224404
R6 g3037_5 3 2.224404
C12 4 gnd 2.080806f
R7 4 g3037_5 2.224404
C13 5 gnd 2.080806f
R8 5 4 2.224404
C14 6 gnd 2.080806f
R9 6 5 2.224404
R10 g3037_4 6 2.224404
C15 7 gnd 2.080806f
R11 g3037_5 7 2.224404
C16 8 gnd 2.080806f
R12 7 8 2.224404
C17 9 gnd 2.080806f
R13 8 9 2.224404
C18 10 gnd 2.080806f
R14 9 10 2.224404
C19 11 gnd 2.080806f
R15 11 10 2.224404
C20 12 gnd 2.080806f
R16 11 12 2.224404
R17 g3037_2 12 2.224404
C21 13 gnd 2.080806f
R18 g3037_2 13 2.224404
C22 14 gnd 2.080806f
R19 14 13 2.224404
C23 15 gnd 2.080806f
R20 15 14 2.224404
R21 g3037_1 15 2.224404
C24 16 gnd 2.080806f
R22 15 16 2.224404
C25 17 gnd 2.080806f
R23 16 17 2.224404
C26 18 gnd 2.080806f
R24 17 18 2.224404
R25 g3037_7 18 2.224404
.ends

.subckt netg2409 g2409_0 g2409_2 g2409_1 gnd
C1  g2409_0 gnd 2.080806f
C2  g2409_2 gnd 2.080806f
C3  g2409_1 gnd 2.080806f
R1 g2409_2 g2409_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2409_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
R22 g2409_1 20 2.224404
.ends

.subckt netg1683 g1683_2 g1683_3 g1683_1 gnd
C1  g1683_2 gnd 2.080806f
C2  g1683_3 gnd 2.080806f
C3  g1683_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1683_3 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g1683_2 2.224404
C8 5 gnd 2.080806f
R6 g1683_2 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
R24 22 g1683_1 2.224404
.ends

.subckt netg7513 g7513_0 g7513_1 gnd
C1  g7513_0 gnd 2.080806f
C2  g7513_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7513_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
R22 g7513_1 21 2.224404
.ends

.subckt netg5418 g5418_1 g5418_0 g5418_2 gnd
C1  g5418_1 gnd 2.080806f
C2  g5418_0 gnd 2.080806f
C3  g5418_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g5418_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5418_1 2 2.224404
C6 3 gnd 2.080806f
R4 g5418_0 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
R23 21 g5418_2 2.224404
.ends

.subckt netg7515 g7515_0 g7515_1 gnd
C1  g7515_0 gnd 2.080806f
C2  g7515_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7515_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
R22 g7515_1 21 2.224404
.ends

.subckt netg45 g45_0 g45_1 gnd
C1  g45_0 gnd 2.080806f
C2  g45_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g45_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
R22 21 g45_1 2.224404
.ends

.subckt netg683 g683_3 g683_2 g683_0 g683_5 g683_6 g683_1 g683_4 gnd
C1  g683_3 gnd 2.080806f
C2  g683_2 gnd 2.080806f
C3  g683_0 gnd 2.080806f
C4  g683_5 gnd 2.080806f
C5  g683_6 gnd 2.080806f
C6  g683_1 gnd 2.080806f
C7  g683_4 gnd 2.080806f
R1 g683_0 g683_1 2.224404
R2 g683_1 g683_3 2.224404
C8 1 gnd 2.080806f
R3 1 g683_0 2.224404
C9 2 gnd 2.080806f
R4 2 1 2.224404
C10 3 gnd 2.080806f
R5 3 2 2.224404
C11 4 gnd 2.080806f
R6 4 3 2.224404
C12 5 gnd 2.080806f
R7 5 4 2.224404
C13 6 gnd 2.080806f
R8 6 5 2.224404
R9 g683_4 6 2.224404
C14 7 gnd 2.080806f
R10 7 g683_4 2.224404
R11 7 g683_5 2.224404
C15 8 gnd 2.080806f
R12 g683_3 8 2.224404
C16 9 gnd 2.080806f
R13 9 8 2.224404
C17 10 gnd 2.080806f
R14 9 10 2.224404
C18 11 gnd 2.080806f
R15 10 11 2.224404
C19 12 gnd 2.080806f
R16 11 12 2.224404
C20 13 gnd 2.080806f
R17 13 12 2.224404
C21 14 gnd 2.080806f
R18 13 14 2.224404
C22 15 gnd 2.080806f
R19 14 15 2.224404
R20 15 g683_2 2.224404
C23 16 gnd 2.080806f
R21 g683_2 16 2.224404
C24 17 gnd 2.080806f
R22 16 17 2.224404
C25 18 gnd 2.080806f
R23 17 18 2.224404
C26 19 gnd 2.080806f
R24 18 19 2.224404
C27 20 gnd 2.080806f
R25 19 20 2.224404
C28 21 gnd 2.080806f
R26 20 21 2.224404
R27 21 g683_6 2.224404
.ends

.subckt netg3057 g3057_1 g3057_0 gnd
C1  g3057_1 gnd 2.080806f
C2  g3057_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g3057_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
R24 23 g3057_1 2.224404
.ends

.subckt netg588 g588_2 g588_3 g588_1 g588_4 g588_5 g588_0 gnd
C1  g588_2 gnd 2.080806f
C2  g588_3 gnd 2.080806f
C3  g588_1 gnd 2.080806f
C4  g588_4 gnd 2.080806f
C5  g588_5 gnd 2.080806f
C6  g588_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g588_0 2.224404
R2 g588_3 1 2.224404
C8 2 gnd 2.080806f
R3 2 g588_3 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
C16 10 gnd 2.080806f
R11 10 9 2.224404
C17 11 gnd 2.080806f
R12 11 10 2.224404
C18 12 gnd 2.080806f
R13 12 11 2.224404
C19 13 gnd 2.080806f
R14 13 12 2.224404
C20 14 gnd 2.080806f
R15 14 13 2.224404
C21 15 gnd 2.080806f
R16 15 14 2.224404
C22 16 gnd 2.080806f
R17 16 15 2.224404
R18 g588_4 16 2.224404
C23 17 gnd 2.080806f
R19 17 g588_4 2.224404
C24 18 gnd 2.080806f
R20 17 18 2.224404
R21 g588_5 18 2.224404
R22 g588_1 g588_5 2.224404
C25 19 gnd 2.080806f
R23 19 g588_1 2.224404
R24 g588_2 19 2.224404
.ends

.subckt netg6590 g6590_2 g6590_1 g6590_4 g6590_0 g6590_3 g6590_6 gnd
C1  g6590_2 gnd 2.080806f
C2  g6590_1 gnd 2.080806f
C3  g6590_4 gnd 2.080806f
C4  g6590_0 gnd 2.080806f
C5  g6590_3 gnd 2.080806f
C6  g6590_6 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g6590_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
C10 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g6590_3 2.224404
R6 g6590_3 g6590_4 2.224404
C11 5 gnd 2.080806f
R7 g6590_3 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g6590_6 2.224404
C13 7 gnd 2.080806f
R10 g6590_6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
R14 10 g6590_1 2.224404
C17 11 gnd 2.080806f
R15 g6590_0 11 2.224404
C18 12 gnd 2.080806f
R16 11 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
C21 15 gnd 2.080806f
R19 14 15 2.224404
C22 16 gnd 2.080806f
R20 15 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
C29 23 gnd 2.080806f
R27 22 23 2.224404
R28 23 g6590_2 2.224404
.ends

.subckt netg56 g56_1 g56_0 gnd
C1  g56_1 gnd 2.080806f
C2  g56_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g56_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
R22 g56_1 21 2.224404
.ends

.subckt netg7497 g7497_0 g7497_1 gnd
C1  g7497_0 gnd 2.080806f
C2  g7497_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7497_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
R22 g7497_1 21 2.224404
.ends

.subckt netg2284 g2284_1 g2284_0 g2284_3 g2284_2 gnd
C1  g2284_1 gnd 2.080806f
C2  g2284_0 gnd 2.080806f
C3  g2284_3 gnd 2.080806f
C4  g2284_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2284_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g2284_1 2.224404
C11 7 gnd 2.080806f
R8 g2284_1 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
R13 11 g2284_2 2.224404
C16 12 gnd 2.080806f
R14 12 g2284_0 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
C24 20 gnd 2.080806f
R22 20 19 2.224404
C25 21 gnd 2.080806f
R23 21 20 2.224404
R24 g2284_3 21 2.224404
.ends

.subckt netg3587 g3587_8 g3587_9 g3587_2 g3587_12 g3587_0 g3587_3 g3587_13 g3587_6 g3587_11 g3587_4 g3587_10 g3587_1 g3587_7 gnd
C1  g3587_8 gnd 2.080806f
C2  g3587_9 gnd 2.080806f
C3  g3587_2 gnd 2.080806f
C4  g3587_12 gnd 2.080806f
C5  g3587_0 gnd 2.080806f
C6  g3587_3 gnd 2.080806f
C7  g3587_13 gnd 2.080806f
C8  g3587_6 gnd 2.080806f
C9  g3587_11 gnd 2.080806f
C10  g3587_4 gnd 2.080806f
C11  g3587_10 gnd 2.080806f
C12  g3587_1 gnd 2.080806f
C13  g3587_7 gnd 2.080806f
C14 1 gnd 2.080806f
R1 1 g3587_0 2.224404
R2 g3587_6 1 2.224404
R3 g3587_3 g3587_6 2.224404
C15 2 gnd 2.080806f
R4 g3587_3 2 2.224404
R5 g3587_11 2 2.224404
C16 3 gnd 2.080806f
R6 g3587_0 3 2.224404
R7 3 g3587_8 2.224404
C17 4 gnd 2.080806f
R8 4 g3587_3 2.224404
C18 5 gnd 2.080806f
R9 5 4 2.224404
R10 g3587_10 5 2.224404
R11 g3587_9 g3587_10 2.224404
R12 g3587_9 g3587_2 2.224404
C19 6 gnd 2.080806f
R13 6 g3587_2 2.224404
R14 g3587_13 6 2.224404
C20 7 gnd 2.080806f
R15 g3587_2 7 2.224404
R16 7 g3587_4 2.224404
C21 8 gnd 2.080806f
R17 8 g3587_13 2.224404
C22 9 gnd 2.080806f
R18 9 8 2.224404
C23 10 gnd 2.080806f
R19 10 9 2.224404
C24 11 gnd 2.080806f
R20 11 10 2.224404
C25 12 gnd 2.080806f
R21 12 11 2.224404
C26 13 gnd 2.080806f
R22 12 13 2.224404
R23 g3587_12 13 2.224404
C27 14 gnd 2.080806f
R24 14 g3587_12 2.224404
C28 15 gnd 2.080806f
R25 15 14 2.224404
C29 16 gnd 2.080806f
R26 16 15 2.224404
R27 g3587_7 16 2.224404
C30 17 gnd 2.080806f
R28 17 15 2.224404
C31 18 gnd 2.080806f
R29 18 17 2.224404
R30 g3587_1 18 2.224404
.ends

.subckt netg582 g582_5 g582_4 g582_2 g582_3 g582_1 g582_0 gnd
C1  g582_5 gnd 2.080806f
C2  g582_4 gnd 2.080806f
C3  g582_2 gnd 2.080806f
C4  g582_3 gnd 2.080806f
C5  g582_1 gnd 2.080806f
C6  g582_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g582_0 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g582_2 2.224404
R4 g582_4 2 2.224404
C9 3 gnd 2.080806f
R5 g582_2 3 2.224404
C10 4 gnd 2.080806f
R6 3 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
R11 8 g582_1 2.224404
C15 9 gnd 2.080806f
R12 g582_2 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
R18 14 g582_5 2.224404
C21 15 gnd 2.080806f
R19 g582_1 15 2.224404
C22 16 gnd 2.080806f
R20 15 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
C29 23 gnd 2.080806f
R27 22 23 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 24 25 2.224404
R30 25 g582_3 2.224404
.ends

.subckt netg2552 g2552_1 g2552_0 g2552_2 gnd
C1  g2552_1 gnd 2.080806f
C2  g2552_0 gnd 2.080806f
C3  g2552_2 gnd 2.080806f
R1 g2552_0 g2552_1 2.224404
C4 1 gnd 2.080806f
R2 1 g2552_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
R24 g2552_2 22 2.224404
.ends

.subckt netg1102 g1102_4 g1102_2 g1102_1 g1102_0 g1102_3 g1102_5 gnd
C1  g1102_4 gnd 2.080806f
C2  g1102_2 gnd 2.080806f
C3  g1102_1 gnd 2.080806f
C4  g1102_0 gnd 2.080806f
C5  g1102_3 gnd 2.080806f
C6  g1102_5 gnd 2.080806f
R1 g1102_4 g1102_0 2.224404
C7 1 gnd 2.080806f
R2 g1102_0 1 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
R4 2 g1102_3 2.224404
C9 3 gnd 2.080806f
R5 3 g1102_4 2.224404
C10 4 gnd 2.080806f
R6 4 3 2.224404
C11 5 gnd 2.080806f
R7 5 4 2.224404
C12 6 gnd 2.080806f
R8 6 5 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 8 7 2.224404
R11 g1102_5 8 2.224404
C15 9 gnd 2.080806f
R12 g1102_3 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
R19 g1102_1 15 2.224404
C22 16 gnd 2.080806f
R20 9 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 21 20 2.224404
R26 21 g1102_2 2.224404
.ends

.subckt netg7498 g7498_1 g7498_0 gnd
C1  g7498_1 gnd 2.080806f
C2  g7498_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7498_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
R22 21 g7498_1 2.224404
.ends

.subckt netg7510 g7510_1 g7510_0 gnd
C1  g7510_1 gnd 2.080806f
C2  g7510_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7510_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
R22 g7510_1 21 2.224404
.ends

.subckt netg4582 g4582_6 g4582_5 g4582_3 g4582_12 g4582_10 g4582_15 g4582_9 g4582_0 g4582_11 g4582_2 g4582_7 g4582_1 g4582_8 g4582_13 g4582_4 g4582_14 gnd
C1  g4582_6 gnd 2.080806f
C2  g4582_5 gnd 2.080806f
C3  g4582_3 gnd 2.080806f
C4  g4582_12 gnd 2.080806f
C5  g4582_10 gnd 2.080806f
C6  g4582_15 gnd 2.080806f
C7  g4582_9 gnd 2.080806f
C8  g4582_0 gnd 2.080806f
C9  g4582_11 gnd 2.080806f
C10  g4582_2 gnd 2.080806f
C11  g4582_7 gnd 2.080806f
C12  g4582_1 gnd 2.080806f
C13  g4582_8 gnd 2.080806f
C14  g4582_13 gnd 2.080806f
C15  g4582_4 gnd 2.080806f
C16  g4582_14 gnd 2.080806f
C17 1 gnd 2.080806f
R1 g4582_0 1 2.224404
R2 1 g4582_11 2.224404
C18 2 gnd 2.080806f
R3 g4582_11 2 2.224404
R4 2 g4582_5 2.224404
C19 3 gnd 2.080806f
R5 g4582_5 3 2.224404
R6 3 g4582_8 2.224404
C20 4 gnd 2.080806f
R7 4 2 2.224404
R8 g4582_2 4 2.224404
R9 g4582_3 g4582_2 2.224404
C21 5 gnd 2.080806f
R10 g4582_2 5 2.224404
R11 5 g4582_9 2.224404
C22 6 gnd 2.080806f
R12 6 g4582_3 2.224404
R13 g4582_7 6 2.224404
C23 7 gnd 2.080806f
R14 7 g4582_3 2.224404
R15 7 g4582_10 2.224404
R16 g4582_10 g4582_13 2.224404
C24 8 gnd 2.080806f
R17 8 g4582_7 2.224404
R18 g4582_14 8 2.224404
R19 g4582_4 g4582_14 2.224404
R20 g4582_12 g4582_14 2.224404
R21 g4582_14 g4582_15 2.224404
C25 9 gnd 2.080806f
R22 9 g4582_12 2.224404
C26 10 gnd 2.080806f
R23 10 9 2.224404
C27 11 gnd 2.080806f
R24 11 10 2.224404
C28 12 gnd 2.080806f
R25 12 11 2.224404
C29 13 gnd 2.080806f
R26 13 12 2.224404
C30 14 gnd 2.080806f
R27 14 13 2.224404
C31 15 gnd 2.080806f
R28 15 14 2.224404
R29 g4582_6 15 2.224404
C32 16 gnd 2.080806f
R30 16 g4582_6 2.224404
C33 17 gnd 2.080806f
R31 17 16 2.224404
C34 18 gnd 2.080806f
R32 18 17 2.224404
R33 g4582_1 18 2.224404
.ends

.subckt netg46 g46_1 g46_0 gnd
C1  g46_1 gnd 2.080806f
C2  g46_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g46_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
R23 g46_1 22 2.224404
.ends

.subckt netg7506 g7506_1 g7506_0 gnd
C1  g7506_1 gnd 2.080806f
C2  g7506_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7506_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
R23 g7506_1 22 2.224404
.ends

.subckt netg2680 g2680_2 g2680_0 g2680_1 gnd
C1  g2680_2 gnd 2.080806f
C2  g2680_0 gnd 2.080806f
C3  g2680_1 gnd 2.080806f
R1 g2680_2 g2680_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2680_2 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
R25 g2680_1 23 2.224404
.ends

.subckt netg594 g594_3 g594_7 g594_5 g594_2 g594_6 g594_4 g594_1 gnd
C1  g594_3 gnd 2.080806f
C2  g594_7 gnd 2.080806f
C3  g594_5 gnd 2.080806f
C4  g594_2 gnd 2.080806f
C5  g594_6 gnd 2.080806f
C6  g594_4 gnd 2.080806f
C7  g594_1 gnd 2.080806f
R1 g594_1 g594_7 2.224404
R2 g594_7 g594_3 2.224404
C8 1 gnd 2.080806f
R3 g594_3 1 2.224404
C9 2 gnd 2.080806f
R4 1 2 2.224404
R5 2 g594_5 2.224404
R6 g594_2 g594_5 2.224404
C10 3 gnd 2.080806f
R7 g594_5 3 2.224404
C11 4 gnd 2.080806f
R8 3 4 2.224404
C12 5 gnd 2.080806f
R9 4 5 2.224404
C13 6 gnd 2.080806f
R10 5 6 2.224404
C14 7 gnd 2.080806f
R11 6 7 2.224404
C15 8 gnd 2.080806f
R12 7 8 2.224404
C16 9 gnd 2.080806f
R13 8 9 2.224404
C17 10 gnd 2.080806f
R14 9 10 2.224404
C18 11 gnd 2.080806f
R15 10 11 2.224404
C19 12 gnd 2.080806f
R16 11 12 2.224404
C20 13 gnd 2.080806f
R17 12 13 2.224404
R18 13 g594_4 2.224404
C21 14 gnd 2.080806f
R19 14 g594_4 2.224404
C22 15 gnd 2.080806f
R20 15 14 2.224404
C23 16 gnd 2.080806f
R21 16 15 2.224404
C24 17 gnd 2.080806f
R22 17 16 2.224404
C25 18 gnd 2.080806f
R23 18 17 2.224404
C26 19 gnd 2.080806f
R24 19 18 2.224404
R25 g594_6 19 2.224404
.ends

.subckt netg3552 g3552_1 g3552_0 gnd
C1  g3552_1 gnd 2.080806f
C2  g3552_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3552_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
R27 g3552_1 26 2.224404
.ends

.subckt netg842 g842_6 g842_0 g842_1 g842_4 g842_3 g842_2 g842_5 gnd
C1  g842_6 gnd 2.080806f
C2  g842_0 gnd 2.080806f
C3  g842_1 gnd 2.080806f
C4  g842_4 gnd 2.080806f
C5  g842_3 gnd 2.080806f
C6  g842_2 gnd 2.080806f
C7  g842_5 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g842_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
R3 g842_6 2 2.224404
C10 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g842_2 2.224404
C11 4 gnd 2.080806f
R6 g842_2 4 2.224404
R7 4 g842_3 2.224404
C12 5 gnd 2.080806f
R8 5 g842_3 2.224404
R9 g842_5 5 2.224404
C13 6 gnd 2.080806f
R10 2 6 2.224404
C14 7 gnd 2.080806f
R11 6 7 2.224404
C15 8 gnd 2.080806f
R12 7 8 2.224404
R13 8 g842_1 2.224404
C16 9 gnd 2.080806f
R14 9 g842_1 2.224404
C17 10 gnd 2.080806f
R15 10 9 2.224404
C18 11 gnd 2.080806f
R16 11 10 2.224404
C19 12 gnd 2.080806f
R17 11 12 2.224404
C20 13 gnd 2.080806f
R18 13 12 2.224404
C21 14 gnd 2.080806f
R19 13 14 2.224404
C22 15 gnd 2.080806f
R20 14 15 2.224404
C23 16 gnd 2.080806f
R21 16 15 2.224404
C24 17 gnd 2.080806f
R22 17 16 2.224404
C25 18 gnd 2.080806f
R23 17 18 2.224404
C26 19 gnd 2.080806f
R24 19 18 2.224404
C27 20 gnd 2.080806f
R25 19 20 2.224404
R26 g842_4 20 2.224404
.ends

.subckt netg660 g660_4 g660_1 g660_2 g660_0 g660_5 g660_3 gnd
C1  g660_4 gnd 2.080806f
C2  g660_1 gnd 2.080806f
C3  g660_2 gnd 2.080806f
C4  g660_0 gnd 2.080806f
C5  g660_5 gnd 2.080806f
C6  g660_3 gnd 2.080806f
R1 g660_2 g660_0 2.224404
C7 1 gnd 2.080806f
R2 1 g660_2 2.224404
C8 2 gnd 2.080806f
R3 2 1 2.224404
R4 g660_3 2 2.224404
C9 3 gnd 2.080806f
R5 g660_3 3 2.224404
C10 4 gnd 2.080806f
R6 3 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
R8 5 g660_5 2.224404
C12 6 gnd 2.080806f
R9 g660_0 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
R24 20 g660_1 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
R27 22 g660_4 2.224404
.ends

.subckt netg2314 g2314_2 g2314_3 g2314_1 gnd
C1  g2314_2 gnd 2.080806f
C2  g2314_3 gnd 2.080806f
C3  g2314_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2314_1 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
R16 g2314_3 15 2.224404
C19 16 gnd 2.080806f
R17 16 g2314_3 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
R24 g2314_2 22 2.224404
.ends

.subckt netg7495 g7495_1 g7495_0 gnd
C1  g7495_1 gnd 2.080806f
C2  g7495_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7495_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
R23 g7495_1 22 2.224404
.ends

.subckt netg1398 g1398_1 g1398_0 gnd
C1  g1398_1 gnd 2.080806f
C2  g1398_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1398_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
R23 22 g1398_1 2.224404
.ends

.subckt netg1811 g1811_3 g1811_0 g1811_2 g1811_1 gnd
C1  g1811_3 gnd 2.080806f
C2  g1811_0 gnd 2.080806f
C3  g1811_2 gnd 2.080806f
C4  g1811_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1811_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
C14 10 gnd 2.080806f
R10 10 9 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
R12 g1811_3 11 2.224404
C16 12 gnd 2.080806f
R13 g1811_3 12 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 15 14 2.224404
C20 16 gnd 2.080806f
R17 16 15 2.224404
C21 17 gnd 2.080806f
R18 17 16 2.224404
C22 18 gnd 2.080806f
R19 18 17 2.224404
C23 19 gnd 2.080806f
R20 19 18 2.224404
C24 20 gnd 2.080806f
R21 20 19 2.224404
C25 21 gnd 2.080806f
R22 21 20 2.224404
C26 22 gnd 2.080806f
R23 22 21 2.224404
R24 g1811_2 22 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
C28 24 gnd 2.080806f
R26 23 24 2.224404
C29 25 gnd 2.080806f
R27 24 25 2.224404
C30 26 gnd 2.080806f
R28 25 26 2.224404
C31 27 gnd 2.080806f
R29 26 27 2.224404
R30 27 g1811_1 2.224404
.ends

.subckt netg1620 g1620_0 g1620_3 g1620_2 g1620_1 gnd
C1  g1620_0 gnd 2.080806f
C2  g1620_3 gnd 2.080806f
C3  g1620_2 gnd 2.080806f
C4  g1620_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1620_0 1 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
R5 g1620_2 4 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 15 14 2.224404
C20 16 gnd 2.080806f
R17 16 15 2.224404
C21 17 gnd 2.080806f
R18 17 16 2.224404
C22 18 gnd 2.080806f
R19 18 17 2.224404
C23 19 gnd 2.080806f
R20 19 18 2.224404
C24 20 gnd 2.080806f
R21 20 19 2.224404
C25 21 gnd 2.080806f
R22 21 20 2.224404
R23 g1620_3 21 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 23 22 2.224404
C28 24 gnd 2.080806f
R26 24 23 2.224404
R27 24 g1620_1 2.224404
.ends

.subckt netg2276 g2276_2 g2276_1 g2276_3 g2276_0 gnd
C1  g2276_2 gnd 2.080806f
C2  g2276_1 gnd 2.080806f
C3  g2276_3 gnd 2.080806f
C4  g2276_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2276_0 2.224404
R2 g2276_1 1 2.224404
C6 2 gnd 2.080806f
R3 2 g2276_1 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 15 14 2.224404
C20 16 gnd 2.080806f
R17 16 15 2.224404
C21 17 gnd 2.080806f
R18 17 16 2.224404
C22 18 gnd 2.080806f
R19 18 17 2.224404
C23 19 gnd 2.080806f
R20 19 18 2.224404
C24 20 gnd 2.080806f
R21 20 19 2.224404
R22 g2276_3 20 2.224404
C25 21 gnd 2.080806f
R23 20 21 2.224404
R24 21 g2276_2 2.224404
.ends

.subckt netg1116 g1116_0 g1116_1 gnd
C1  g1116_0 gnd 2.080806f
C2  g1116_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1116_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
R23 22 g1116_1 2.224404
.ends

.subckt netg2089 g2089_0 g2089_2 g2089_1 gnd
C1  g2089_0 gnd 2.080806f
C2  g2089_2 gnd 2.080806f
C3  g2089_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2089_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
R14 13 g2089_1 2.224404
C17 14 gnd 2.080806f
R15 14 g2089_0 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
R28 g2089_2 26 2.224404
.ends

.subckt netg123 g123_0 g123_1 gnd
C1  g123_0 gnd 2.080806f
C2  g123_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g123_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
R24 g123_1 23 2.224404
.ends

.subckt netg138 g138_1 g138_0 gnd
C1  g138_1 gnd 2.080806f
C2  g138_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g138_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
R24 23 g138_1 2.224404
.ends

.subckt netg58 g58_1 g58_0 gnd
C1  g58_1 gnd 2.080806f
C2  g58_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g58_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
R24 g58_1 23 2.224404
.ends

.subckt netg4662 g4662_0 g4662_2 g4662_1 gnd
C1  g4662_0 gnd 2.080806f
C2  g4662_2 gnd 2.080806f
C3  g4662_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4662_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
R21 g4662_2 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
R24 22 g4662_1 2.224404
.ends

.subckt netg2635 g2635_0 g2635_1 g2635_2 gnd
C1  g2635_0 gnd 2.080806f
C2  g2635_1 gnd 2.080806f
C3  g2635_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2635_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2635_2 2.224404
C6 3 gnd 2.080806f
R4 g2635_2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
R24 22 g2635_1 2.224404
.ends

.subckt netg7260 g7260_2 g7260_0 g7260_1 gnd
C1  g7260_2 gnd 2.080806f
C2  g7260_0 gnd 2.080806f
C3  g7260_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7260_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
R5 g7260_1 4 2.224404
C8 5 gnd 2.080806f
R6 g7260_1 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
R26 g7260_2 24 2.224404
.ends

.subckt netg2546 g2546_0 g2546_2 g2546_1 gnd
C1  g2546_0 gnd 2.080806f
C2  g2546_2 gnd 2.080806f
C3  g2546_1 gnd 2.080806f
R1 g2546_1 g2546_0 2.224404
C4 1 gnd 2.080806f
R2 1 g2546_1 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
R24 g2546_2 22 2.224404
.ends

.subckt netg712 g712_3 g712_1 g712_0 g712_2 gnd
C1  g712_3 gnd 2.080806f
C2  g712_1 gnd 2.080806f
C3  g712_0 gnd 2.080806f
C4  g712_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g712_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
R4 g712_3 3 2.224404
C8 4 gnd 2.080806f
R5 4 g712_3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 15 14 2.224404
C20 16 gnd 2.080806f
R17 16 15 2.224404
C21 17 gnd 2.080806f
R18 17 16 2.224404
C22 18 gnd 2.080806f
R19 18 17 2.224404
C23 19 gnd 2.080806f
R20 19 18 2.224404
C24 20 gnd 2.080806f
R21 20 19 2.224404
C25 21 gnd 2.080806f
R22 21 20 2.224404
R23 g712_2 21 2.224404
R24 g712_1 g712_2 2.224404
.ends

.subckt netg1905 g1905_1 g1905_0 gnd
C1  g1905_1 gnd 2.080806f
C2  g1905_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1905_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
R24 g1905_1 23 2.224404
.ends

.subckt netg21 g21_0 g21_1 gnd
C1  g21_0 gnd 2.080806f
C2  g21_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g21_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
R24 g21_1 23 2.224404
.ends

.subckt netg7493 g7493_1 g7493_0 gnd
C1  g7493_1 gnd 2.080806f
C2  g7493_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7493_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
R24 23 g7493_1 2.224404
.ends

.subckt netg139 g139_1 g139_0 gnd
C1  g139_1 gnd 2.080806f
C2  g139_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g139_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
R25 24 g139_1 2.224404
.ends

.subckt netg2107 g2107_3 g2107_1 g2107_0 g2107_2 gnd
C1  g2107_3 gnd 2.080806f
C2  g2107_1 gnd 2.080806f
C3  g2107_0 gnd 2.080806f
C4  g2107_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2107_0 1 2.224404
R2 g2107_1 1 2.224404
C6 2 gnd 2.080806f
R3 1 2 2.224404
C7 3 gnd 2.080806f
R4 2 3 2.224404
C8 4 gnd 2.080806f
R5 3 4 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 11 12 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
C18 14 gnd 2.080806f
R15 13 14 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
C20 16 gnd 2.080806f
R17 15 16 2.224404
C21 17 gnd 2.080806f
R18 16 17 2.224404
C22 18 gnd 2.080806f
R19 17 18 2.224404
C23 19 gnd 2.080806f
R20 18 19 2.224404
C24 20 gnd 2.080806f
R21 19 20 2.224404
R22 20 g2107_2 2.224404
C25 21 gnd 2.080806f
R23 g2107_2 21 2.224404
C26 22 gnd 2.080806f
R24 21 22 2.224404
R25 22 g2107_3 2.224404
.ends

.subckt netg1904 g1904_1 g1904_0 gnd
C1  g1904_1 gnd 2.080806f
C2  g1904_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1904_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
R25 g1904_1 24 2.224404
.ends

.subckt netg5968 g5968_0 g5968_1 gnd
C1  g5968_0 gnd 2.080806f
C2  g5968_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5968_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
R25 24 g5968_1 2.224404
.ends

.subckt netg1782 g1782_3 g1782_1 g1782_0 g1782_2 gnd
C1  g1782_3 gnd 2.080806f
C2  g1782_1 gnd 2.080806f
C3  g1782_0 gnd 2.080806f
C4  g1782_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1782_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
C11 7 gnd 2.080806f
R7 6 7 2.224404
C12 8 gnd 2.080806f
R8 7 8 2.224404
C13 9 gnd 2.080806f
R9 8 9 2.224404
C14 10 gnd 2.080806f
R10 9 10 2.224404
C15 11 gnd 2.080806f
R11 10 11 2.224404
C16 12 gnd 2.080806f
R12 11 12 2.224404
C17 13 gnd 2.080806f
R13 12 13 2.224404
C18 14 gnd 2.080806f
R14 13 14 2.224404
C19 15 gnd 2.080806f
R15 15 14 2.224404
C20 16 gnd 2.080806f
R16 15 16 2.224404
C21 17 gnd 2.080806f
R17 16 17 2.224404
C22 18 gnd 2.080806f
R18 17 18 2.224404
C23 19 gnd 2.080806f
R19 18 19 2.224404
C24 20 gnd 2.080806f
R20 19 20 2.224404
C25 21 gnd 2.080806f
R21 20 21 2.224404
C26 22 gnd 2.080806f
R22 21 22 2.224404
C27 23 gnd 2.080806f
R23 23 22 2.224404
R24 23 g1782_3 2.224404
C28 24 gnd 2.080806f
R25 24 g1782_3 2.224404
C29 25 gnd 2.080806f
R26 25 24 2.224404
R27 25 g1782_2 2.224404
C30 26 gnd 2.080806f
R28 26 g1782_2 2.224404
R29 g1782_1 26 2.224404
.ends

.subckt netg4784 g4784_3 g4784_2 g4784_4 g4784_1 g4784_6 g4784_5 g4784_0 gnd
C1  g4784_3 gnd 2.080806f
C2  g4784_2 gnd 2.080806f
C3  g4784_4 gnd 2.080806f
C4  g4784_1 gnd 2.080806f
C5  g4784_6 gnd 2.080806f
C6  g4784_5 gnd 2.080806f
C7  g4784_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g4784_0 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
R3 g4784_1 2 2.224404
C10 3 gnd 2.080806f
R4 g4784_1 3 2.224404
R5 g4784_5 3 2.224404
C11 4 gnd 2.080806f
R6 4 1 2.224404
C12 5 gnd 2.080806f
R7 5 4 2.224404
C13 6 gnd 2.080806f
R8 6 5 2.224404
R9 6 g4784_6 2.224404
C14 7 gnd 2.080806f
R10 7 g4784_6 2.224404
C15 8 gnd 2.080806f
R11 8 7 2.224404
C16 9 gnd 2.080806f
R12 8 9 2.224404
R13 9 g4784_2 2.224404
C17 10 gnd 2.080806f
R14 10 8 2.224404
R15 g4784_4 10 2.224404
C18 11 gnd 2.080806f
R16 11 g4784_5 2.224404
C19 12 gnd 2.080806f
R17 12 11 2.224404
C20 13 gnd 2.080806f
R18 13 12 2.224404
C21 14 gnd 2.080806f
R19 14 13 2.224404
C22 15 gnd 2.080806f
R20 15 14 2.224404
C23 16 gnd 2.080806f
R21 16 15 2.224404
C24 17 gnd 2.080806f
R22 17 16 2.224404
C25 18 gnd 2.080806f
R23 18 17 2.224404
C26 19 gnd 2.080806f
R24 19 18 2.224404
C27 20 gnd 2.080806f
R25 20 19 2.224404
C28 21 gnd 2.080806f
R26 21 20 2.224404
R27 g4784_3 21 2.224404
.ends

.subckt netg7496 g7496_1 g7496_0 gnd
C1  g7496_1 gnd 2.080806f
C2  g7496_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7496_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
R25 g7496_1 24 2.224404
.ends

.subckt netg1628 g1628_1 g1628_0 g1628_2 g1628_3 gnd
C1  g1628_1 gnd 2.080806f
C2  g1628_0 gnd 2.080806f
C3  g1628_2 gnd 2.080806f
C4  g1628_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1628_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
R6 g1628_1 5 2.224404
C10 6 gnd 2.080806f
R7 4 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 11 12 2.224404
R14 12 g1628_2 2.224404
C17 13 gnd 2.080806f
R15 13 1 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
C24 20 gnd 2.080806f
R22 20 19 2.224404
C25 21 gnd 2.080806f
R23 21 20 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 23 22 2.224404
C28 24 gnd 2.080806f
R26 24 23 2.224404
C29 25 gnd 2.080806f
R27 25 24 2.224404
C30 26 gnd 2.080806f
R28 26 25 2.224404
C31 27 gnd 2.080806f
R29 27 26 2.224404
R30 27 g1628_3 2.224404
.ends

.subckt netg1828 g1828_2 g1828_1 g1828_0 g1828_3 gnd
C1  g1828_2 gnd 2.080806f
C2  g1828_1 gnd 2.080806f
C3  g1828_0 gnd 2.080806f
C4  g1828_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1828_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
R8 g1828_1 7 2.224404
C12 8 gnd 2.080806f
R9 8 g1828_1 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
R15 g1828_3 13 2.224404
C18 14 gnd 2.080806f
R16 g1828_0 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
C24 20 gnd 2.080806f
R22 19 20 2.224404
C25 21 gnd 2.080806f
R23 20 21 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
C28 24 gnd 2.080806f
R26 23 24 2.224404
R27 24 g1828_2 2.224404
.ends

.subckt netg6234 g6234_0 g6234_1 g6234_2 gnd
C1  g6234_0 gnd 2.080806f
C2  g6234_1 gnd 2.080806f
C3  g6234_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6234_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
R21 g6234_1 20 2.224404
C24 21 gnd 2.080806f
R22 g6234_1 21 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
R25 g6234_2 23 2.224404
.ends

.subckt netg7494 g7494_1 g7494_0 gnd
C1  g7494_1 gnd 2.080806f
C2  g7494_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7494_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
R25 g7494_1 24 2.224404
.ends

.subckt netg721 g721_3 g721_0 g721_5 g721_1 g721_2 g721_4 gnd
C1  g721_3 gnd 2.080806f
C2  g721_0 gnd 2.080806f
C3  g721_5 gnd 2.080806f
C4  g721_1 gnd 2.080806f
C5  g721_2 gnd 2.080806f
C6  g721_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g721_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g721_4 2.224404
C9 3 gnd 2.080806f
R4 3 g721_0 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
C16 10 gnd 2.080806f
R11 10 9 2.224404
C17 11 gnd 2.080806f
R12 11 10 2.224404
C18 12 gnd 2.080806f
R13 12 11 2.224404
C19 13 gnd 2.080806f
R14 12 13 2.224404
C20 14 gnd 2.080806f
R15 14 13 2.224404
R16 g721_2 14 2.224404
C21 15 gnd 2.080806f
R17 15 g721_2 2.224404
C22 16 gnd 2.080806f
R18 16 15 2.224404
C23 17 gnd 2.080806f
R19 17 16 2.224404
C24 18 gnd 2.080806f
R20 18 17 2.224404
C25 19 gnd 2.080806f
R21 19 18 2.224404
C26 20 gnd 2.080806f
R22 20 19 2.224404
C27 21 gnd 2.080806f
R23 21 20 2.224404
C28 22 gnd 2.080806f
R24 22 21 2.224404
C29 23 gnd 2.080806f
R25 23 22 2.224404
R26 23 g721_5 2.224404
C30 24 gnd 2.080806f
R27 24 g721_5 2.224404
R28 g721_3 24 2.224404
R29 g721_1 g721_3 2.224404
.ends

.subckt netg3294 g3294_0 g3294_2 g3294_1 gnd
C1  g3294_0 gnd 2.080806f
C2  g3294_2 gnd 2.080806f
C3  g3294_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3294_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
R16 15 g3294_2 2.224404
C19 16 gnd 2.080806f
R17 g3294_2 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
R29 27 g3294_1 2.224404
.ends

.subckt netg43 g43_0 g43_1 gnd
C1  g43_0 gnd 2.080806f
C2  g43_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g43_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
R25 24 g43_1 2.224404
.ends

.subckt netg5185 g5185_2 g5185_1 g5185_0 gnd
C1  g5185_2 gnd 2.080806f
C2  g5185_1 gnd 2.080806f
C3  g5185_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5185_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5185_1 2.224404
C6 3 gnd 2.080806f
R4 3 g5185_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
R26 g5185_2 24 2.224404
.ends

.subckt netg3956 g3956_3 g3956_2 g3956_0 g3956_4 gnd
C1  g3956_3 gnd 2.080806f
C2  g3956_2 gnd 2.080806f
C3  g3956_0 gnd 2.080806f
C4  g3956_4 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g3956_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g3956_4 2.224404
R5 g3956_3 3 2.224404
C8 4 gnd 2.080806f
R6 4 g3956_0 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
C24 20 gnd 2.080806f
R22 20 19 2.224404
C25 21 gnd 2.080806f
R23 21 20 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 23 22 2.224404
C28 24 gnd 2.080806f
R26 24 23 2.224404
C29 25 gnd 2.080806f
R27 25 24 2.224404
C30 26 gnd 2.080806f
R28 26 25 2.224404
C31 27 gnd 2.080806f
R29 27 26 2.224404
R30 g3956_2 27 2.224404
.ends

.subckt netg512 g512_4 g512_3 g512_1 g512_0 gnd
C1  g512_4 gnd 2.080806f
C2  g512_3 gnd 2.080806f
C3  g512_1 gnd 2.080806f
C4  g512_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g512_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g512_1 2.224404
C7 3 gnd 2.080806f
R4 3 1 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
R13 g512_3 11 2.224404
C16 12 gnd 2.080806f
R14 g512_1 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
C24 20 gnd 2.080806f
R22 19 20 2.224404
C25 21 gnd 2.080806f
R23 20 21 2.224404
C26 22 gnd 2.080806f
R24 21 22 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
R26 23 g512_4 2.224404
.ends

.subckt netg7507 g7507_1 g7507_0 gnd
C1  g7507_1 gnd 2.080806f
C2  g7507_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7507_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
R25 24 g7507_1 2.224404
.ends

.subckt netg42 g42_1 g42_0 gnd
C1  g42_1 gnd 2.080806f
C2  g42_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g42_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
R26 g42_1 25 2.224404
.ends

.subckt netg7548 g7548_0 g7548_1 gnd
C1  g7548_0 gnd 2.080806f
C2  g7548_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7548_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
R26 25 g7548_1 2.224404
.ends

.subckt netg2111 g2111_3 g2111_0 g2111_2 g2111_1 gnd
C1  g2111_3 gnd 2.080806f
C2  g2111_0 gnd 2.080806f
C3  g2111_2 gnd 2.080806f
C4  g2111_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2111_0 1 2.224404
R2 g2111_2 1 2.224404
C6 2 gnd 2.080806f
R3 2 g2111_0 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
R5 3 g2111_3 2.224404
C8 4 gnd 2.080806f
R6 1 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
C24 20 gnd 2.080806f
R22 19 20 2.224404
C25 21 gnd 2.080806f
R23 20 21 2.224404
C26 22 gnd 2.080806f
R24 21 22 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
C28 24 gnd 2.080806f
R26 23 24 2.224404
R27 24 g2111_1 2.224404
.ends

.subckt netg55 g55_1 g55_0 gnd
C1  g55_1 gnd 2.080806f
C2  g55_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g55_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
R26 g55_1 25 2.224404
.ends

.subckt netg1862 g1862_2 g1862_1 g1862_0 gnd
C1  g1862_2 gnd 2.080806f
C2  g1862_1 gnd 2.080806f
C3  g1862_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1862_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
R25 24 g1862_1 2.224404
R26 g1862_1 g1862_2 2.224404
.ends

.subckt netg101 g101_0 g101_1 gnd
C1  g101_0 gnd 2.080806f
C2  g101_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g101_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
R26 g101_1 25 2.224404
.ends

.subckt netg3950 g3950_5 g3950_1 g3950_4 g3950_2 g3950_3 g3950_0 gnd
C1  g3950_5 gnd 2.080806f
C2  g3950_1 gnd 2.080806f
C3  g3950_4 gnd 2.080806f
C4  g3950_2 gnd 2.080806f
C5  g3950_3 gnd 2.080806f
C6  g3950_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g3950_0 2.224404
R2 g3950_5 1 2.224404
C8 2 gnd 2.080806f
R3 g3950_5 2 2.224404
R4 2 g3950_2 2.224404
C9 3 gnd 2.080806f
R5 3 g3950_5 2.224404
C10 4 gnd 2.080806f
R6 4 3 2.224404
C11 5 gnd 2.080806f
R7 5 4 2.224404
C12 6 gnd 2.080806f
R8 6 5 2.224404
C13 7 gnd 2.080806f
R9 7 6 2.224404
C14 8 gnd 2.080806f
R10 8 7 2.224404
C15 9 gnd 2.080806f
R11 9 8 2.224404
C16 10 gnd 2.080806f
R12 10 9 2.224404
C17 11 gnd 2.080806f
R13 11 10 2.224404
R14 g3950_1 11 2.224404
R15 g3950_3 g3950_1 2.224404
C18 12 gnd 2.080806f
R16 12 g3950_3 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
C21 15 gnd 2.080806f
R19 15 14 2.224404
C22 16 gnd 2.080806f
R20 16 15 2.224404
C23 17 gnd 2.080806f
R21 17 16 2.224404
C24 18 gnd 2.080806f
R22 18 17 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 21 20 2.224404
C28 22 gnd 2.080806f
R26 22 21 2.224404
C29 23 gnd 2.080806f
R27 23 22 2.224404
C30 24 gnd 2.080806f
R28 24 23 2.224404
R29 g3950_4 24 2.224404
.ends

.subckt netg1118 g1118_0 g1118_1 gnd
C1  g1118_0 gnd 2.080806f
C2  g1118_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g1118_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
R26 g1118_1 25 2.224404
.ends

.subckt netg640 g640_0 g640_3 g640_5 g640_1 g640_2 g640_4 gnd
C1  g640_0 gnd 2.080806f
C2  g640_3 gnd 2.080806f
C3  g640_5 gnd 2.080806f
C4  g640_1 gnd 2.080806f
C5  g640_2 gnd 2.080806f
C6  g640_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g640_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g640_1 2.224404
C10 4 gnd 2.080806f
R5 1 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g640_3 2.224404
C12 6 gnd 2.080806f
R8 g640_3 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 8 7 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
R12 g640_2 9 2.224404
C16 10 gnd 2.080806f
R13 10 g640_2 2.224404
C17 11 gnd 2.080806f
R14 11 10 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 13 12 2.224404
C20 14 gnd 2.080806f
R17 14 13 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 16 15 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 19 18 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
R24 g640_5 20 2.224404
C27 21 gnd 2.080806f
R25 g640_5 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
R27 22 g640_4 2.224404
.ends

.subckt netg7552 g7552_1 g7552_0 gnd
C1  g7552_1 gnd 2.080806f
C2  g7552_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7552_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
R26 25 g7552_1 2.224404
.ends

.subckt netg48 g48_0 g48_1 gnd
C1  g48_0 gnd 2.080806f
C2  g48_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g48_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
R26 25 g48_1 2.224404
.ends

.subckt netg111 g111_0 g111_1 gnd
C1  g111_0 gnd 2.080806f
C2  g111_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g111_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
R26 25 g111_1 2.224404
.ends

.subckt netg1178 g1178_6 g1178_3 g1178_4 g1178_0 g1178_5 g1178_2 g1178_1 gnd
C1  g1178_6 gnd 2.080806f
C2  g1178_3 gnd 2.080806f
C3  g1178_4 gnd 2.080806f
C4  g1178_0 gnd 2.080806f
C5  g1178_5 gnd 2.080806f
C6  g1178_2 gnd 2.080806f
C7  g1178_1 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g1178_0 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1178_1 2 2.224404
C10 3 gnd 2.080806f
R4 3 1 2.224404
C11 4 gnd 2.080806f
R5 4 3 2.224404
R6 g1178_4 4 2.224404
C12 5 gnd 2.080806f
R7 g1178_1 5 2.224404
C13 6 gnd 2.080806f
R8 6 5 2.224404
C14 7 gnd 2.080806f
R9 6 7 2.224404
R10 g1178_6 7 2.224404
C15 8 gnd 2.080806f
R11 5 8 2.224404
C16 9 gnd 2.080806f
R12 8 9 2.224404
C17 10 gnd 2.080806f
R13 9 10 2.224404
R14 10 g1178_3 2.224404
C18 11 gnd 2.080806f
R15 g1178_6 11 2.224404
C19 12 gnd 2.080806f
R16 12 11 2.224404
C20 13 gnd 2.080806f
R17 12 13 2.224404
C21 14 gnd 2.080806f
R18 13 14 2.224404
C22 15 gnd 2.080806f
R19 14 15 2.224404
C23 16 gnd 2.080806f
R20 16 15 2.224404
C24 17 gnd 2.080806f
R21 16 17 2.224404
R22 g1178_2 17 2.224404
C25 18 gnd 2.080806f
R23 18 g1178_6 2.224404
C26 19 gnd 2.080806f
R24 19 18 2.224404
C27 20 gnd 2.080806f
R25 20 19 2.224404
C28 21 gnd 2.080806f
R26 21 20 2.224404
C29 22 gnd 2.080806f
R27 22 21 2.224404
C30 23 gnd 2.080806f
R28 22 23 2.224404
C31 24 gnd 2.080806f
R29 24 23 2.224404
C32 25 gnd 2.080806f
R30 25 24 2.224404
C33 26 gnd 2.080806f
R31 26 25 2.224404
C34 27 gnd 2.080806f
R32 27 26 2.224404
C35 28 gnd 2.080806f
R33 28 27 2.224404
C36 29 gnd 2.080806f
R34 29 28 2.224404
C37 30 gnd 2.080806f
R35 30 29 2.224404
R36 30 g1178_5 2.224404
.ends

.subckt netg96 g96_0 g96_1 gnd
C1  g96_0 gnd 2.080806f
C2  g96_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g96_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
R26 25 g96_1 2.224404
.ends

.subckt netg2389 g2389_2 g2389_1 g2389_0 gnd
C1  g2389_2 gnd 2.080806f
C2  g2389_1 gnd 2.080806f
C3  g2389_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2389_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2389_2 2 2.224404
C6 3 gnd 2.080806f
R4 g2389_2 3 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
R26 g2389_1 24 2.224404
.ends

.subckt netg2288 g2288_1 g2288_3 g2288_0 g2288_2 gnd
C1  g2288_1 gnd 2.080806f
C2  g2288_3 gnd 2.080806f
C3  g2288_0 gnd 2.080806f
C4  g2288_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2288_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2288_3 2.224404
C8 4 gnd 2.080806f
R5 4 g2288_0 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
R13 g2288_1 11 2.224404
C16 12 gnd 2.080806f
R14 12 g2288_1 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
C24 20 gnd 2.080806f
R22 20 19 2.224404
C25 21 gnd 2.080806f
R23 21 20 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 23 22 2.224404
R26 g2288_2 23 2.224404
.ends

.subckt netg1824 g1824_0 g1824_1 g1824_2 g1824_3 gnd
C1  g1824_0 gnd 2.080806f
C2  g1824_1 gnd 2.080806f
C3  g1824_2 gnd 2.080806f
C4  g1824_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1824_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
R7 6 g1824_2 2.224404
C11 7 gnd 2.080806f
R8 g1824_2 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
C18 14 gnd 2.080806f
R15 13 14 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
R17 15 g1824_3 2.224404
C20 16 gnd 2.080806f
R18 g1824_3 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
C24 20 gnd 2.080806f
R22 19 20 2.224404
C25 21 gnd 2.080806f
R23 20 21 2.224404
C26 22 gnd 2.080806f
R24 21 22 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
C28 24 gnd 2.080806f
R26 23 24 2.224404
C29 25 gnd 2.080806f
R27 24 25 2.224404
C30 26 gnd 2.080806f
R28 25 26 2.224404
R29 26 g1824_1 2.224404
.ends

.subckt netg135 g135_0 g135_1 gnd
C1  g135_0 gnd 2.080806f
C2  g135_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g135_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
R27 26 g135_1 2.224404
.ends

.subckt netg5830 g5830_0 g5830_2 g5830_1 gnd
C1  g5830_0 gnd 2.080806f
C2  g5830_2 gnd 2.080806f
C3  g5830_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5830_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g5830_2 2.224404
C6 3 gnd 2.080806f
R4 g5830_2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
R27 25 g5830_1 2.224404
.ends

.subckt netg88 g88_1 g88_0 gnd
C1  g88_1 gnd 2.080806f
C2  g88_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g88_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
R27 g88_1 26 2.224404
.ends

.subckt netg2641 g2641_2 g2641_0 g2641_1 gnd
C1  g2641_2 gnd 2.080806f
C2  g2641_0 gnd 2.080806f
C3  g2641_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g2641_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2641_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 g2641_2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
R27 g2641_1 25 2.224404
.ends

.subckt netg5302 g5302_5 g5302_3 g5302_6 g5302_4 g5302_2 g5302_1 g5302_0 gnd
C1  g5302_5 gnd 2.080806f
C2  g5302_3 gnd 2.080806f
C3  g5302_6 gnd 2.080806f
C4  g5302_4 gnd 2.080806f
C5  g5302_2 gnd 2.080806f
C6  g5302_1 gnd 2.080806f
C7  g5302_0 gnd 2.080806f
R1 g5302_4 g5302_0 2.224404
R2 g5302_3 g5302_4 2.224404
C8 1 gnd 2.080806f
R3 1 g5302_3 2.224404
C9 2 gnd 2.080806f
R4 2 1 2.224404
R5 g5302_5 2 2.224404
C10 3 gnd 2.080806f
R6 3 g5302_5 2.224404
C11 4 gnd 2.080806f
R7 4 3 2.224404
R8 g5302_6 4 2.224404
C12 5 gnd 2.080806f
R9 5 g5302_6 2.224404
R10 g5302_1 5 2.224404
C13 6 gnd 2.080806f
R11 6 g5302_1 2.224404
C14 7 gnd 2.080806f
R12 7 6 2.224404
C15 8 gnd 2.080806f
R13 8 7 2.224404
C16 9 gnd 2.080806f
R14 8 9 2.224404
C17 10 gnd 2.080806f
R15 10 9 2.224404
C18 11 gnd 2.080806f
R16 11 10 2.224404
C19 12 gnd 2.080806f
R17 11 12 2.224404
C20 13 gnd 2.080806f
R18 13 12 2.224404
C21 14 gnd 2.080806f
R19 14 13 2.224404
C22 15 gnd 2.080806f
R20 14 15 2.224404
C23 16 gnd 2.080806f
R21 16 15 2.224404
C24 17 gnd 2.080806f
R22 17 16 2.224404
C25 18 gnd 2.080806f
R23 17 18 2.224404
C26 19 gnd 2.080806f
R24 19 18 2.224404
C27 20 gnd 2.080806f
R25 20 19 2.224404
C28 21 gnd 2.080806f
R26 21 20 2.224404
C29 22 gnd 2.080806f
R27 22 21 2.224404
R28 g5302_2 22 2.224404
.ends

.subckt netg136 g136_0 g136_1 gnd
C1  g136_0 gnd 2.080806f
C2  g136_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g136_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
R27 g136_1 26 2.224404
.ends

.subckt netg2692 g2692_1 g2692_2 gnd
C1  g2692_1 gnd 2.080806f
C2  g2692_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2692_2 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
R29 g2692_1 28 2.224404
.ends

.subckt netg3366 g3366_0 g3366_1 gnd
C1  g3366_0 gnd 2.080806f
C2  g3366_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g3366_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
R29 g3366_1 28 2.224404
.ends

.subckt netg7545 g7545_1 g7545_0 gnd
C1  g7545_1 gnd 2.080806f
C2  g7545_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7545_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
R27 26 g7545_1 2.224404
.ends

.subckt netg140 g140_1 g140_0 gnd
C1  g140_1 gnd 2.080806f
C2  g140_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g140_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
R27 26 g140_1 2.224404
.ends

.subckt netg1954 g1954_2 g1954_0 g1954_1 gnd
C1  g1954_2 gnd 2.080806f
C2  g1954_0 gnd 2.080806f
C3  g1954_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g1954_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
R27 g1954_2 26 2.224404
R28 g1954_1 g1954_2 2.224404
.ends

.subckt netg6564 g6564_0 g6564_1 gnd
C1  g6564_0 gnd 2.080806f
C2  g6564_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6564_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
R28 g6564_1 27 2.224404
.ends

.subckt netg7547 g7547_1 g7547_0 gnd
C1  g7547_1 gnd 2.080806f
C2  g7547_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7547_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
R28 27 g7547_1 2.224404
.ends

.subckt netg7546 g7546_1 g7546_0 gnd
C1  g7546_1 gnd 2.080806f
C2  g7546_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7546_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
R28 g7546_1 27 2.224404
.ends

.subckt netg142 g142_1 g142_0 gnd
C1  g142_1 gnd 2.080806f
C2  g142_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g142_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
R28 27 g142_1 2.224404
.ends

.subckt netg5569 g5569_1 g5569_0 g5569_2 gnd
C1  g5569_1 gnd 2.080806f
C2  g5569_0 gnd 2.080806f
C3  g5569_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5569_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
R27 26 g5569_1 2.224404
R28 g5569_1 g5569_2 2.224404
.ends

.subckt netg501 g501_2 g501_4 g501_1 g501_3 g501_5 gnd
C1  g501_2 gnd 2.080806f
C2  g501_4 gnd 2.080806f
C3  g501_1 gnd 2.080806f
C4  g501_3 gnd 2.080806f
C5  g501_5 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g501_5 2.224404
C7 2 gnd 2.080806f
R2 2 1 2.224404
C8 3 gnd 2.080806f
R3 3 2 2.224404
C9 4 gnd 2.080806f
R4 4 3 2.224404
R5 g501_2 4 2.224404
C10 5 gnd 2.080806f
R6 g501_5 5 2.224404
C11 6 gnd 2.080806f
R7 5 6 2.224404
C12 7 gnd 2.080806f
R8 6 7 2.224404
C13 8 gnd 2.080806f
R9 7 8 2.224404
C14 9 gnd 2.080806f
R10 8 9 2.224404
C15 10 gnd 2.080806f
R11 9 10 2.224404
C16 11 gnd 2.080806f
R12 10 11 2.224404
C17 12 gnd 2.080806f
R13 11 12 2.224404
C18 13 gnd 2.080806f
R14 12 13 2.224404
C19 14 gnd 2.080806f
R15 13 14 2.224404
C20 15 gnd 2.080806f
R16 14 15 2.224404
C21 16 gnd 2.080806f
R17 15 16 2.224404
R18 16 g501_1 2.224404
C22 17 gnd 2.080806f
R19 17 16 2.224404
C23 18 gnd 2.080806f
R20 18 17 2.224404
C24 19 gnd 2.080806f
R21 19 18 2.224404
C25 20 gnd 2.080806f
R22 20 19 2.224404
C26 21 gnd 2.080806f
R23 21 20 2.224404
C27 22 gnd 2.080806f
R24 22 21 2.224404
C28 23 gnd 2.080806f
R25 23 22 2.224404
C29 24 gnd 2.080806f
R26 24 23 2.224404
C30 25 gnd 2.080806f
R27 25 24 2.224404
C31 26 gnd 2.080806f
R28 26 25 2.224404
C32 27 gnd 2.080806f
R29 27 26 2.224404
R30 g501_3 27 2.224404
C33 28 gnd 2.080806f
R31 28 27 2.224404
C34 29 gnd 2.080806f
R32 29 28 2.224404
C35 30 gnd 2.080806f
R33 29 30 2.224404
C36 31 gnd 2.080806f
R34 30 31 2.224404
C37 32 gnd 2.080806f
R35 31 32 2.224404
C38 33 gnd 2.080806f
R36 32 33 2.224404
C39 34 gnd 2.080806f
R37 33 34 2.224404
C40 35 gnd 2.080806f
R38 34 35 2.224404
R39 35 g501_4 2.224404
.ends

.subckt netg33 g33_1 g33_0 gnd
C1  g33_1 gnd 2.080806f
C2  g33_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g33_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
R28 27 g33_1 2.224404
.ends

.subckt netg39 g39_0 g39_1 gnd
C1  g39_0 gnd 2.080806f
C2  g39_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g39_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
R28 27 g39_1 2.224404
.ends

.subckt netg137 g137_0 g137_1 gnd
C1  g137_0 gnd 2.080806f
C2  g137_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g137_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
R28 g137_1 27 2.224404
.ends

.subckt netg2292 g2292_3 g2292_1 g2292_2 g2292_0 gnd
C1  g2292_3 gnd 2.080806f
C2  g2292_1 gnd 2.080806f
C3  g2292_2 gnd 2.080806f
C4  g2292_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2292_0 1 2.224404
R2 1 g2292_1 2.224404
C6 2 gnd 2.080806f
R3 2 g2292_0 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
R11 g2292_3 9 2.224404
C14 10 gnd 2.080806f
R12 10 g2292_3 2.224404
C15 11 gnd 2.080806f
R13 11 10 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
C24 20 gnd 2.080806f
R22 20 19 2.224404
C25 21 gnd 2.080806f
R23 21 20 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 23 22 2.224404
C28 24 gnd 2.080806f
R26 24 23 2.224404
C29 25 gnd 2.080806f
R27 25 24 2.224404
R28 g2292_2 25 2.224404
.ends

.subckt netg6214 g6214_1 g6214_2 g6214_0 gnd
C1  g6214_1 gnd 2.080806f
C2  g6214_2 gnd 2.080806f
C3  g6214_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6214_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 3 g6214_2 2.224404
C7 4 gnd 2.080806f
R5 4 1 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
R28 g6214_1 26 2.224404
.ends

.subckt netg60 g60_1 g60_0 gnd
C1  g60_1 gnd 2.080806f
C2  g60_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g60_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
R28 g60_1 27 2.224404
.ends

.subckt netg538 g538_4 g538_2 g538_1 g538_3 g538_5 gnd
C1  g538_4 gnd 2.080806f
C2  g538_2 gnd 2.080806f
C3  g538_1 gnd 2.080806f
C4  g538_3 gnd 2.080806f
C5  g538_5 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g538_3 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
C8 3 gnd 2.080806f
R3 2 3 2.224404
C9 4 gnd 2.080806f
R4 3 4 2.224404
C10 5 gnd 2.080806f
R5 4 5 2.224404
C11 6 gnd 2.080806f
R6 5 6 2.224404
C12 7 gnd 2.080806f
R7 6 7 2.224404
C13 8 gnd 2.080806f
R8 7 8 2.224404
R9 8 g538_4 2.224404
C14 9 gnd 2.080806f
R10 9 g538_4 2.224404
C15 10 gnd 2.080806f
R11 10 9 2.224404
C16 11 gnd 2.080806f
R12 10 11 2.224404
C17 12 gnd 2.080806f
R13 11 12 2.224404
R14 12 g538_2 2.224404
C18 13 gnd 2.080806f
R15 g538_2 13 2.224404
C19 14 gnd 2.080806f
R16 13 14 2.224404
C20 15 gnd 2.080806f
R17 14 15 2.224404
C21 16 gnd 2.080806f
R18 15 16 2.224404
C22 17 gnd 2.080806f
R19 16 17 2.224404
C23 18 gnd 2.080806f
R20 17 18 2.224404
C24 19 gnd 2.080806f
R21 18 19 2.224404
C25 20 gnd 2.080806f
R22 19 20 2.224404
C26 21 gnd 2.080806f
R23 20 21 2.224404
C27 22 gnd 2.080806f
R24 21 22 2.224404
C28 23 gnd 2.080806f
R25 22 23 2.224404
C29 24 gnd 2.080806f
R26 23 24 2.224404
C30 25 gnd 2.080806f
R27 24 25 2.224404
R28 25 g538_5 2.224404
C31 26 gnd 2.080806f
R29 g538_5 26 2.224404
C32 27 gnd 2.080806f
R30 26 27 2.224404
C33 28 gnd 2.080806f
R31 27 28 2.224404
C34 29 gnd 2.080806f
R32 28 29 2.224404
C35 30 gnd 2.080806f
R33 29 30 2.224404
C36 31 gnd 2.080806f
R34 31 30 2.224404
R35 g538_1 31 2.224404
.ends

.subckt netg3601 g3601_9 g3601_8 g3601_7 g3601_15 g3601_4 g3601_14 g3601_12 g3601_2 g3601_5 g3601_11 g3601_10 g3601_0 g3601_3 g3601_1 g3601_13 g3601_6 gnd
C1  g3601_9 gnd 2.080806f
C2  g3601_8 gnd 2.080806f
C3  g3601_7 gnd 2.080806f
C4  g3601_15 gnd 2.080806f
C5  g3601_4 gnd 2.080806f
C6  g3601_14 gnd 2.080806f
C7  g3601_12 gnd 2.080806f
C8  g3601_2 gnd 2.080806f
C9  g3601_5 gnd 2.080806f
C10  g3601_11 gnd 2.080806f
C11  g3601_10 gnd 2.080806f
C12  g3601_0 gnd 2.080806f
C13  g3601_3 gnd 2.080806f
C14  g3601_1 gnd 2.080806f
C15  g3601_13 gnd 2.080806f
C16  g3601_6 gnd 2.080806f
C17 1 gnd 2.080806f
R1 g3601_0 1 2.224404
C18 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g3601_8 2.224404
R4 g3601_8 g3601_13 2.224404
C19 3 gnd 2.080806f
R5 3 g3601_8 2.224404
R6 g3601_11 3 2.224404
R7 g3601_11 g3601_3 2.224404
C20 4 gnd 2.080806f
R8 4 g3601_11 2.224404
R9 g3601_6 4 2.224404
C21 5 gnd 2.080806f
R10 5 g3601_13 2.224404
C22 6 gnd 2.080806f
R11 5 6 2.224404
R12 6 g3601_4 2.224404
C23 7 gnd 2.080806f
R13 7 g3601_4 2.224404
R14 7 g3601_10 2.224404
C24 8 gnd 2.080806f
R15 8 g3601_0 2.224404
C25 9 gnd 2.080806f
R16 9 8 2.224404
C26 10 gnd 2.080806f
R17 10 9 2.224404
R18 g3601_7 10 2.224404
C27 11 gnd 2.080806f
R19 g3601_8 11 2.224404
C28 12 gnd 2.080806f
R20 11 12 2.224404
C29 13 gnd 2.080806f
R21 12 13 2.224404
R22 13 g3601_2 2.224404
R23 g3601_9 g3601_2 2.224404
R24 g3601_2 g3601_14 2.224404
C30 14 gnd 2.080806f
R25 14 g3601_7 2.224404
C31 15 gnd 2.080806f
R26 14 15 2.224404
C32 16 gnd 2.080806f
R27 16 15 2.224404
C33 17 gnd 2.080806f
R28 16 17 2.224404
R29 g3601_5 17 2.224404
C34 18 gnd 2.080806f
R30 18 g3601_5 2.224404
C35 19 gnd 2.080806f
R31 19 18 2.224404
C36 20 gnd 2.080806f
R32 20 19 2.224404
C37 21 gnd 2.080806f
R33 21 20 2.224404
C38 22 gnd 2.080806f
R34 21 22 2.224404
R35 g3601_12 22 2.224404
C39 23 gnd 2.080806f
R36 g3601_12 23 2.224404
C40 24 gnd 2.080806f
R37 23 24 2.224404
C41 25 gnd 2.080806f
R38 24 25 2.224404
R39 g3601_15 25 2.224404
C42 26 gnd 2.080806f
R40 18 26 2.224404
C43 27 gnd 2.080806f
R41 26 27 2.224404
C44 28 gnd 2.080806f
R42 27 28 2.224404
C45 29 gnd 2.080806f
R43 28 29 2.224404
C46 30 gnd 2.080806f
R44 29 30 2.224404
C47 31 gnd 2.080806f
R45 30 31 2.224404
R46 31 g3601_1 2.224404
.ends

.subckt netg2412 g2412_2 g2412_1 g2412_0 gnd
C1  g2412_2 gnd 2.080806f
C2  g2412_1 gnd 2.080806f
C3  g2412_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2412_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g2412_1 2.224404
C6 3 gnd 2.080806f
R4 3 g2412_1 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
R36 34 g2412_2 2.224404
.ends

.subckt netg7491 g7491_1 g7491_0 gnd
C1  g7491_1 gnd 2.080806f
C2  g7491_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7491_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
R28 g7491_1 27 2.224404
.ends

.subckt netg3361 g3361_2 g3361_1 g3361_0 gnd
C1  g3361_2 gnd 2.080806f
C2  g3361_1 gnd 2.080806f
C3  g3361_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g3361_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
R21 g3361_2 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
R35 33 g3361_1 2.224404
.ends

.subckt netg2188 g2188_0 g2188_2 g2188_1 g2188_3 g2188_5 g2188_4 gnd
C1  g2188_0 gnd 2.080806f
C2  g2188_2 gnd 2.080806f
C3  g2188_1 gnd 2.080806f
C4  g2188_3 gnd 2.080806f
C5  g2188_5 gnd 2.080806f
C6  g2188_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2188_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
C10 4 gnd 2.080806f
R4 4 3 2.224404
R5 g2188_3 4 2.224404
C11 5 gnd 2.080806f
R6 3 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g2188_5 2.224404
C13 7 gnd 2.080806f
R9 g2188_5 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
R14 11 g2188_2 2.224404
C18 12 gnd 2.080806f
R15 12 g2188_0 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 14 13 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 17 16 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
R22 g2188_1 18 2.224404
C25 19 gnd 2.080806f
R23 g2188_2 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
C29 23 gnd 2.080806f
R27 22 23 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 24 25 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
C33 27 gnd 2.080806f
R31 26 27 2.224404
C34 28 gnd 2.080806f
R32 27 28 2.224404
C35 29 gnd 2.080806f
R33 28 29 2.224404
C36 30 gnd 2.080806f
R34 29 30 2.224404
C37 31 gnd 2.080806f
R35 30 31 2.224404
C38 32 gnd 2.080806f
R36 31 32 2.224404
R37 32 g2188_4 2.224404
.ends

.subckt netg4880 g4880_1 g4880_0 g4880_2 g4880_3 gnd
C1  g4880_1 gnd 2.080806f
C2  g4880_0 gnd 2.080806f
C3  g4880_2 gnd 2.080806f
C4  g4880_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g4880_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
R4 g4880_3 3 2.224404
R5 g4880_3 g4880_2 2.224404
C8 4 gnd 2.080806f
R6 g4880_0 4 2.224404
C9 5 gnd 2.080806f
R7 4 5 2.224404
C10 6 gnd 2.080806f
R8 5 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
C24 20 gnd 2.080806f
R22 19 20 2.224404
C25 21 gnd 2.080806f
R23 20 21 2.224404
C26 22 gnd 2.080806f
R24 21 22 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
C28 24 gnd 2.080806f
R26 23 24 2.224404
C29 25 gnd 2.080806f
R27 24 25 2.224404
C30 26 gnd 2.080806f
R28 25 26 2.224404
R29 26 g4880_1 2.224404
.ends

.subckt netg6067 g6067_0 g6067_1 gnd
C1  g6067_0 gnd 2.080806f
C2  g6067_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6067_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
R32 g6067_1 31 2.224404
.ends

.subckt netg1502 g1502_0 g1502_1 gnd
C1  g1502_0 gnd 2.080806f
C2  g1502_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g1502_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
R29 28 g1502_1 2.224404
.ends

.subckt netg40 g40_0 g40_1 gnd
C1  g40_0 gnd 2.080806f
C2  g40_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g40_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
R29 28 g40_1 2.224404
.ends

.subckt netg6406 g6406_0 g6406_1 gnd
C1  g6406_0 gnd 2.080806f
C2  g6406_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6406_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
R29 28 g6406_1 2.224404
.ends

.subckt netg4474 g4474_5 g4474_8 g4474_6 g4474_10 g4474_1 g4474_4 g4474_0 g4474_7 g4474_9 g4474_2 g4474_3 gnd
C1  g4474_5 gnd 2.080806f
C2  g4474_8 gnd 2.080806f
C3  g4474_6 gnd 2.080806f
C4  g4474_10 gnd 2.080806f
C5  g4474_1 gnd 2.080806f
C6  g4474_4 gnd 2.080806f
C7  g4474_0 gnd 2.080806f
C8  g4474_7 gnd 2.080806f
C9  g4474_9 gnd 2.080806f
C10  g4474_2 gnd 2.080806f
C11  g4474_3 gnd 2.080806f
C12 1 gnd 2.080806f
R1 1 g4474_0 2.224404
C13 2 gnd 2.080806f
R2 2 1 2.224404
C14 3 gnd 2.080806f
R3 3 2 2.224404
C15 4 gnd 2.080806f
R4 4 3 2.224404
C16 5 gnd 2.080806f
R5 5 4 2.224404
C17 6 gnd 2.080806f
R6 6 5 2.224404
C18 7 gnd 2.080806f
R7 7 6 2.224404
C19 8 gnd 2.080806f
R8 8 7 2.224404
C20 9 gnd 2.080806f
R9 9 8 2.224404
C21 10 gnd 2.080806f
R10 10 9 2.224404
C22 11 gnd 2.080806f
R11 11 10 2.224404
C23 12 gnd 2.080806f
R12 12 11 2.224404
C24 13 gnd 2.080806f
R13 13 12 2.224404
C25 14 gnd 2.080806f
R14 14 13 2.224404
C26 15 gnd 2.080806f
R15 15 14 2.224404
R16 g4474_3 15 2.224404
C27 16 gnd 2.080806f
R17 16 g4474_3 2.224404
C28 17 gnd 2.080806f
R18 17 16 2.224404
R19 g4474_5 17 2.224404
R20 g4474_8 g4474_5 2.224404
R21 g4474_9 g4474_8 2.224404
R22 g4474_1 g4474_9 2.224404
C29 18 gnd 2.080806f
R23 18 g4474_9 2.224404
C30 19 gnd 2.080806f
R24 19 18 2.224404
R25 g4474_10 19 2.224404
C31 20 gnd 2.080806f
R26 20 g4474_1 2.224404
C32 21 gnd 2.080806f
R27 21 20 2.224404
R28 g4474_2 21 2.224404
C33 22 gnd 2.080806f
R29 g4474_2 22 2.224404
R30 g4474_4 22 2.224404
C34 23 gnd 2.080806f
R31 23 g4474_4 2.224404
C35 24 gnd 2.080806f
R32 23 24 2.224404
R33 g4474_6 24 2.224404
C36 25 gnd 2.080806f
R34 25 g4474_10 2.224404
C37 26 gnd 2.080806f
R35 25 26 2.224404
C38 27 gnd 2.080806f
R36 26 27 2.224404
C39 28 gnd 2.080806f
R37 27 28 2.224404
R38 28 g4474_7 2.224404
.ends

.subckt netg621 g621_2 g621_4 g621_6 g621_3 g621_1 g621_5 gnd
C1  g621_2 gnd 2.080806f
C2  g621_4 gnd 2.080806f
C3  g621_6 gnd 2.080806f
C4  g621_3 gnd 2.080806f
C5  g621_1 gnd 2.080806f
C6  g621_5 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g621_1 2.224404
R2 g621_4 1 2.224404
C8 2 gnd 2.080806f
R3 2 g621_4 2.224404
R4 g621_5 2 2.224404
C9 3 gnd 2.080806f
R5 3 g621_5 2.224404
C10 4 gnd 2.080806f
R6 4 3 2.224404
R7 g621_2 4 2.224404
C11 5 gnd 2.080806f
R8 3 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
R14 10 g621_6 2.224404
C17 11 gnd 2.080806f
R15 g621_6 11 2.224404
C18 12 gnd 2.080806f
R16 11 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
C21 15 gnd 2.080806f
R19 14 15 2.224404
C22 16 gnd 2.080806f
R20 15 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
C29 23 gnd 2.080806f
R27 22 23 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 25 24 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
R31 g621_3 26 2.224404
.ends

.subckt netg57 g57_1 g57_0 gnd
C1  g57_1 gnd 2.080806f
C2  g57_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g57_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
R29 g57_1 28 2.224404
.ends

.subckt netg122 g122_1 g122_0 gnd
C1  g122_1 gnd 2.080806f
C2  g122_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g122_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
R30 g122_1 29 2.224404
.ends

.subckt netg7492 g7492_0 g7492_1 gnd
C1  g7492_0 gnd 2.080806f
C2  g7492_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7492_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
R30 g7492_1 29 2.224404
.ends

.subckt netg1185 g1185_6 g1185_5 g1185_1 g1185_4 g1185_2 g1185_3 g1185_0 gnd
C1  g1185_6 gnd 2.080806f
C2  g1185_5 gnd 2.080806f
C3  g1185_1 gnd 2.080806f
C4  g1185_4 gnd 2.080806f
C5  g1185_2 gnd 2.080806f
C6  g1185_3 gnd 2.080806f
C7  g1185_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g1185_0 2.224404
R2 g1185_2 1 2.224404
C9 2 gnd 2.080806f
R3 g1185_0 2 2.224404
C10 3 gnd 2.080806f
R4 2 3 2.224404
C11 4 gnd 2.080806f
R5 3 4 2.224404
C12 5 gnd 2.080806f
R6 4 5 2.224404
C13 6 gnd 2.080806f
R7 5 6 2.224404
C14 7 gnd 2.080806f
R8 6 7 2.224404
C15 8 gnd 2.080806f
R9 7 8 2.224404
R10 8 g1185_4 2.224404
C16 9 gnd 2.080806f
R11 g1185_4 9 2.224404
C17 10 gnd 2.080806f
R12 9 10 2.224404
C18 11 gnd 2.080806f
R13 10 11 2.224404
C19 12 gnd 2.080806f
R14 11 12 2.224404
C20 13 gnd 2.080806f
R15 12 13 2.224404
C21 14 gnd 2.080806f
R16 13 14 2.224404
C22 15 gnd 2.080806f
R17 14 15 2.224404
C23 16 gnd 2.080806f
R18 15 16 2.224404
C24 17 gnd 2.080806f
R19 16 17 2.224404
C25 18 gnd 2.080806f
R20 17 18 2.224404
R21 18 g1185_6 2.224404
C26 19 gnd 2.080806f
R22 g1185_6 19 2.224404
C27 20 gnd 2.080806f
R23 19 20 2.224404
C28 21 gnd 2.080806f
R24 20 21 2.224404
R25 21 g1185_5 2.224404
C29 22 gnd 2.080806f
R26 22 g1185_5 2.224404
C30 23 gnd 2.080806f
R27 23 22 2.224404
C31 24 gnd 2.080806f
R28 23 24 2.224404
R29 g1185_3 24 2.224404
C32 25 gnd 2.080806f
R30 21 25 2.224404
C33 26 gnd 2.080806f
R31 25 26 2.224404
C34 27 gnd 2.080806f
R32 26 27 2.224404
R33 27 g1185_1 2.224404
.ends

.subckt netg6064 g6064_1 g6064_0 gnd
C1  g6064_1 gnd 2.080806f
C2  g6064_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6064_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
R34 g6064_1 33 2.224404
.ends

.subckt netg3754 g3754_5 g3754_2 g3754_12 g3754_10 g3754_4 g3754_9 g3754_6 g3754_13 g3754_3 g3754_7 g3754_11 g3754_8 g3754_0 g3754_1 gnd
C1  g3754_5 gnd 2.080806f
C2  g3754_2 gnd 2.080806f
C3  g3754_12 gnd 2.080806f
C4  g3754_10 gnd 2.080806f
C5  g3754_4 gnd 2.080806f
C6  g3754_9 gnd 2.080806f
C7  g3754_6 gnd 2.080806f
C8  g3754_13 gnd 2.080806f
C9  g3754_3 gnd 2.080806f
C10  g3754_7 gnd 2.080806f
C11  g3754_11 gnd 2.080806f
C12  g3754_8 gnd 2.080806f
C13  g3754_0 gnd 2.080806f
C14  g3754_1 gnd 2.080806f
C15 1 gnd 2.080806f
R1 1 g3754_0 2.224404
R2 g3754_5 1 2.224404
C16 2 gnd 2.080806f
R3 g3754_0 2 2.224404
C17 3 gnd 2.080806f
R4 2 3 2.224404
C18 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g3754_11 2.224404
C19 5 gnd 2.080806f
R7 g3754_11 5 2.224404
C20 6 gnd 2.080806f
R8 5 6 2.224404
C21 7 gnd 2.080806f
R9 6 7 2.224404
C22 8 gnd 2.080806f
R10 7 8 2.224404
C23 9 gnd 2.080806f
R11 8 9 2.224404
C24 10 gnd 2.080806f
R12 9 10 2.224404
C25 11 gnd 2.080806f
R13 10 11 2.224404
R14 11 g3754_9 2.224404
C26 12 gnd 2.080806f
R15 g3754_9 12 2.224404
R16 12 g3754_7 2.224404
C27 13 gnd 2.080806f
R17 13 g3754_7 2.224404
R18 g3754_2 13 2.224404
R19 g3754_2 g3754_10 2.224404
C28 14 gnd 2.080806f
R20 14 g3754_2 2.224404
C29 15 gnd 2.080806f
R21 15 14 2.224404
R22 g3754_1 15 2.224404
C30 16 gnd 2.080806f
R23 g3754_10 16 2.224404
C31 17 gnd 2.080806f
R24 16 17 2.224404
C32 18 gnd 2.080806f
R25 17 18 2.224404
R26 18 g3754_4 2.224404
C33 19 gnd 2.080806f
R27 19 g3754_4 2.224404
R28 g3754_6 19 2.224404
C34 20 gnd 2.080806f
R29 20 g3754_6 2.224404
R30 g3754_13 20 2.224404
C35 21 gnd 2.080806f
R31 21 g3754_13 2.224404
C36 22 gnd 2.080806f
R32 22 21 2.224404
C37 23 gnd 2.080806f
R33 23 22 2.224404
R34 g3754_8 23 2.224404
C38 24 gnd 2.080806f
R35 24 g3754_8 2.224404
C39 25 gnd 2.080806f
R36 25 24 2.224404
R37 g3754_12 25 2.224404
C40 26 gnd 2.080806f
R38 26 g3754_6 2.224404
C41 27 gnd 2.080806f
R39 27 26 2.224404
C42 28 gnd 2.080806f
R40 28 27 2.224404
C43 29 gnd 2.080806f
R41 28 29 2.224404
C44 30 gnd 2.080806f
R42 29 30 2.224404
C45 31 gnd 2.080806f
R43 31 30 2.224404
C46 32 gnd 2.080806f
R44 31 32 2.224404
C47 33 gnd 2.080806f
R45 32 33 2.224404
R46 33 g3754_3 2.224404
.ends

.subckt netg6056 g6056_4 g6056_0 g6056_2 g6056_5 g6056_1 g6056_6 g6056_3 gnd
C1  g6056_4 gnd 2.080806f
C2  g6056_0 gnd 2.080806f
C3  g6056_2 gnd 2.080806f
C4  g6056_5 gnd 2.080806f
C5  g6056_1 gnd 2.080806f
C6  g6056_6 gnd 2.080806f
C7  g6056_3 gnd 2.080806f
R1 g6056_1 g6056_0 2.224404
R2 g6056_0 g6056_3 2.224404
R3 g6056_0 g6056_6 2.224404
R4 g6056_3 g6056_2 2.224404
C8 1 gnd 2.080806f
R5 g6056_6 1 2.224404
R6 1 g6056_4 2.224404
C9 2 gnd 2.080806f
R7 g6056_4 2 2.224404
C10 3 gnd 2.080806f
R8 2 3 2.224404
C11 4 gnd 2.080806f
R9 3 4 2.224404
C12 5 gnd 2.080806f
R10 4 5 2.224404
C13 6 gnd 2.080806f
R11 5 6 2.224404
C14 7 gnd 2.080806f
R12 6 7 2.224404
C15 8 gnd 2.080806f
R13 7 8 2.224404
C16 9 gnd 2.080806f
R14 9 8 2.224404
C17 10 gnd 2.080806f
R15 10 9 2.224404
C18 11 gnd 2.080806f
R16 10 11 2.224404
C19 12 gnd 2.080806f
R17 11 12 2.224404
C20 13 gnd 2.080806f
R18 12 13 2.224404
C21 14 gnd 2.080806f
R19 13 14 2.224404
C22 15 gnd 2.080806f
R20 15 14 2.224404
C23 16 gnd 2.080806f
R21 16 15 2.224404
C24 17 gnd 2.080806f
R22 16 17 2.224404
C25 18 gnd 2.080806f
R23 18 17 2.224404
C26 19 gnd 2.080806f
R24 19 18 2.224404
C27 20 gnd 2.080806f
R25 20 19 2.224404
C28 21 gnd 2.080806f
R26 20 21 2.224404
C29 22 gnd 2.080806f
R27 21 22 2.224404
C30 23 gnd 2.080806f
R28 23 22 2.224404
C31 24 gnd 2.080806f
R29 23 24 2.224404
C32 25 gnd 2.080806f
R30 24 25 2.224404
R31 25 g6056_5 2.224404
.ends

.subckt netg391 g391_1 g391_0 g391_2 gnd
C1  g391_1 gnd 2.080806f
C2  g391_0 gnd 2.080806f
C3  g391_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g391_0 2.224404
R2 g391_1 1 2.224404
C5 2 gnd 2.080806f
R3 g391_1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
R30 g391_2 28 2.224404
.ends

.subckt netg2802 g2802_0 g2802_1 gnd
C1  g2802_0 gnd 2.080806f
C2  g2802_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2802_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
R36 g2802_1 35 2.224404
.ends

.subckt netg2794 g2794_1 g2794_0 gnd
C1  g2794_1 gnd 2.080806f
C2  g2794_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2794_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
R30 g2794_1 29 2.224404
.ends

.subckt netg5499 g5499_0 g5499_1 g5499_2 gnd
C1  g5499_0 gnd 2.080806f
C2  g5499_1 gnd 2.080806f
C3  g5499_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g5499_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5499_2 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
R34 32 g5499_1 2.224404
.ends

.subckt netg4359 g4359_1 g4359_2 g4359_0 gnd
C1  g4359_1 gnd 2.080806f
C2  g4359_2 gnd 2.080806f
C3  g4359_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4359_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
R8 g4359_1 7 2.224404
C11 8 gnd 2.080806f
R9 8 1 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
R31 29 g4359_2 2.224404
.ends

.subckt netg646 g646_3 g646_4 g646_0 g646_5 g646_2 g646_1 gnd
C1  g646_3 gnd 2.080806f
C2  g646_4 gnd 2.080806f
C3  g646_0 gnd 2.080806f
C4  g646_5 gnd 2.080806f
C5  g646_2 gnd 2.080806f
C6  g646_1 gnd 2.080806f
R1 g646_1 g646_0 2.224404
C7 1 gnd 2.080806f
R2 1 g646_1 2.224404
C8 2 gnd 2.080806f
R3 2 1 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
R9 g646_3 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
R14 11 g646_4 2.224404
C18 12 gnd 2.080806f
R15 12 9 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 14 13 2.224404
C21 15 gnd 2.080806f
R18 15 14 2.224404
C22 16 gnd 2.080806f
R19 16 15 2.224404
C23 17 gnd 2.080806f
R20 17 16 2.224404
C24 18 gnd 2.080806f
R21 18 17 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
R23 g646_5 19 2.224404
C26 20 gnd 2.080806f
R24 g646_5 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 22 21 2.224404
C29 23 gnd 2.080806f
R27 23 22 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 25 24 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
C33 27 gnd 2.080806f
R31 26 27 2.224404
C34 28 gnd 2.080806f
R32 28 27 2.224404
C35 29 gnd 2.080806f
R33 28 29 2.224404
R34 g646_2 29 2.224404
.ends

.subckt netg2300 g2300_0 g2300_2 g2300_3 g2300_1 gnd
C1  g2300_0 gnd 2.080806f
C2  g2300_2 gnd 2.080806f
C3  g2300_3 gnd 2.080806f
C4  g2300_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2300_0 2.224404
R2 1 g2300_2 2.224404
C6 2 gnd 2.080806f
R3 2 1 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 15 14 2.224404
C20 16 gnd 2.080806f
R17 16 15 2.224404
R18 g2300_3 16 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
C24 20 gnd 2.080806f
R22 20 19 2.224404
C25 21 gnd 2.080806f
R23 21 20 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 23 22 2.224404
C28 24 gnd 2.080806f
R26 24 23 2.224404
C29 25 gnd 2.080806f
R27 25 24 2.224404
C30 26 gnd 2.080806f
R28 26 25 2.224404
C31 27 gnd 2.080806f
R29 27 26 2.224404
C32 28 gnd 2.080806f
R30 28 27 2.224404
C33 29 gnd 2.080806f
R31 29 28 2.224404
R32 g2300_1 29 2.224404
.ends

.subckt netg4876 g4876_3 g4876_1 g4876_0 g4876_2 gnd
C1  g4876_3 gnd 2.080806f
C2  g4876_1 gnd 2.080806f
C3  g4876_0 gnd 2.080806f
C4  g4876_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g4876_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
C14 10 gnd 2.080806f
R10 10 9 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
C16 12 gnd 2.080806f
R12 12 11 2.224404
C17 13 gnd 2.080806f
R13 13 12 2.224404
C18 14 gnd 2.080806f
R14 14 13 2.224404
C19 15 gnd 2.080806f
R15 15 14 2.224404
C20 16 gnd 2.080806f
R16 16 15 2.224404
C21 17 gnd 2.080806f
R17 17 16 2.224404
C22 18 gnd 2.080806f
R18 18 17 2.224404
C23 19 gnd 2.080806f
R19 19 18 2.224404
C24 20 gnd 2.080806f
R20 20 19 2.224404
C25 21 gnd 2.080806f
R21 21 20 2.224404
C26 22 gnd 2.080806f
R22 22 21 2.224404
C27 23 gnd 2.080806f
R23 23 22 2.224404
R24 g4876_2 23 2.224404
C28 24 gnd 2.080806f
R25 24 21 2.224404
C29 25 gnd 2.080806f
R26 25 24 2.224404
C30 26 gnd 2.080806f
R27 26 25 2.224404
C31 27 gnd 2.080806f
R28 27 26 2.224404
C32 28 gnd 2.080806f
R29 28 27 2.224404
C33 29 gnd 2.080806f
R30 29 28 2.224404
C34 30 gnd 2.080806f
R31 30 29 2.224404
C35 31 gnd 2.080806f
R32 31 30 2.224404
R33 g4876_3 31 2.224404
C36 32 gnd 2.080806f
R34 31 32 2.224404
R35 g4876_1 32 2.224404
.ends

.subckt netg450 g450_4 g450_0 g450_3 g450_1 g450_2 gnd
C1  g450_4 gnd 2.080806f
C2  g450_0 gnd 2.080806f
C3  g450_3 gnd 2.080806f
C4  g450_1 gnd 2.080806f
C5  g450_2 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g450_0 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
C8 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g450_4 2.224404
C9 4 gnd 2.080806f
R5 g450_0 4 2.224404
C10 5 gnd 2.080806f
R6 4 5 2.224404
C11 6 gnd 2.080806f
R7 5 6 2.224404
C12 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g450_2 2.224404
C13 8 gnd 2.080806f
R10 g450_2 8 2.224404
C14 9 gnd 2.080806f
R11 8 9 2.224404
C15 10 gnd 2.080806f
R12 9 10 2.224404
C16 11 gnd 2.080806f
R13 10 11 2.224404
R14 11 g450_3 2.224404
C17 12 gnd 2.080806f
R15 12 g450_0 2.224404
C18 13 gnd 2.080806f
R16 13 12 2.224404
C19 14 gnd 2.080806f
R17 14 13 2.224404
C20 15 gnd 2.080806f
R18 15 14 2.224404
C21 16 gnd 2.080806f
R19 16 15 2.224404
C22 17 gnd 2.080806f
R20 17 16 2.224404
C23 18 gnd 2.080806f
R21 18 17 2.224404
C24 19 gnd 2.080806f
R22 19 18 2.224404
C25 20 gnd 2.080806f
R23 20 19 2.224404
C26 21 gnd 2.080806f
R24 21 20 2.224404
C27 22 gnd 2.080806f
R25 22 21 2.224404
C28 23 gnd 2.080806f
R26 23 22 2.224404
C29 24 gnd 2.080806f
R27 24 23 2.224404
C30 25 gnd 2.080806f
R28 25 24 2.224404
C31 26 gnd 2.080806f
R29 26 25 2.224404
C32 27 gnd 2.080806f
R30 27 26 2.224404
C33 28 gnd 2.080806f
R31 28 27 2.224404
C34 29 gnd 2.080806f
R32 29 28 2.224404
C35 30 gnd 2.080806f
R33 30 29 2.224404
C36 31 gnd 2.080806f
R34 31 30 2.224404
R35 g450_1 31 2.224404
.ends

.subckt netg2296 g2296_3 g2296_2 g2296_1 g2296_0 gnd
C1  g2296_3 gnd 2.080806f
C2  g2296_2 gnd 2.080806f
C3  g2296_1 gnd 2.080806f
C4  g2296_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2296_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
C11 7 gnd 2.080806f
R7 6 7 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
R9 8 g2296_1 2.224404
C13 9 gnd 2.080806f
R10 g2296_1 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 11 12 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
C18 14 gnd 2.080806f
R15 13 14 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
C20 16 gnd 2.080806f
R17 15 16 2.224404
C21 17 gnd 2.080806f
R18 16 17 2.224404
C22 18 gnd 2.080806f
R19 17 18 2.224404
C23 19 gnd 2.080806f
R20 18 19 2.224404
C24 20 gnd 2.080806f
R21 19 20 2.224404
C25 21 gnd 2.080806f
R22 20 21 2.224404
C26 22 gnd 2.080806f
R23 21 22 2.224404
C27 23 gnd 2.080806f
R24 22 23 2.224404
C28 24 gnd 2.080806f
R25 23 24 2.224404
C29 25 gnd 2.080806f
R26 24 25 2.224404
C30 26 gnd 2.080806f
R27 25 26 2.224404
C31 27 gnd 2.080806f
R28 26 27 2.224404
C32 28 gnd 2.080806f
R29 27 28 2.224404
C33 29 gnd 2.080806f
R30 28 29 2.224404
C34 30 gnd 2.080806f
R31 29 30 2.224404
R32 30 g2296_2 2.224404
C35 31 gnd 2.080806f
R33 31 g2296_2 2.224404
R34 31 g2296_3 2.224404
.ends

.subckt netg1832 g1832_1 g1832_3 g1832_0 g1832_2 gnd
C1  g1832_1 gnd 2.080806f
C2  g1832_3 gnd 2.080806f
C3  g1832_0 gnd 2.080806f
C4  g1832_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1832_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
R8 g1832_1 7 2.224404
C12 8 gnd 2.080806f
R9 g1832_1 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 11 12 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 13 14 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
C20 16 gnd 2.080806f
R17 15 16 2.224404
R18 g1832_2 16 2.224404
C21 17 gnd 2.080806f
R19 17 g1832_2 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
C24 20 gnd 2.080806f
R22 20 19 2.224404
C25 21 gnd 2.080806f
R23 21 20 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 23 22 2.224404
C28 24 gnd 2.080806f
R26 24 23 2.224404
C29 25 gnd 2.080806f
R27 25 24 2.224404
C30 26 gnd 2.080806f
R28 26 25 2.224404
C31 27 gnd 2.080806f
R29 27 26 2.224404
C32 28 gnd 2.080806f
R30 28 27 2.224404
C33 29 gnd 2.080806f
R31 29 28 2.224404
C34 30 gnd 2.080806f
R32 30 29 2.224404
C35 31 gnd 2.080806f
R33 31 30 2.224404
C36 32 gnd 2.080806f
R34 32 31 2.224404
C37 33 gnd 2.080806f
R35 33 32 2.224404
C38 34 gnd 2.080806f
R36 34 33 2.224404
R37 g1832_3 34 2.224404
.ends

.subckt netg3852 g3852_3 g3852_2 g3852_8 g3852_9 g3852_0 g3852_5 g3852_7 g3852_1 g3852_6 g3852_4 gnd
C1  g3852_3 gnd 2.080806f
C2  g3852_2 gnd 2.080806f
C3  g3852_8 gnd 2.080806f
C4  g3852_9 gnd 2.080806f
C5  g3852_0 gnd 2.080806f
C6  g3852_5 gnd 2.080806f
C7  g3852_7 gnd 2.080806f
C8  g3852_1 gnd 2.080806f
C9  g3852_6 gnd 2.080806f
C10  g3852_4 gnd 2.080806f
C11 1 gnd 2.080806f
R1 1 g3852_0 2.224404
R2 1 g3852_1 2.224404
C12 2 gnd 2.080806f
R3 g3852_0 2 2.224404
R4 2 g3852_2 2.224404
C13 3 gnd 2.080806f
R5 g3852_1 3 2.224404
R6 3 g3852_8 2.224404
C14 4 gnd 2.080806f
R7 g3852_8 4 2.224404
C15 5 gnd 2.080806f
R8 4 5 2.224404
R9 5 g3852_4 2.224404
C16 6 gnd 2.080806f
R10 6 2 2.224404
C17 7 gnd 2.080806f
R11 7 6 2.224404
R12 g3852_3 7 2.224404
C18 8 gnd 2.080806f
R13 8 g3852_3 2.224404
R14 g3852_7 8 2.224404
C19 9 gnd 2.080806f
R15 9 g3852_7 2.224404
C20 10 gnd 2.080806f
R16 10 9 2.224404
C21 11 gnd 2.080806f
R17 10 11 2.224404
R18 g3852_9 11 2.224404
C22 12 gnd 2.080806f
R19 g3852_4 12 2.224404
C23 13 gnd 2.080806f
R20 12 13 2.224404
C24 14 gnd 2.080806f
R21 14 13 2.224404
C25 15 gnd 2.080806f
R22 14 15 2.224404
C26 16 gnd 2.080806f
R23 15 16 2.224404
C27 17 gnd 2.080806f
R24 16 17 2.224404
R25 17 g3852_5 2.224404
C28 18 gnd 2.080806f
R26 g3852_5 18 2.224404
C29 19 gnd 2.080806f
R27 18 19 2.224404
C30 20 gnd 2.080806f
R28 19 20 2.224404
C31 21 gnd 2.080806f
R29 20 21 2.224404
C32 22 gnd 2.080806f
R30 21 22 2.224404
C33 23 gnd 2.080806f
R31 22 23 2.224404
C34 24 gnd 2.080806f
R32 23 24 2.224404
C35 25 gnd 2.080806f
R33 24 25 2.224404
C36 26 gnd 2.080806f
R34 25 26 2.224404
C37 27 gnd 2.080806f
R35 26 27 2.224404
C38 28 gnd 2.080806f
R36 28 27 2.224404
C39 29 gnd 2.080806f
R37 28 29 2.224404
C40 30 gnd 2.080806f
R38 29 30 2.224404
C41 31 gnd 2.080806f
R39 30 31 2.224404
R40 31 g3852_6 2.224404
.ends

.subckt netg494 g494_5 g494_4 g494_3 g494_1 g494_2 g494_0 gnd
C1  g494_5 gnd 2.080806f
C2  g494_4 gnd 2.080806f
C3  g494_3 gnd 2.080806f
C4  g494_1 gnd 2.080806f
C5  g494_2 gnd 2.080806f
C6  g494_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g494_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
C10 4 gnd 2.080806f
R4 3 4 2.224404
C11 5 gnd 2.080806f
R5 4 5 2.224404
C12 6 gnd 2.080806f
R6 5 6 2.224404
C13 7 gnd 2.080806f
R7 6 7 2.224404
C14 8 gnd 2.080806f
R8 7 8 2.224404
C15 9 gnd 2.080806f
R9 8 9 2.224404
C16 10 gnd 2.080806f
R10 9 10 2.224404
R11 10 g494_1 2.224404
C17 11 gnd 2.080806f
R12 g494_1 11 2.224404
C18 12 gnd 2.080806f
R13 11 12 2.224404
C19 13 gnd 2.080806f
R14 12 13 2.224404
R15 13 g494_4 2.224404
C20 14 gnd 2.080806f
R16 13 14 2.224404
C21 15 gnd 2.080806f
R17 14 15 2.224404
C22 16 gnd 2.080806f
R18 15 16 2.224404
C23 17 gnd 2.080806f
R19 16 17 2.224404
R20 17 g494_2 2.224404
C24 18 gnd 2.080806f
R21 18 8 2.224404
C25 19 gnd 2.080806f
R22 19 18 2.224404
C26 20 gnd 2.080806f
R23 20 19 2.224404
C27 21 gnd 2.080806f
R24 21 20 2.224404
C28 22 gnd 2.080806f
R25 22 21 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
R27 23 g494_5 2.224404
C30 24 gnd 2.080806f
R28 g494_2 24 2.224404
C31 25 gnd 2.080806f
R29 24 25 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
C33 27 gnd 2.080806f
R31 26 27 2.224404
C34 28 gnd 2.080806f
R32 27 28 2.224404
C35 29 gnd 2.080806f
R33 28 29 2.224404
C36 30 gnd 2.080806f
R34 29 30 2.224404
C37 31 gnd 2.080806f
R35 30 31 2.224404
R36 31 g494_3 2.224404
.ends

.subckt netg4377 g4377_0 g4377_2 g4377_1 gnd
C1  g4377_0 gnd 2.080806f
C2  g4377_2 gnd 2.080806f
C3  g4377_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g4377_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
R17 g4377_1 16 2.224404
C20 17 gnd 2.080806f
R18 1 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
R34 32 g4377_2 2.224404
.ends

.subckt netg6203 g6203_0 g6203_1 gnd
C1  g6203_0 gnd 2.080806f
C2  g6203_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g6203_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
R35 g6203_1 34 2.224404
.ends

.subckt netg1612 g1612_2 g1612_1 g1612_0 g1612_3 gnd
C1  g1612_2 gnd 2.080806f
C2  g1612_1 gnd 2.080806f
C3  g1612_0 gnd 2.080806f
C4  g1612_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g1612_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
R7 g1612_3 6 2.224404
C11 7 gnd 2.080806f
R8 7 g1612_3 2.224404
R9 7 g1612_1 2.224404
C12 8 gnd 2.080806f
R10 1 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
C24 20 gnd 2.080806f
R22 19 20 2.224404
C25 21 gnd 2.080806f
R23 20 21 2.224404
C26 22 gnd 2.080806f
R24 21 22 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
C28 24 gnd 2.080806f
R26 23 24 2.224404
C29 25 gnd 2.080806f
R27 24 25 2.224404
C30 26 gnd 2.080806f
R28 25 26 2.224404
C31 27 gnd 2.080806f
R29 26 27 2.224404
C32 28 gnd 2.080806f
R30 27 28 2.224404
C33 29 gnd 2.080806f
R31 28 29 2.224404
C34 30 gnd 2.080806f
R32 29 30 2.224404
C35 31 gnd 2.080806f
R33 30 31 2.224404
C36 32 gnd 2.080806f
R34 31 32 2.224404
R35 32 g1612_2 2.224404
.ends

.subckt netg1604 g1604_3 g1604_0 g1604_2 g1604_1 gnd
C1  g1604_3 gnd 2.080806f
C2  g1604_0 gnd 2.080806f
C3  g1604_2 gnd 2.080806f
C4  g1604_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g1604_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
C11 7 gnd 2.080806f
R7 6 7 2.224404
C12 8 gnd 2.080806f
R8 7 8 2.224404
C13 9 gnd 2.080806f
R9 8 9 2.224404
C14 10 gnd 2.080806f
R10 9 10 2.224404
C15 11 gnd 2.080806f
R11 10 11 2.224404
C16 12 gnd 2.080806f
R12 11 12 2.224404
C17 13 gnd 2.080806f
R13 12 13 2.224404
C18 14 gnd 2.080806f
R14 13 14 2.224404
C19 15 gnd 2.080806f
R15 14 15 2.224404
C20 16 gnd 2.080806f
R16 15 16 2.224404
C21 17 gnd 2.080806f
R17 16 17 2.224404
C22 18 gnd 2.080806f
R18 17 18 2.224404
C23 19 gnd 2.080806f
R19 18 19 2.224404
C24 20 gnd 2.080806f
R20 19 20 2.224404
C25 21 gnd 2.080806f
R21 20 21 2.224404
C26 22 gnd 2.080806f
R22 21 22 2.224404
C27 23 gnd 2.080806f
R23 22 23 2.224404
C28 24 gnd 2.080806f
R24 23 24 2.224404
R25 24 g1604_1 2.224404
C29 25 gnd 2.080806f
R26 g1604_1 25 2.224404
C30 26 gnd 2.080806f
R27 26 25 2.224404
C31 27 gnd 2.080806f
R28 27 26 2.224404
C32 28 gnd 2.080806f
R29 28 27 2.224404
C33 29 gnd 2.080806f
R30 28 29 2.224404
C34 30 gnd 2.080806f
R31 29 30 2.224404
R32 30 g1604_3 2.224404
C35 31 gnd 2.080806f
R33 g1604_3 31 2.224404
R34 31 g1604_2 2.224404
.ends

.subckt netg2115 g2115_2 g2115_3 g2115_1 gnd
C1  g2115_2 gnd 2.080806f
C2  g2115_3 gnd 2.080806f
C3  g2115_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g2115_3 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
R29 g2115_1 28 2.224404
C32 29 gnd 2.080806f
R30 29 g2115_1 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
R34 g2115_2 32 2.224404
.ends

.subckt netg3355 g3355_2 g3355_1 g3355_0 gnd
C1  g3355_2 gnd 2.080806f
C2  g3355_1 gnd 2.080806f
C3  g3355_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g3355_0 2.224404
R2 g3355_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g3355_1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
R36 g3355_2 34 2.224404
.ends

.subckt netg2194 g2194_0 g2194_2 g2194_5 g2194_1 g2194_4 g2194_3 gnd
C1  g2194_0 gnd 2.080806f
C2  g2194_2 gnd 2.080806f
C3  g2194_5 gnd 2.080806f
C4  g2194_1 gnd 2.080806f
C5  g2194_4 gnd 2.080806f
C6  g2194_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g2194_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g2194_1 2.224404
C10 4 gnd 2.080806f
R5 2 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g2194_2 2.224404
C12 6 gnd 2.080806f
R8 g2194_2 6 2.224404
R9 6 g2194_3 2.224404
C13 7 gnd 2.080806f
R10 g2194_1 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 9 8 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
R14 g2194_4 10 2.224404
C17 11 gnd 2.080806f
R15 g2194_3 11 2.224404
C18 12 gnd 2.080806f
R16 11 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
C21 15 gnd 2.080806f
R19 15 14 2.224404
C22 16 gnd 2.080806f
R20 15 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
C29 23 gnd 2.080806f
R27 22 23 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 24 25 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
C33 27 gnd 2.080806f
R31 26 27 2.224404
C34 28 gnd 2.080806f
R32 27 28 2.224404
C35 29 gnd 2.080806f
R33 28 29 2.224404
C36 30 gnd 2.080806f
R34 29 30 2.224404
C37 31 gnd 2.080806f
R35 30 31 2.224404
C38 32 gnd 2.080806f
R36 31 32 2.224404
C39 33 gnd 2.080806f
R37 32 33 2.224404
C40 34 gnd 2.080806f
R38 33 34 2.224404
R39 34 g2194_5 2.224404
.ends

.subckt netg59 g59_1 g59_0 gnd
C1  g59_1 gnd 2.080806f
C2  g59_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g59_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
R32 g59_1 31 2.224404
.ends

.subckt netg532 g532_1 g532_0 g532_5 g532_4 g532_3 gnd
C1  g532_1 gnd 2.080806f
C2  g532_0 gnd 2.080806f
C3  g532_5 gnd 2.080806f
C4  g532_4 gnd 2.080806f
C5  g532_3 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g532_0 2.224404
C7 2 gnd 2.080806f
R2 2 1 2.224404
C8 3 gnd 2.080806f
R3 3 2 2.224404
C9 4 gnd 2.080806f
R4 4 3 2.224404
C10 5 gnd 2.080806f
R5 5 4 2.224404
C11 6 gnd 2.080806f
R6 6 5 2.224404
R7 g532_5 6 2.224404
C12 7 gnd 2.080806f
R8 g532_5 7 2.224404
C13 8 gnd 2.080806f
R9 8 7 2.224404
C14 9 gnd 2.080806f
R10 9 8 2.224404
C15 10 gnd 2.080806f
R11 10 9 2.224404
C16 11 gnd 2.080806f
R12 10 11 2.224404
R13 g532_3 11 2.224404
C17 12 gnd 2.080806f
R14 g532_0 12 2.224404
C18 13 gnd 2.080806f
R15 12 13 2.224404
C19 14 gnd 2.080806f
R16 13 14 2.224404
C20 15 gnd 2.080806f
R17 14 15 2.224404
C21 16 gnd 2.080806f
R18 15 16 2.224404
C22 17 gnd 2.080806f
R19 16 17 2.224404
C23 18 gnd 2.080806f
R20 17 18 2.224404
C24 19 gnd 2.080806f
R21 18 19 2.224404
C25 20 gnd 2.080806f
R22 19 20 2.224404
C26 21 gnd 2.080806f
R23 20 21 2.224404
C27 22 gnd 2.080806f
R24 21 22 2.224404
C28 23 gnd 2.080806f
R25 22 23 2.224404
C29 24 gnd 2.080806f
R26 23 24 2.224404
C30 25 gnd 2.080806f
R27 24 25 2.224404
C31 26 gnd 2.080806f
R28 25 26 2.224404
C32 27 gnd 2.080806f
R29 26 27 2.224404
C33 28 gnd 2.080806f
R30 27 28 2.224404
R31 28 g532_1 2.224404
C34 29 gnd 2.080806f
R32 28 29 2.224404
C35 30 gnd 2.080806f
R33 29 30 2.224404
R34 30 g532_4 2.224404
.ends

.subckt netg41 g41_1 g41_0 gnd
C1  g41_1 gnd 2.080806f
C2  g41_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g41_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
R32 31 g41_1 2.224404
.ends

.subckt netg6520 g6520_0 g6520_1 gnd
C1  g6520_0 gnd 2.080806f
C2  g6520_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6520_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
R32 31 g6520_1 2.224404
.ends

.subckt netg36 g36_1 g36_0 gnd
C1  g36_1 gnd 2.080806f
C2  g36_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g36_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
R32 g36_1 31 2.224404
.ends

.subckt netg6597 g6597_3 g6597_0 g6597_6 g6597_2 g6597_1 g6597_4 g6597_5 gnd
C1  g6597_3 gnd 2.080806f
C2  g6597_0 gnd 2.080806f
C3  g6597_6 gnd 2.080806f
C4  g6597_2 gnd 2.080806f
C5  g6597_1 gnd 2.080806f
C6  g6597_4 gnd 2.080806f
C7  g6597_5 gnd 2.080806f
R1 g6597_1 g6597_0 2.224404
C8 1 gnd 2.080806f
R2 1 g6597_0 2.224404
C9 2 gnd 2.080806f
R3 2 1 2.224404
C10 3 gnd 2.080806f
R4 3 2 2.224404
C11 4 gnd 2.080806f
R5 3 4 2.224404
R6 g6597_5 4 2.224404
C12 5 gnd 2.080806f
R7 g6597_5 5 2.224404
C13 6 gnd 2.080806f
R8 5 6 2.224404
R9 g6597_4 6 2.224404
C14 7 gnd 2.080806f
R10 7 g6597_5 2.224404
C15 8 gnd 2.080806f
R11 8 7 2.224404
R12 g6597_6 8 2.224404
C16 9 gnd 2.080806f
R13 6 9 2.224404
C17 10 gnd 2.080806f
R14 9 10 2.224404
C18 11 gnd 2.080806f
R15 10 11 2.224404
C19 12 gnd 2.080806f
R16 11 12 2.224404
C20 13 gnd 2.080806f
R17 12 13 2.224404
C21 14 gnd 2.080806f
R18 13 14 2.224404
C22 15 gnd 2.080806f
R19 14 15 2.224404
C23 16 gnd 2.080806f
R20 15 16 2.224404
C24 17 gnd 2.080806f
R21 16 17 2.224404
C25 18 gnd 2.080806f
R22 17 18 2.224404
C26 19 gnd 2.080806f
R23 18 19 2.224404
R24 19 g6597_3 2.224404
C27 20 gnd 2.080806f
R25 g6597_3 20 2.224404
C28 21 gnd 2.080806f
R26 20 21 2.224404
C29 22 gnd 2.080806f
R27 21 22 2.224404
C30 23 gnd 2.080806f
R28 22 23 2.224404
C31 24 gnd 2.080806f
R29 23 24 2.224404
C32 25 gnd 2.080806f
R30 24 25 2.224404
C33 26 gnd 2.080806f
R31 25 26 2.224404
C34 27 gnd 2.080806f
R32 26 27 2.224404
C35 28 gnd 2.080806f
R33 27 28 2.224404
C36 29 gnd 2.080806f
R34 28 29 2.224404
C37 30 gnd 2.080806f
R35 29 30 2.224404
C38 31 gnd 2.080806f
R36 30 31 2.224404
C39 32 gnd 2.080806f
R37 31 32 2.224404
C40 33 gnd 2.080806f
R38 33 32 2.224404
C41 34 gnd 2.080806f
R39 33 34 2.224404
R40 g6597_2 34 2.224404
.ends

.subckt netg3845 g3845_4 g3845_2 g3845_3 g3845_1 g3845_6 g3845_5 g3845_0 gnd
C1  g3845_4 gnd 2.080806f
C2  g3845_2 gnd 2.080806f
C3  g3845_3 gnd 2.080806f
C4  g3845_1 gnd 2.080806f
C5  g3845_6 gnd 2.080806f
C6  g3845_5 gnd 2.080806f
C7  g3845_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g3845_0 2.224404
R2 g3845_1 1 2.224404
C9 2 gnd 2.080806f
R3 g3845_1 2 2.224404
C10 3 gnd 2.080806f
R4 3 2 2.224404
C11 4 gnd 2.080806f
R5 3 4 2.224404
R6 g3845_5 4 2.224404
C12 5 gnd 2.080806f
R7 g3845_0 5 2.224404
C13 6 gnd 2.080806f
R8 5 6 2.224404
C14 7 gnd 2.080806f
R9 6 7 2.224404
C15 8 gnd 2.080806f
R10 7 8 2.224404
C16 9 gnd 2.080806f
R11 8 9 2.224404
R12 9 g3845_6 2.224404
C17 10 gnd 2.080806f
R13 9 10 2.224404
R14 10 g3845_2 2.224404
C18 11 gnd 2.080806f
R15 g3845_2 11 2.224404
C19 12 gnd 2.080806f
R16 11 12 2.224404
C20 13 gnd 2.080806f
R17 12 13 2.224404
R18 13 g3845_4 2.224404
C21 14 gnd 2.080806f
R19 14 g3845_1 2.224404
C22 15 gnd 2.080806f
R20 15 14 2.224404
C23 16 gnd 2.080806f
R21 16 15 2.224404
C24 17 gnd 2.080806f
R22 17 16 2.224404
C25 18 gnd 2.080806f
R23 18 17 2.224404
C26 19 gnd 2.080806f
R24 19 18 2.224404
C27 20 gnd 2.080806f
R25 20 19 2.224404
C28 21 gnd 2.080806f
R26 21 20 2.224404
C29 22 gnd 2.080806f
R27 22 21 2.224404
C30 23 gnd 2.080806f
R28 23 22 2.224404
C31 24 gnd 2.080806f
R29 24 23 2.224404
C32 25 gnd 2.080806f
R30 25 24 2.224404
C33 26 gnd 2.080806f
R31 26 25 2.224404
C34 27 gnd 2.080806f
R32 27 26 2.224404
C35 28 gnd 2.080806f
R33 28 27 2.224404
C36 29 gnd 2.080806f
R34 29 28 2.224404
C37 30 gnd 2.080806f
R35 30 29 2.224404
C38 31 gnd 2.080806f
R36 31 30 2.224404
C39 32 gnd 2.080806f
R37 32 31 2.224404
R38 g3845_3 32 2.224404
.ends

.subckt netg2203 g2203_1 g2203_5 g2203_3 g2203_4 g2203_2 gnd
C1  g2203_1 gnd 2.080806f
C2  g2203_5 gnd 2.080806f
C3  g2203_3 gnd 2.080806f
C4  g2203_4 gnd 2.080806f
C5  g2203_2 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g2203_4 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
C8 3 gnd 2.080806f
R3 2 3 2.224404
C9 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g2203_1 2.224404
C10 5 gnd 2.080806f
R6 g2203_1 5 2.224404
C11 6 gnd 2.080806f
R7 5 6 2.224404
C12 7 gnd 2.080806f
R8 6 7 2.224404
C13 8 gnd 2.080806f
R9 7 8 2.224404
R10 8 g2203_5 2.224404
C14 9 gnd 2.080806f
R11 g2203_5 9 2.224404
C15 10 gnd 2.080806f
R12 9 10 2.224404
C16 11 gnd 2.080806f
R13 10 11 2.224404
C17 12 gnd 2.080806f
R14 11 12 2.224404
C18 13 gnd 2.080806f
R15 12 13 2.224404
C19 14 gnd 2.080806f
R16 13 14 2.224404
C20 15 gnd 2.080806f
R17 14 15 2.224404
C21 16 gnd 2.080806f
R18 15 16 2.224404
C22 17 gnd 2.080806f
R19 16 17 2.224404
C23 18 gnd 2.080806f
R20 17 18 2.224404
C24 19 gnd 2.080806f
R21 18 19 2.224404
C25 20 gnd 2.080806f
R22 19 20 2.224404
C26 21 gnd 2.080806f
R23 20 21 2.224404
C27 22 gnd 2.080806f
R24 21 22 2.224404
C28 23 gnd 2.080806f
R25 23 22 2.224404
C29 24 gnd 2.080806f
R26 23 24 2.224404
C30 25 gnd 2.080806f
R27 24 25 2.224404
C31 26 gnd 2.080806f
R28 25 26 2.224404
C32 27 gnd 2.080806f
R29 26 27 2.224404
C33 28 gnd 2.080806f
R30 27 28 2.224404
C34 29 gnd 2.080806f
R31 28 29 2.224404
C35 30 gnd 2.080806f
R32 29 30 2.224404
C36 31 gnd 2.080806f
R33 31 30 2.224404
C37 32 gnd 2.080806f
R34 32 31 2.224404
C38 33 gnd 2.080806f
R35 32 33 2.224404
C39 34 gnd 2.080806f
R36 33 34 2.224404
C40 35 gnd 2.080806f
R37 34 35 2.224404
C41 36 gnd 2.080806f
R38 35 36 2.224404
R39 36 g2203_2 2.224404
C42 37 gnd 2.080806f
R40 37 36 2.224404
C43 38 gnd 2.080806f
R41 38 37 2.224404
R42 g2203_3 38 2.224404
.ends

.subckt netg2421 g2421_1 g2421_0 gnd
C1  g2421_1 gnd 2.080806f
C2  g2421_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g2421_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
R35 g2421_1 34 2.224404
.ends

.subckt netg6408 g6408_1 g6408_0 gnd
C1  g6408_1 gnd 2.080806f
C2  g6408_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g6408_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
R33 32 g6408_1 2.224404
.ends

.subckt netg3687 g3687_0 g3687_2 g3687_1 g3687_3 gnd
C1  g3687_0 gnd 2.080806f
C2  g3687_2 gnd 2.080806f
C3  g3687_1 gnd 2.080806f
C4  g3687_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g3687_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 6 7 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
R9 g3687_2 8 2.224404
C13 9 gnd 2.080806f
R10 9 1 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 11 12 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
C18 14 gnd 2.080806f
R15 13 14 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
C20 16 gnd 2.080806f
R17 15 16 2.224404
C21 17 gnd 2.080806f
R18 17 16 2.224404
C22 18 gnd 2.080806f
R19 17 18 2.224404
C23 19 gnd 2.080806f
R20 18 19 2.224404
C24 20 gnd 2.080806f
R21 19 20 2.224404
C25 21 gnd 2.080806f
R22 21 20 2.224404
C26 22 gnd 2.080806f
R23 21 22 2.224404
C27 23 gnd 2.080806f
R24 22 23 2.224404
C28 24 gnd 2.080806f
R25 23 24 2.224404
C29 25 gnd 2.080806f
R26 24 25 2.224404
C30 26 gnd 2.080806f
R27 25 26 2.224404
C31 27 gnd 2.080806f
R28 26 27 2.224404
C32 28 gnd 2.080806f
R29 27 28 2.224404
C33 29 gnd 2.080806f
R30 28 29 2.224404
C34 30 gnd 2.080806f
R31 30 29 2.224404
C35 31 gnd 2.080806f
R32 30 31 2.224404
C36 32 gnd 2.080806f
R33 31 32 2.224404
R34 32 g3687_1 2.224404
C37 33 gnd 2.080806f
R35 33 g3687_1 2.224404
R36 g3687_3 33 2.224404
.ends

.subckt netg5816 g5816_3 g5816_2 g5816_1 g5816_0 gnd
C1  g5816_3 gnd 2.080806f
C2  g5816_2 gnd 2.080806f
C3  g5816_1 gnd 2.080806f
C4  g5816_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g5816_0 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
R3 g5816_3 2 2.224404
R4 g5816_2 g5816_3 2.224404
C7 3 gnd 2.080806f
R5 3 g5816_0 2.224404
C8 4 gnd 2.080806f
R6 4 3 2.224404
C9 5 gnd 2.080806f
R7 5 4 2.224404
C10 6 gnd 2.080806f
R8 6 5 2.224404
C11 7 gnd 2.080806f
R9 7 6 2.224404
C12 8 gnd 2.080806f
R10 8 7 2.224404
C13 9 gnd 2.080806f
R11 9 8 2.224404
C14 10 gnd 2.080806f
R12 10 9 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 12 11 2.224404
C17 13 gnd 2.080806f
R15 13 12 2.224404
C18 14 gnd 2.080806f
R16 14 13 2.224404
C19 15 gnd 2.080806f
R17 15 14 2.224404
C20 16 gnd 2.080806f
R18 16 15 2.224404
C21 17 gnd 2.080806f
R19 17 16 2.224404
C22 18 gnd 2.080806f
R20 18 17 2.224404
C23 19 gnd 2.080806f
R21 19 18 2.224404
C24 20 gnd 2.080806f
R22 20 19 2.224404
C25 21 gnd 2.080806f
R23 21 20 2.224404
C26 22 gnd 2.080806f
R24 21 22 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
C28 24 gnd 2.080806f
R26 23 24 2.224404
C29 25 gnd 2.080806f
R27 25 24 2.224404
C30 26 gnd 2.080806f
R28 26 25 2.224404
C31 27 gnd 2.080806f
R29 26 27 2.224404
C32 28 gnd 2.080806f
R30 28 27 2.224404
C33 29 gnd 2.080806f
R31 28 29 2.224404
C34 30 gnd 2.080806f
R32 29 30 2.224404
R33 30 g5816_1 2.224404
.ends

.subckt netg37 g37_1 g37_0 gnd
C1  g37_1 gnd 2.080806f
C2  g37_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g37_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
R33 32 g37_1 2.224404
.ends

.subckt netg699 g699_3 g699_2 g699_4 g699_1 g699_5 g699_0 gnd
C1  g699_3 gnd 2.080806f
C2  g699_2 gnd 2.080806f
C3  g699_4 gnd 2.080806f
C4  g699_1 gnd 2.080806f
C5  g699_5 gnd 2.080806f
C6  g699_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g699_0 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 g699_4 2 2.224404
C9 3 gnd 2.080806f
R4 g699_0 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g699_2 2.224404
C14 8 gnd 2.080806f
R10 g699_2 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
C19 13 gnd 2.080806f
R15 12 13 2.224404
C20 14 gnd 2.080806f
R16 13 14 2.224404
C21 15 gnd 2.080806f
R17 14 15 2.224404
C22 16 gnd 2.080806f
R18 15 16 2.224404
C23 17 gnd 2.080806f
R19 16 17 2.224404
C24 18 gnd 2.080806f
R20 17 18 2.224404
C25 19 gnd 2.080806f
R21 18 19 2.224404
C26 20 gnd 2.080806f
R22 19 20 2.224404
C27 21 gnd 2.080806f
R23 20 21 2.224404
C28 22 gnd 2.080806f
R24 21 22 2.224404
C29 23 gnd 2.080806f
R25 22 23 2.224404
C30 24 gnd 2.080806f
R26 24 23 2.224404
C31 25 gnd 2.080806f
R27 24 25 2.224404
C32 26 gnd 2.080806f
R28 25 26 2.224404
C33 27 gnd 2.080806f
R29 27 26 2.224404
C34 28 gnd 2.080806f
R30 28 27 2.224404
C35 29 gnd 2.080806f
R31 28 29 2.224404
C36 30 gnd 2.080806f
R32 30 29 2.224404
C37 31 gnd 2.080806f
R33 31 30 2.224404
C38 32 gnd 2.080806f
R34 31 32 2.224404
C39 33 gnd 2.080806f
R35 33 32 2.224404
R36 33 g699_3 2.224404
C40 34 gnd 2.080806f
R37 34 g699_3 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
R40 36 g699_5 2.224404
C43 37 gnd 2.080806f
R41 g699_5 37 2.224404
C44 38 gnd 2.080806f
R42 37 38 2.224404
C45 39 gnd 2.080806f
R43 38 39 2.224404
C46 40 gnd 2.080806f
R44 39 40 2.224404
C47 41 gnd 2.080806f
R45 40 41 2.224404
C48 42 gnd 2.080806f
R46 42 41 2.224404
C49 43 gnd 2.080806f
R47 42 43 2.224404
R48 43 g699_1 2.224404
.ends

.subckt netg47 g47_0 g47_1 gnd
C1  g47_0 gnd 2.080806f
C2  g47_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g47_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
R33 g47_1 32 2.224404
.ends

.subckt netg799 g799_3 g799_1 g799_0 g799_2 g799_5 g799_4 gnd
C1  g799_3 gnd 2.080806f
C2  g799_1 gnd 2.080806f
C3  g799_0 gnd 2.080806f
C4  g799_2 gnd 2.080806f
C5  g799_5 gnd 2.080806f
C6  g799_4 gnd 2.080806f
R1 g799_0 g799_2 2.224404
C7 1 gnd 2.080806f
R2 g799_0 1 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
R9 g799_5 7 2.224404
C14 8 gnd 2.080806f
R10 8 g799_5 2.224404
C15 9 gnd 2.080806f
R11 9 8 2.224404
C16 10 gnd 2.080806f
R12 10 9 2.224404
C17 11 gnd 2.080806f
R13 11 10 2.224404
C18 12 gnd 2.080806f
R14 12 11 2.224404
C19 13 gnd 2.080806f
R15 13 12 2.224404
R16 g799_4 13 2.224404
C20 14 gnd 2.080806f
R17 14 g799_4 2.224404
C21 15 gnd 2.080806f
R18 15 14 2.224404
C22 16 gnd 2.080806f
R19 16 15 2.224404
C23 17 gnd 2.080806f
R20 17 16 2.224404
C24 18 gnd 2.080806f
R21 18 17 2.224404
C25 19 gnd 2.080806f
R22 19 18 2.224404
C26 20 gnd 2.080806f
R23 20 19 2.224404
C27 21 gnd 2.080806f
R24 21 20 2.224404
C28 22 gnd 2.080806f
R25 22 21 2.224404
C29 23 gnd 2.080806f
R26 23 22 2.224404
C30 24 gnd 2.080806f
R27 24 23 2.224404
C31 25 gnd 2.080806f
R28 25 24 2.224404
C32 26 gnd 2.080806f
R29 26 25 2.224404
C33 27 gnd 2.080806f
R30 27 26 2.224404
C34 28 gnd 2.080806f
R31 28 27 2.224404
C35 29 gnd 2.080806f
R32 29 28 2.224404
C36 30 gnd 2.080806f
R33 30 29 2.224404
C37 31 gnd 2.080806f
R34 31 30 2.224404
C38 32 gnd 2.080806f
R35 32 31 2.224404
R36 g799_3 32 2.224404
C39 33 gnd 2.080806f
R37 33 g799_3 2.224404
C40 34 gnd 2.080806f
R38 33 34 2.224404
C41 35 gnd 2.080806f
R39 34 35 2.224404
C42 36 gnd 2.080806f
R40 36 35 2.224404
C43 37 gnd 2.080806f
R41 37 36 2.224404
R42 g799_1 37 2.224404
.ends

.subckt netg1462 g1462_3 g1462_1 g1462_2 g1462_5 g1462_4 g1462_0 gnd
C1  g1462_3 gnd 2.080806f
C2  g1462_1 gnd 2.080806f
C3  g1462_2 gnd 2.080806f
C4  g1462_5 gnd 2.080806f
C5  g1462_4 gnd 2.080806f
C6  g1462_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1462_0 1 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
C10 4 gnd 2.080806f
R4 3 4 2.224404
C11 5 gnd 2.080806f
R5 5 4 2.224404
R6 g1462_4 5 2.224404
C12 6 gnd 2.080806f
R7 6 g1462_4 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
R9 g1462_1 7 2.224404
C14 8 gnd 2.080806f
R10 8 g1462_0 2.224404
C15 9 gnd 2.080806f
R11 9 8 2.224404
C16 10 gnd 2.080806f
R12 10 9 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
C19 13 gnd 2.080806f
R15 12 13 2.224404
C20 14 gnd 2.080806f
R16 13 14 2.224404
C21 15 gnd 2.080806f
R17 14 15 2.224404
C22 16 gnd 2.080806f
R18 15 16 2.224404
C23 17 gnd 2.080806f
R19 16 17 2.224404
C24 18 gnd 2.080806f
R20 17 18 2.224404
C25 19 gnd 2.080806f
R21 18 19 2.224404
C26 20 gnd 2.080806f
R22 19 20 2.224404
C27 21 gnd 2.080806f
R23 20 21 2.224404
C28 22 gnd 2.080806f
R24 21 22 2.224404
C29 23 gnd 2.080806f
R25 22 23 2.224404
R26 23 g1462_3 2.224404
C30 24 gnd 2.080806f
R27 g1462_3 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
R41 37 g1462_2 2.224404
R42 g1462_2 g1462_5 2.224404
.ends

.subckt netg672 g672_1 g672_3 g672_2 g672_4 g672_0 g672_5 gnd
C1  g672_1 gnd 2.080806f
C2  g672_3 gnd 2.080806f
C3  g672_2 gnd 2.080806f
C4  g672_4 gnd 2.080806f
C5  g672_0 gnd 2.080806f
C6  g672_5 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g672_0 2.224404
R2 g672_3 1 2.224404
C8 2 gnd 2.080806f
R3 g672_3 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
R5 3 g672_5 2.224404
C10 4 gnd 2.080806f
R6 g672_5 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
R14 11 g672_1 2.224404
C18 12 gnd 2.080806f
R15 g672_1 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
R26 22 g672_2 2.224404
C29 23 gnd 2.080806f
R27 12 23 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 24 25 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
C33 27 gnd 2.080806f
R31 26 27 2.224404
C34 28 gnd 2.080806f
R32 27 28 2.224404
C35 29 gnd 2.080806f
R33 28 29 2.224404
C36 30 gnd 2.080806f
R34 29 30 2.224404
C37 31 gnd 2.080806f
R35 30 31 2.224404
C38 32 gnd 2.080806f
R36 31 32 2.224404
R37 32 g672_4 2.224404
.ends

.subckt netg38 g38_0 g38_1 gnd
C1  g38_0 gnd 2.080806f
C2  g38_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g38_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
R34 g38_1 33 2.224404
.ends

.subckt netg6778 g6778_0 g6778_1 g6778_2 gnd
C1  g6778_0 gnd 2.080806f
C2  g6778_1 gnd 2.080806f
C3  g6778_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g6778_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g6778_2 2.224404
C6 3 gnd 2.080806f
R4 g6778_0 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
R36 34 g6778_1 2.224404
.ends

.subckt netg34 g34_1 g34_0 gnd
C1  g34_1 gnd 2.080806f
C2  g34_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g34_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
R34 33 g34_1 2.224404
.ends

.subckt netg5269 g5269_1 g5269_0 gnd
C1  g5269_1 gnd 2.080806f
C2  g5269_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g5269_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
R35 g5269_1 34 2.224404
.ends

.subckt netg3071 g3071_2 g3071_0 g3071_5 g3071_4 g3071_3 g3071_1 gnd
C1  g3071_2 gnd 2.080806f
C2  g3071_0 gnd 2.080806f
C3  g3071_5 gnd 2.080806f
C4  g3071_4 gnd 2.080806f
C5  g3071_3 gnd 2.080806f
C6  g3071_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g3071_0 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 g3071_4 2 2.224404
C9 3 gnd 2.080806f
R4 3 g3071_0 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
R11 g3071_1 9 2.224404
R12 g3071_5 g3071_1 2.224404
R13 g3071_2 g3071_5 2.224404
C16 10 gnd 2.080806f
R14 9 10 2.224404
C17 11 gnd 2.080806f
R15 10 11 2.224404
C18 12 gnd 2.080806f
R16 11 12 2.224404
C19 13 gnd 2.080806f
R17 12 13 2.224404
C20 14 gnd 2.080806f
R18 13 14 2.224404
C21 15 gnd 2.080806f
R19 14 15 2.224404
C22 16 gnd 2.080806f
R20 15 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
C29 23 gnd 2.080806f
R27 22 23 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 24 25 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
C33 27 gnd 2.080806f
R31 26 27 2.224404
C34 28 gnd 2.080806f
R32 27 28 2.224404
C35 29 gnd 2.080806f
R33 28 29 2.224404
C36 30 gnd 2.080806f
R34 29 30 2.224404
C37 31 gnd 2.080806f
R35 30 31 2.224404
C38 32 gnd 2.080806f
R36 31 32 2.224404
R37 32 g3071_3 2.224404
.ends

.subckt netg54 g54_1 g54_0 g54_2 gnd
C1  g54_1 gnd 2.080806f
C2  g54_0 gnd 2.080806f
C3  g54_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g54_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
R22 g54_1 21 2.224404
C25 22 gnd 2.080806f
R23 19 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
R39 37 g54_2 2.224404
.ends

.subckt netg2182 g2182_5 g2182_2 g2182_1 g2182_4 g2182_3 g2182_0 gnd
C1  g2182_5 gnd 2.080806f
C2  g2182_2 gnd 2.080806f
C3  g2182_1 gnd 2.080806f
C4  g2182_4 gnd 2.080806f
C5  g2182_3 gnd 2.080806f
C6  g2182_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2182_0 2.224404
R2 g2182_5 1 2.224404
R3 g2182_5 g2182_1 2.224404
C8 2 gnd 2.080806f
R4 g2182_1 2 2.224404
C9 3 gnd 2.080806f
R5 2 3 2.224404
R6 3 g2182_2 2.224404
C10 4 gnd 2.080806f
R7 g2182_0 4 2.224404
C11 5 gnd 2.080806f
R8 4 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
R22 g2182_4 18 2.224404
C25 19 gnd 2.080806f
R23 19 g2182_4 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
C29 23 gnd 2.080806f
R27 22 23 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 24 25 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
C33 27 gnd 2.080806f
R31 26 27 2.224404
C34 28 gnd 2.080806f
R32 27 28 2.224404
C35 29 gnd 2.080806f
R33 28 29 2.224404
C36 30 gnd 2.080806f
R34 29 30 2.224404
C37 31 gnd 2.080806f
R35 30 31 2.224404
C38 32 gnd 2.080806f
R36 31 32 2.224404
C39 33 gnd 2.080806f
R37 32 33 2.224404
C40 34 gnd 2.080806f
R38 33 34 2.224404
C41 35 gnd 2.080806f
R39 34 35 2.224404
C42 36 gnd 2.080806f
R40 35 36 2.224404
C43 37 gnd 2.080806f
R41 36 37 2.224404
C44 38 gnd 2.080806f
R42 37 38 2.224404
R43 38 g2182_3 2.224404
.ends

.subckt netg442 g442_0 g442_2 g442_1 g442_3 gnd
C1  g442_0 gnd 2.080806f
C2  g442_2 gnd 2.080806f
C3  g442_1 gnd 2.080806f
C4  g442_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g442_0 2.224404
R2 g442_2 1 2.224404
C6 2 gnd 2.080806f
R3 g442_0 2 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 5 4 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 15 14 2.224404
C20 16 gnd 2.080806f
R17 16 15 2.224404
C21 17 gnd 2.080806f
R18 17 16 2.224404
C22 18 gnd 2.080806f
R19 18 17 2.224404
C23 19 gnd 2.080806f
R20 18 19 2.224404
C24 20 gnd 2.080806f
R21 19 20 2.224404
C25 21 gnd 2.080806f
R22 20 21 2.224404
C26 22 gnd 2.080806f
R23 22 21 2.224404
C27 23 gnd 2.080806f
R24 23 22 2.224404
C28 24 gnd 2.080806f
R25 23 24 2.224404
C29 25 gnd 2.080806f
R26 24 25 2.224404
C30 26 gnd 2.080806f
R27 26 25 2.224404
C31 27 gnd 2.080806f
R28 27 26 2.224404
C32 28 gnd 2.080806f
R29 28 27 2.224404
C33 29 gnd 2.080806f
R30 29 28 2.224404
R31 g442_3 29 2.224404
C34 30 gnd 2.080806f
R32 30 g442_3 2.224404
C35 31 gnd 2.080806f
R33 31 30 2.224404
C36 32 gnd 2.080806f
R34 32 31 2.224404
C37 33 gnd 2.080806f
R35 33 32 2.224404
C38 34 gnd 2.080806f
R36 34 33 2.224404
C39 35 gnd 2.080806f
R37 34 35 2.224404
C40 36 gnd 2.080806f
R38 36 35 2.224404
C41 37 gnd 2.080806f
R39 36 37 2.224404
C42 38 gnd 2.080806f
R40 37 38 2.224404
C43 39 gnd 2.080806f
R41 39 38 2.224404
C44 40 gnd 2.080806f
R42 40 39 2.224404
C45 41 gnd 2.080806f
R43 41 40 2.224404
C46 42 gnd 2.080806f
R44 41 42 2.224404
C47 43 gnd 2.080806f
R45 43 42 2.224404
C48 44 gnd 2.080806f
R46 44 43 2.224404
C49 45 gnd 2.080806f
R47 45 44 2.224404
C50 46 gnd 2.080806f
R48 46 45 2.224404
R49 g442_1 46 2.224404
.ends

.subckt netg1859 g1859_0 g1859_1 g1859_2 gnd
C1  g1859_0 gnd 2.080806f
C2  g1859_1 gnd 2.080806f
C3  g1859_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g1859_0 1 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
R37 g1859_1 36 2.224404
C40 37 gnd 2.080806f
R38 37 g1859_1 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
R50 g1859_2 48 2.224404
.ends

.subckt netg488 g488_3 g488_4 g488_2 g488_0 g488_1 g488_5 gnd
C1  g488_3 gnd 2.080806f
C2  g488_4 gnd 2.080806f
C3  g488_2 gnd 2.080806f
C4  g488_0 gnd 2.080806f
C5  g488_1 gnd 2.080806f
C6  g488_5 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g488_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
C10 4 gnd 2.080806f
R4 4 3 2.224404
C11 5 gnd 2.080806f
R5 5 4 2.224404
R6 g488_1 5 2.224404
R7 g488_2 g488_1 2.224404
C12 6 gnd 2.080806f
R8 6 g488_0 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
C19 13 gnd 2.080806f
R15 12 13 2.224404
C20 14 gnd 2.080806f
R16 13 14 2.224404
C21 15 gnd 2.080806f
R17 14 15 2.224404
C22 16 gnd 2.080806f
R18 15 16 2.224404
C23 17 gnd 2.080806f
R19 16 17 2.224404
C24 18 gnd 2.080806f
R20 17 18 2.224404
C25 19 gnd 2.080806f
R21 18 19 2.224404
R22 19 g488_5 2.224404
C26 20 gnd 2.080806f
R23 g488_5 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
R33 29 g488_4 2.224404
C36 30 gnd 2.080806f
R34 30 g488_4 2.224404
C37 31 gnd 2.080806f
R35 31 30 2.224404
R36 g488_3 31 2.224404
.ends

.subckt netg35 g35_0 g35_1 gnd
C1  g35_0 gnd 2.080806f
C2  g35_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g35_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
R36 g35_1 35 2.224404
.ends

.subckt netg31 g31_1 g31_0 gnd
C1  g31_1 gnd 2.080806f
C2  g31_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g31_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
R36 g31_1 35 2.224404
.ends

.subckt netg64 g64_1 g64_0 g64_2 gnd
C1  g64_1 gnd 2.080806f
C2  g64_0 gnd 2.080806f
C3  g64_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g64_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g64_2 2.224404
C7 4 gnd 2.080806f
R5 4 g64_2 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
R40 g64_1 38 2.224404
.ends

.subckt netg143 g143_0 g143_1 gnd
C1  g143_0 gnd 2.080806f
C2  g143_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g143_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
R36 g143_1 35 2.224404
.ends

.subckt netg145 g145_1 g145_0 gnd
C1  g145_1 gnd 2.080806f
C2  g145_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g145_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
R37 36 g145_1 2.224404
.ends

.subckt netg2209 g2209_4 g2209_3 g2209_0 g2209_5 g2209_1 g2209_2 gnd
C1  g2209_4 gnd 2.080806f
C2  g2209_3 gnd 2.080806f
C3  g2209_0 gnd 2.080806f
C4  g2209_5 gnd 2.080806f
C5  g2209_1 gnd 2.080806f
C6  g2209_2 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g2209_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 g2209_5 3 2.224404
C10 4 gnd 2.080806f
R5 4 g2209_5 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
C16 10 gnd 2.080806f
R11 10 9 2.224404
C17 11 gnd 2.080806f
R12 11 10 2.224404
C18 12 gnd 2.080806f
R13 12 11 2.224404
C19 13 gnd 2.080806f
R14 13 12 2.224404
C20 14 gnd 2.080806f
R15 14 13 2.224404
C21 15 gnd 2.080806f
R16 15 14 2.224404
C22 16 gnd 2.080806f
R17 16 15 2.224404
C23 17 gnd 2.080806f
R18 17 16 2.224404
C24 18 gnd 2.080806f
R19 18 17 2.224404
C25 19 gnd 2.080806f
R20 19 18 2.224404
C26 20 gnd 2.080806f
R21 20 19 2.224404
C27 21 gnd 2.080806f
R22 21 20 2.224404
C28 22 gnd 2.080806f
R23 22 21 2.224404
C29 23 gnd 2.080806f
R24 23 22 2.224404
C30 24 gnd 2.080806f
R25 24 23 2.224404
C31 25 gnd 2.080806f
R26 25 24 2.224404
C32 26 gnd 2.080806f
R27 26 25 2.224404
C33 27 gnd 2.080806f
R28 27 26 2.224404
R29 g2209_3 27 2.224404
C34 28 gnd 2.080806f
R30 28 g2209_3 2.224404
C35 29 gnd 2.080806f
R31 29 28 2.224404
C36 30 gnd 2.080806f
R32 29 30 2.224404
R33 g2209_2 30 2.224404
C37 31 gnd 2.080806f
R34 31 g2209_2 2.224404
C38 32 gnd 2.080806f
R35 32 31 2.224404
C39 33 gnd 2.080806f
R36 33 32 2.224404
C40 34 gnd 2.080806f
R37 34 33 2.224404
C41 35 gnd 2.080806f
R38 35 34 2.224404
C42 36 gnd 2.080806f
R39 36 35 2.224404
C43 37 gnd 2.080806f
R40 37 36 2.224404
R41 g2209_1 37 2.224404
R42 g2209_4 g2209_1 2.224404
.ends

.subckt netg2119 g2119_1 g2119_2 g2119_3 g2119_0 gnd
C1  g2119_1 gnd 2.080806f
C2  g2119_2 gnd 2.080806f
C3  g2119_3 gnd 2.080806f
C4  g2119_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2119_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
R6 g2119_1 5 2.224404
R7 g2119_3 5 2.224404
C10 6 gnd 2.080806f
R8 g2119_0 6 2.224404
C11 7 gnd 2.080806f
R9 6 7 2.224404
C12 8 gnd 2.080806f
R10 7 8 2.224404
C13 9 gnd 2.080806f
R11 8 9 2.224404
C14 10 gnd 2.080806f
R12 9 10 2.224404
C15 11 gnd 2.080806f
R13 10 11 2.224404
C16 12 gnd 2.080806f
R14 11 12 2.224404
C17 13 gnd 2.080806f
R15 12 13 2.224404
C18 14 gnd 2.080806f
R16 13 14 2.224404
C19 15 gnd 2.080806f
R17 14 15 2.224404
C20 16 gnd 2.080806f
R18 15 16 2.224404
C21 17 gnd 2.080806f
R19 16 17 2.224404
C22 18 gnd 2.080806f
R20 17 18 2.224404
C23 19 gnd 2.080806f
R21 18 19 2.224404
C24 20 gnd 2.080806f
R22 19 20 2.224404
C25 21 gnd 2.080806f
R23 20 21 2.224404
C26 22 gnd 2.080806f
R24 22 21 2.224404
C27 23 gnd 2.080806f
R25 22 23 2.224404
C28 24 gnd 2.080806f
R26 23 24 2.224404
C29 25 gnd 2.080806f
R27 24 25 2.224404
C30 26 gnd 2.080806f
R28 25 26 2.224404
C31 27 gnd 2.080806f
R29 26 27 2.224404
C32 28 gnd 2.080806f
R30 27 28 2.224404
C33 29 gnd 2.080806f
R31 28 29 2.224404
C34 30 gnd 2.080806f
R32 29 30 2.224404
C35 31 gnd 2.080806f
R33 30 31 2.224404
C36 32 gnd 2.080806f
R34 31 32 2.224404
C37 33 gnd 2.080806f
R35 32 33 2.224404
C38 34 gnd 2.080806f
R36 34 33 2.224404
C39 35 gnd 2.080806f
R37 35 34 2.224404
C40 36 gnd 2.080806f
R38 36 35 2.224404
C41 37 gnd 2.080806f
R39 36 37 2.224404
C42 38 gnd 2.080806f
R40 38 37 2.224404
C43 39 gnd 2.080806f
R41 38 39 2.224404
C44 40 gnd 2.080806f
R42 39 40 2.224404
C45 41 gnd 2.080806f
R43 40 41 2.224404
C46 42 gnd 2.080806f
R44 41 42 2.224404
C47 43 gnd 2.080806f
R45 42 43 2.224404
C48 44 gnd 2.080806f
R46 43 44 2.224404
R47 44 g2119_2 2.224404
.ends

.subckt netg6705 g6705_0 g6705_3 g6705_2 g6705_4 g6705_1 gnd
C1  g6705_0 gnd 2.080806f
C2  g6705_3 gnd 2.080806f
C3  g6705_2 gnd 2.080806f
C4  g6705_4 gnd 2.080806f
C5  g6705_1 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g6705_0 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
C8 3 gnd 2.080806f
R3 3 2 2.224404
C9 4 gnd 2.080806f
R4 3 4 2.224404
R5 g6705_2 4 2.224404
R6 g6705_2 g6705_3 2.224404
R7 g6705_4 g6705_2 2.224404
C10 5 gnd 2.080806f
R8 g6705_3 5 2.224404
C11 6 gnd 2.080806f
R9 5 6 2.224404
C12 7 gnd 2.080806f
R10 6 7 2.224404
C13 8 gnd 2.080806f
R11 8 7 2.224404
C14 9 gnd 2.080806f
R12 9 8 2.224404
C15 10 gnd 2.080806f
R13 9 10 2.224404
C16 11 gnd 2.080806f
R14 11 10 2.224404
C17 12 gnd 2.080806f
R15 12 11 2.224404
C18 13 gnd 2.080806f
R16 12 13 2.224404
C19 14 gnd 2.080806f
R17 13 14 2.224404
C20 15 gnd 2.080806f
R18 14 15 2.224404
C21 16 gnd 2.080806f
R19 15 16 2.224404
C22 17 gnd 2.080806f
R20 17 16 2.224404
C23 18 gnd 2.080806f
R21 17 18 2.224404
C24 19 gnd 2.080806f
R22 19 18 2.224404
C25 20 gnd 2.080806f
R23 19 20 2.224404
C26 21 gnd 2.080806f
R24 21 20 2.224404
C27 22 gnd 2.080806f
R25 22 21 2.224404
C28 23 gnd 2.080806f
R26 23 22 2.224404
C29 24 gnd 2.080806f
R27 24 23 2.224404
C30 25 gnd 2.080806f
R28 24 25 2.224404
C31 26 gnd 2.080806f
R29 26 25 2.224404
C32 27 gnd 2.080806f
R30 27 26 2.224404
C33 28 gnd 2.080806f
R31 28 27 2.224404
C34 29 gnd 2.080806f
R32 28 29 2.224404
C35 30 gnd 2.080806f
R33 29 30 2.224404
C36 31 gnd 2.080806f
R34 31 30 2.224404
C37 32 gnd 2.080806f
R35 32 31 2.224404
C38 33 gnd 2.080806f
R36 33 32 2.224404
C39 34 gnd 2.080806f
R37 34 33 2.224404
R38 g6705_1 34 2.224404
.ends

.subckt netg86 g86_0 g86_1 gnd
C1  g86_0 gnd 2.080806f
C2  g86_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g86_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
R37 36 g86_1 2.224404
.ends

.subckt netg147 g147_1 g147_0 gnd
C1  g147_1 gnd 2.080806f
C2  g147_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g147_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
R37 36 g147_1 2.224404
.ends

.subckt netg2304 g2304_0 g2304_3 g2304_2 g2304_1 gnd
C1  g2304_0 gnd 2.080806f
C2  g2304_3 gnd 2.080806f
C3  g2304_2 gnd 2.080806f
C4  g2304_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2304_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
R10 g2304_2 9 2.224404
C14 10 gnd 2.080806f
R11 g2304_0 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 11 12 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
C18 14 gnd 2.080806f
R15 13 14 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
C20 16 gnd 2.080806f
R17 15 16 2.224404
C21 17 gnd 2.080806f
R18 16 17 2.224404
C22 18 gnd 2.080806f
R19 17 18 2.224404
C23 19 gnd 2.080806f
R20 18 19 2.224404
C24 20 gnd 2.080806f
R21 19 20 2.224404
C25 21 gnd 2.080806f
R22 20 21 2.224404
C26 22 gnd 2.080806f
R23 21 22 2.224404
C27 23 gnd 2.080806f
R24 22 23 2.224404
C28 24 gnd 2.080806f
R25 23 24 2.224404
C29 25 gnd 2.080806f
R26 24 25 2.224404
C30 26 gnd 2.080806f
R27 25 26 2.224404
C31 27 gnd 2.080806f
R28 26 27 2.224404
C32 28 gnd 2.080806f
R29 27 28 2.224404
C33 29 gnd 2.080806f
R30 28 29 2.224404
C34 30 gnd 2.080806f
R31 29 30 2.224404
C35 31 gnd 2.080806f
R32 30 31 2.224404
C36 32 gnd 2.080806f
R33 31 32 2.224404
C37 33 gnd 2.080806f
R34 32 33 2.224404
C38 34 gnd 2.080806f
R35 33 34 2.224404
R36 34 g2304_3 2.224404
R37 g2304_3 g2304_1 2.224404
.ends

.subckt netg74 g74_1 g74_0 gnd
C1  g74_1 gnd 2.080806f
C2  g74_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g74_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
R38 37 g74_1 2.224404
.ends

.subckt netg20 g20_1 g20_0 gnd
C1  g20_1 gnd 2.080806f
C2  g20_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g20_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
R38 g20_1 37 2.224404
.ends

.subckt netg2308 g2308_2 g2308_3 g2308_1 g2308_0 gnd
C1  g2308_2 gnd 2.080806f
C2  g2308_3 gnd 2.080806f
C3  g2308_1 gnd 2.080806f
C4  g2308_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g2308_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
C14 10 gnd 2.080806f
R10 10 9 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
C16 12 gnd 2.080806f
R12 12 11 2.224404
C17 13 gnd 2.080806f
R13 13 12 2.224404
R14 g2308_3 13 2.224404
C18 14 gnd 2.080806f
R15 g2308_0 14 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
C20 16 gnd 2.080806f
R17 15 16 2.224404
C21 17 gnd 2.080806f
R18 16 17 2.224404
C22 18 gnd 2.080806f
R19 17 18 2.224404
C23 19 gnd 2.080806f
R20 18 19 2.224404
C24 20 gnd 2.080806f
R21 19 20 2.224404
C25 21 gnd 2.080806f
R22 20 21 2.224404
C26 22 gnd 2.080806f
R23 21 22 2.224404
C27 23 gnd 2.080806f
R24 22 23 2.224404
C28 24 gnd 2.080806f
R25 23 24 2.224404
C29 25 gnd 2.080806f
R26 24 25 2.224404
C30 26 gnd 2.080806f
R27 25 26 2.224404
C31 27 gnd 2.080806f
R28 26 27 2.224404
C32 28 gnd 2.080806f
R29 27 28 2.224404
C33 29 gnd 2.080806f
R30 28 29 2.224404
C34 30 gnd 2.080806f
R31 29 30 2.224404
C35 31 gnd 2.080806f
R32 30 31 2.224404
C36 32 gnd 2.080806f
R33 31 32 2.224404
C37 33 gnd 2.080806f
R34 32 33 2.224404
C38 34 gnd 2.080806f
R35 33 34 2.224404
C39 35 gnd 2.080806f
R36 34 35 2.224404
R37 35 g2308_2 2.224404
R38 g2308_2 g2308_1 2.224404
.ends

.subckt netg18 g18_1 g18_0 gnd
C1  g18_1 gnd 2.080806f
C2  g18_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g18_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
R38 g18_1 37 2.224404
.ends

.subckt netg146 g146_0 g146_1 gnd
C1  g146_0 gnd 2.080806f
C2  g146_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g146_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
R38 37 g146_1 2.224404
.ends

.subckt netg29 g29_0 g29_1 gnd
C1  g29_0 gnd 2.080806f
C2  g29_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g29_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
R39 g29_1 38 2.224404
.ends

.subckt netg26 g26_1 g26_0 gnd
C1  g26_1 gnd 2.080806f
C2  g26_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g26_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
R39 g26_1 38 2.224404
.ends

.subckt netg144 g144_0 g144_1 gnd
C1  g144_0 gnd 2.080806f
C2  g144_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g144_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
R39 38 g144_1 2.224404
.ends

.subckt netg2147 g2147_2 g2147_3 g2147_4 g2147_1 g2147_0 g2147_5 gnd
C1  g2147_2 gnd 2.080806f
C2  g2147_3 gnd 2.080806f
C3  g2147_4 gnd 2.080806f
C4  g2147_1 gnd 2.080806f
C5  g2147_0 gnd 2.080806f
C6  g2147_5 gnd 2.080806f
R1 g2147_0 g2147_2 2.224404
C7 1 gnd 2.080806f
R2 g2147_2 1 2.224404
R3 1 g2147_5 2.224404
C8 2 gnd 2.080806f
R4 g2147_5 2 2.224404
C9 3 gnd 2.080806f
R5 2 3 2.224404
R6 3 g2147_4 2.224404
C10 4 gnd 2.080806f
R7 g2147_4 4 2.224404
C11 5 gnd 2.080806f
R8 4 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 23 22 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
R31 27 g2147_3 2.224404
C34 28 gnd 2.080806f
R32 28 g2147_3 2.224404
C35 29 gnd 2.080806f
R33 29 28 2.224404
C36 30 gnd 2.080806f
R34 30 29 2.224404
C37 31 gnd 2.080806f
R35 30 31 2.224404
C38 32 gnd 2.080806f
R36 31 32 2.224404
C39 33 gnd 2.080806f
R37 32 33 2.224404
C40 34 gnd 2.080806f
R38 33 34 2.224404
C41 35 gnd 2.080806f
R39 34 35 2.224404
C42 36 gnd 2.080806f
R40 35 36 2.224404
C43 37 gnd 2.080806f
R41 36 37 2.224404
C44 38 gnd 2.080806f
R42 37 38 2.224404
C45 39 gnd 2.080806f
R43 38 39 2.224404
C46 40 gnd 2.080806f
R44 39 40 2.224404
R45 40 g2147_1 2.224404
.ends

.subckt netg1710 g1710_4 g1710_2 g1710_3 g1710_5 g1710_1 g1710_0 gnd
C1  g1710_4 gnd 2.080806f
C2  g1710_2 gnd 2.080806f
C3  g1710_3 gnd 2.080806f
C4  g1710_5 gnd 2.080806f
C5  g1710_1 gnd 2.080806f
C6  g1710_0 gnd 2.080806f
R1 g1710_3 g1710_0 2.224404
C7 1 gnd 2.080806f
R2 1 g1710_0 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
R9 7 g1710_2 2.224404
C14 8 gnd 2.080806f
R10 8 g1710_2 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
R15 12 g1710_1 2.224404
C19 13 gnd 2.080806f
R16 13 g1710_1 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 36 35 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
R43 39 g1710_5 2.224404
C46 40 gnd 2.080806f
R44 g1710_5 40 2.224404
R45 40 g1710_4 2.224404
.ends

.subckt netg132 g132_0 g132_1 gnd
C1  g132_0 gnd 2.080806f
C2  g132_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g132_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
R40 39 g132_1 2.224404
.ends

.subckt netg7525 g7525_1 g7525_0 gnd
C1  g7525_1 gnd 2.080806f
C2  g7525_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7525_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
R40 g7525_1 39 2.224404
.ends

.subckt netg519 g519_5 g519_3 g519_6 g519_4 g519_1 g519_0 g519_2 gnd
C1  g519_5 gnd 2.080806f
C2  g519_3 gnd 2.080806f
C3  g519_6 gnd 2.080806f
C4  g519_4 gnd 2.080806f
C5  g519_1 gnd 2.080806f
C6  g519_0 gnd 2.080806f
C7  g519_2 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g519_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
C10 3 gnd 2.080806f
R3 2 3 2.224404
C11 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g519_3 2.224404
C12 5 gnd 2.080806f
R6 5 g519_0 2.224404
C13 6 gnd 2.080806f
R7 6 5 2.224404
C14 7 gnd 2.080806f
R8 7 6 2.224404
C15 8 gnd 2.080806f
R9 8 7 2.224404
C16 9 gnd 2.080806f
R10 9 8 2.224404
C17 10 gnd 2.080806f
R11 10 9 2.224404
C18 11 gnd 2.080806f
R12 11 10 2.224404
C19 12 gnd 2.080806f
R13 12 11 2.224404
C20 13 gnd 2.080806f
R14 13 12 2.224404
C21 14 gnd 2.080806f
R15 14 13 2.224404
C22 15 gnd 2.080806f
R16 15 14 2.224404
C23 16 gnd 2.080806f
R17 16 15 2.224404
R18 g519_1 16 2.224404
C24 17 gnd 2.080806f
R19 17 g519_1 2.224404
C25 18 gnd 2.080806f
R20 18 17 2.224404
C26 19 gnd 2.080806f
R21 19 18 2.224404
C27 20 gnd 2.080806f
R22 20 19 2.224404
C28 21 gnd 2.080806f
R23 21 20 2.224404
R24 g519_4 21 2.224404
C29 22 gnd 2.080806f
R25 22 g519_4 2.224404
R26 g519_6 22 2.224404
C30 23 gnd 2.080806f
R27 g519_3 23 2.224404
C31 24 gnd 2.080806f
R28 23 24 2.224404
C32 25 gnd 2.080806f
R29 24 25 2.224404
C33 26 gnd 2.080806f
R30 25 26 2.224404
C34 27 gnd 2.080806f
R31 26 27 2.224404
C35 28 gnd 2.080806f
R32 27 28 2.224404
C36 29 gnd 2.080806f
R33 28 29 2.224404
C37 30 gnd 2.080806f
R34 29 30 2.224404
C38 31 gnd 2.080806f
R35 30 31 2.224404
C39 32 gnd 2.080806f
R36 31 32 2.224404
C40 33 gnd 2.080806f
R37 32 33 2.224404
C41 34 gnd 2.080806f
R38 33 34 2.224404
R39 34 g519_2 2.224404
C42 35 gnd 2.080806f
R40 35 g519_2 2.224404
C43 36 gnd 2.080806f
R41 36 35 2.224404
C44 37 gnd 2.080806f
R42 37 36 2.224404
R43 37 g519_5 2.224404
.ends

.subckt netg2175 g2175_4 g2175_6 g2175_5 g2175_3 g2175_2 g2175_1 g2175_0 gnd
C1  g2175_4 gnd 2.080806f
C2  g2175_6 gnd 2.080806f
C3  g2175_5 gnd 2.080806f
C4  g2175_3 gnd 2.080806f
C5  g2175_2 gnd 2.080806f
C6  g2175_1 gnd 2.080806f
C7  g2175_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g2175_0 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2175_1 2 2.224404
C10 3 gnd 2.080806f
R4 g2175_1 3 2.224404
R5 g2175_4 3 2.224404
C11 4 gnd 2.080806f
R6 4 g2175_4 2.224404
R7 g2175_6 4 2.224404
C12 5 gnd 2.080806f
R8 5 g2175_1 2.224404
C13 6 gnd 2.080806f
R9 6 5 2.224404
R10 g2175_2 6 2.224404
C14 7 gnd 2.080806f
R11 g2175_0 7 2.224404
C15 8 gnd 2.080806f
R12 7 8 2.224404
C16 9 gnd 2.080806f
R13 8 9 2.224404
C17 10 gnd 2.080806f
R14 9 10 2.224404
C18 11 gnd 2.080806f
R15 10 11 2.224404
C19 12 gnd 2.080806f
R16 11 12 2.224404
C20 13 gnd 2.080806f
R17 12 13 2.224404
C21 14 gnd 2.080806f
R18 13 14 2.224404
C22 15 gnd 2.080806f
R19 14 15 2.224404
C23 16 gnd 2.080806f
R20 15 16 2.224404
R21 16 g2175_3 2.224404
C24 17 gnd 2.080806f
R22 16 17 2.224404
C25 18 gnd 2.080806f
R23 17 18 2.224404
C26 19 gnd 2.080806f
R24 18 19 2.224404
C27 20 gnd 2.080806f
R25 19 20 2.224404
C28 21 gnd 2.080806f
R26 20 21 2.224404
C29 22 gnd 2.080806f
R27 21 22 2.224404
C30 23 gnd 2.080806f
R28 22 23 2.224404
C31 24 gnd 2.080806f
R29 23 24 2.224404
C32 25 gnd 2.080806f
R30 24 25 2.224404
C33 26 gnd 2.080806f
R31 25 26 2.224404
C34 27 gnd 2.080806f
R32 26 27 2.224404
C35 28 gnd 2.080806f
R33 27 28 2.224404
C36 29 gnd 2.080806f
R34 28 29 2.224404
C37 30 gnd 2.080806f
R35 30 29 2.224404
C38 31 gnd 2.080806f
R36 30 31 2.224404
C39 32 gnd 2.080806f
R37 31 32 2.224404
C40 33 gnd 2.080806f
R38 32 33 2.224404
C41 34 gnd 2.080806f
R39 33 34 2.224404
C42 35 gnd 2.080806f
R40 34 35 2.224404
C43 36 gnd 2.080806f
R41 35 36 2.224404
C44 37 gnd 2.080806f
R42 36 37 2.224404
C45 38 gnd 2.080806f
R43 37 38 2.224404
C46 39 gnd 2.080806f
R44 38 39 2.224404
C47 40 gnd 2.080806f
R45 39 40 2.224404
R46 40 g2175_5 2.224404
.ends

.subckt netg1632 g1632_2 g1632_4 g1632_1 g1632_5 g1632_3 g1632_0 gnd
C1  g1632_2 gnd 2.080806f
C2  g1632_4 gnd 2.080806f
C3  g1632_1 gnd 2.080806f
C4  g1632_5 gnd 2.080806f
C5  g1632_3 gnd 2.080806f
C6  g1632_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1632_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
R3 2 g1632_2 2.224404
R4 g1632_2 g1632_1 2.224404
C9 3 gnd 2.080806f
R5 g1632_0 3 2.224404
C10 4 gnd 2.080806f
R6 3 4 2.224404
R7 4 g1632_5 2.224404
C11 5 gnd 2.080806f
R8 g1632_1 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 30 29 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
R43 39 g1632_4 2.224404
C46 40 gnd 2.080806f
R44 g1632_4 40 2.224404
R45 40 g1632_3 2.224404
.ends

.subckt netg32 g32_0 g32_1 g32_2 gnd
C1  g32_0 gnd 2.080806f
C2  g32_1 gnd 2.080806f
C3  g32_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g32_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g32_1 2.224404
C6 3 gnd 2.080806f
R4 3 g32_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
R40 g32_2 38 2.224404
.ends

.subckt netg7502 g7502_0 g7502_1 gnd
C1  g7502_0 gnd 2.080806f
C2  g7502_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7502_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
R40 g7502_1 39 2.224404
.ends

.subckt netg7522 g7522_0 g7522_1 gnd
C1  g7522_0 gnd 2.080806f
C2  g7522_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7522_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
R41 40 g7522_1 2.224404
.ends

.subckt netg7482 g7482_0 g7482_1 gnd
C1  g7482_0 gnd 2.080806f
C2  g7482_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7482_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
R41 40 g7482_1 2.224404
.ends

.subckt netg446 g446_1 g446_3 g446_0 g446_2 gnd
C1  g446_1 gnd 2.080806f
C2  g446_3 gnd 2.080806f
C3  g446_0 gnd 2.080806f
C4  g446_2 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g446_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 8 9 2.224404
C14 10 gnd 2.080806f
R10 9 10 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
C16 12 gnd 2.080806f
R12 11 12 2.224404
C17 13 gnd 2.080806f
R13 12 13 2.224404
C18 14 gnd 2.080806f
R14 13 14 2.224404
C19 15 gnd 2.080806f
R15 14 15 2.224404
C20 16 gnd 2.080806f
R16 15 16 2.224404
C21 17 gnd 2.080806f
R17 16 17 2.224404
C22 18 gnd 2.080806f
R18 17 18 2.224404
C23 19 gnd 2.080806f
R19 18 19 2.224404
C24 20 gnd 2.080806f
R20 19 20 2.224404
C25 21 gnd 2.080806f
R21 20 21 2.224404
C26 22 gnd 2.080806f
R22 21 22 2.224404
C27 23 gnd 2.080806f
R23 22 23 2.224404
C28 24 gnd 2.080806f
R24 23 24 2.224404
C29 25 gnd 2.080806f
R25 24 25 2.224404
C30 26 gnd 2.080806f
R26 25 26 2.224404
C31 27 gnd 2.080806f
R27 26 27 2.224404
C32 28 gnd 2.080806f
R28 27 28 2.224404
R29 g446_3 28 2.224404
C33 29 gnd 2.080806f
R30 28 29 2.224404
C34 30 gnd 2.080806f
R31 29 30 2.224404
C35 31 gnd 2.080806f
R32 30 31 2.224404
C36 32 gnd 2.080806f
R33 31 32 2.224404
C37 33 gnd 2.080806f
R34 32 33 2.224404
C38 34 gnd 2.080806f
R35 33 34 2.224404
C39 35 gnd 2.080806f
R36 34 35 2.224404
C40 36 gnd 2.080806f
R37 35 36 2.224404
C41 37 gnd 2.080806f
R38 36 37 2.224404
C42 38 gnd 2.080806f
R39 37 38 2.224404
C43 39 gnd 2.080806f
R40 38 39 2.224404
C44 40 gnd 2.080806f
R41 39 40 2.224404
C45 41 gnd 2.080806f
R42 40 41 2.224404
C46 42 gnd 2.080806f
R43 41 42 2.224404
C47 43 gnd 2.080806f
R44 42 43 2.224404
C48 44 gnd 2.080806f
R45 43 44 2.224404
C49 45 gnd 2.080806f
R46 44 45 2.224404
C50 46 gnd 2.080806f
R47 45 46 2.224404
C51 47 gnd 2.080806f
R48 46 47 2.224404
C52 48 gnd 2.080806f
R49 47 48 2.224404
C53 49 gnd 2.080806f
R50 48 49 2.224404
C54 50 gnd 2.080806f
R51 49 50 2.224404
C55 51 gnd 2.080806f
R52 50 51 2.224404
C56 52 gnd 2.080806f
R53 51 52 2.224404
C57 53 gnd 2.080806f
R54 52 53 2.224404
C58 54 gnd 2.080806f
R55 53 54 2.224404
C59 55 gnd 2.080806f
R56 54 55 2.224404
C60 56 gnd 2.080806f
R57 55 56 2.224404
R58 56 g446_1 2.224404
C61 57 gnd 2.080806f
R59 g446_1 57 2.224404
R60 57 g446_2 2.224404
.ends

.subckt netg62 g62_1 g62_2 g62_0 gnd
C1  g62_1 gnd 2.080806f
C2  g62_2 gnd 2.080806f
C3  g62_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g62_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 34 35 2.224404
C39 36 gnd 2.080806f
R36 35 36 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 38 39 2.224404
R40 39 g62_1 2.224404
R41 g62_1 g62_2 2.224404
.ends

.subckt netg24 g24_0 g24_1 gnd
C1  g24_0 gnd 2.080806f
C2  g24_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g24_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
R41 g24_1 40 2.224404
.ends

.subckt netg129 g129_0 g129_1 gnd
C1  g129_0 gnd 2.080806f
C2  g129_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g129_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
R41 40 g129_1 2.224404
.ends

.subckt netg130 g130_1 g130_0 gnd
C1  g130_1 gnd 2.080806f
C2  g130_0 gnd 2.080806f
.ends

.subckt netg154 g154_1 g154_0 gnd
C1  g154_1 gnd 2.080806f
C2  g154_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g154_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
R41 40 g154_1 2.224404
.ends

.subckt netg2215 g2215_1 g2215_4 g2215_2 g2215_5 g2215_0 g2215_3 gnd
C1  g2215_1 gnd 2.080806f
C2  g2215_4 gnd 2.080806f
C3  g2215_2 gnd 2.080806f
C4  g2215_5 gnd 2.080806f
C5  g2215_0 gnd 2.080806f
C6  g2215_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2215_0 2.224404
R2 g2215_3 1 2.224404
C8 2 gnd 2.080806f
R3 2 g2215_3 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
R7 g2215_1 5 2.224404
R8 g2215_5 g2215_1 2.224404
C12 6 gnd 2.080806f
R9 g2215_0 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 32 31 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 35 34 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
R43 g2215_4 39 2.224404
C46 40 gnd 2.080806f
R44 39 40 2.224404
C47 41 gnd 2.080806f
R45 40 41 2.224404
C48 42 gnd 2.080806f
R46 41 42 2.224404
C49 43 gnd 2.080806f
R47 42 43 2.224404
C50 44 gnd 2.080806f
R48 43 44 2.224404
C51 45 gnd 2.080806f
R49 44 45 2.224404
C52 46 gnd 2.080806f
R50 45 46 2.224404
C53 47 gnd 2.080806f
R51 47 46 2.224404
C54 48 gnd 2.080806f
R52 48 47 2.224404
R53 g2215_2 48 2.224404
.ends

.subckt netg63 g63_0 g63_2 g63_1 gnd
C1  g63_0 gnd 2.080806f
C2  g63_2 gnd 2.080806f
C3  g63_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g63_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g63_2 3 2.224404
C7 4 gnd 2.080806f
R5 4 g63_2 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
R42 g63_1 40 2.224404
.ends

.subckt netg131 g131_0 g131_1 gnd
C1  g131_0 gnd 2.080806f
C2  g131_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g131_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
R42 g131_1 41 2.224404
.ends

.subckt netg7524 g7524_0 g7524_1 gnd
C1  g7524_0 gnd 2.080806f
C2  g7524_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7524_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
R43 g7524_1 42 2.224404
.ends

.subckt netg61 g61_1 g61_2 g61_0 gnd
C1  g61_1 gnd 2.080806f
C2  g61_2 gnd 2.080806f
C3  g61_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g61_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g61_2 2.224404
C6 3 gnd 2.080806f
R4 3 g61_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
R43 g61_1 41 2.224404
.ends

.subckt netg25 g25_0 g25_1 gnd
C1  g25_0 gnd 2.080806f
C2  g25_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g25_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
R43 42 g25_1 2.224404
.ends

.subckt netg2127 g2127_2 g2127_5 g2127_3 g2127_4 g2127_0 g2127_1 gnd
C1  g2127_2 gnd 2.080806f
C2  g2127_5 gnd 2.080806f
C3  g2127_3 gnd 2.080806f
C4  g2127_4 gnd 2.080806f
C5  g2127_0 gnd 2.080806f
C6  g2127_1 gnd 2.080806f
R1 g2127_0 g2127_3 2.224404
C7 1 gnd 2.080806f
R2 1 g2127_3 2.224404
R3 1 g2127_1 2.224404
C8 2 gnd 2.080806f
R4 g2127_3 2 2.224404
C9 3 gnd 2.080806f
R5 2 3 2.224404
C10 4 gnd 2.080806f
R6 3 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
R14 11 g2127_2 2.224404
C18 12 gnd 2.080806f
R15 g2127_2 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 41 40 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 45 44 2.224404
C52 46 gnd 2.080806f
R49 46 45 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
R51 47 g2127_5 2.224404
C54 48 gnd 2.080806f
R52 48 g2127_5 2.224404
C55 49 gnd 2.080806f
R53 49 48 2.224404
C56 50 gnd 2.080806f
R54 50 49 2.224404
R55 g2127_4 50 2.224404
.ends

.subckt netg28 g28_1 g28_0 gnd
C1  g28_1 gnd 2.080806f
C2  g28_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g28_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
R44 43 g28_1 2.224404
.ends

.subckt netg2 g2_1 g2_3 g2_2 g2_0 gnd
C1  g2_1 gnd 2.080806f
C2  g2_3 gnd 2.080806f
C3  g2_2 gnd 2.080806f
C4  g2_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g2_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
R5 4 g2_2 2.224404
C9 5 gnd 2.080806f
R6 g2_2 5 2.224404
C10 6 gnd 2.080806f
R7 5 6 2.224404
C11 7 gnd 2.080806f
R8 6 7 2.224404
C12 8 gnd 2.080806f
R9 7 8 2.224404
C13 9 gnd 2.080806f
R10 8 9 2.224404
C14 10 gnd 2.080806f
R11 9 10 2.224404
C15 11 gnd 2.080806f
R12 10 11 2.224404
C16 12 gnd 2.080806f
R13 11 12 2.224404
C17 13 gnd 2.080806f
R14 12 13 2.224404
C18 14 gnd 2.080806f
R15 13 14 2.224404
C19 15 gnd 2.080806f
R16 14 15 2.224404
C20 16 gnd 2.080806f
R17 15 16 2.224404
C21 17 gnd 2.080806f
R18 16 17 2.224404
C22 18 gnd 2.080806f
R19 17 18 2.224404
C23 19 gnd 2.080806f
R20 18 19 2.224404
C24 20 gnd 2.080806f
R21 19 20 2.224404
C25 21 gnd 2.080806f
R22 20 21 2.224404
C26 22 gnd 2.080806f
R23 21 22 2.224404
C27 23 gnd 2.080806f
R24 22 23 2.224404
C28 24 gnd 2.080806f
R25 23 24 2.224404
C29 25 gnd 2.080806f
R26 24 25 2.224404
C30 26 gnd 2.080806f
R27 25 26 2.224404
C31 27 gnd 2.080806f
R28 26 27 2.224404
C32 28 gnd 2.080806f
R29 27 28 2.224404
C33 29 gnd 2.080806f
R30 28 29 2.224404
C34 30 gnd 2.080806f
R31 29 30 2.224404
C35 31 gnd 2.080806f
R32 30 31 2.224404
C36 32 gnd 2.080806f
R33 31 32 2.224404
C37 33 gnd 2.080806f
R34 32 33 2.224404
C38 34 gnd 2.080806f
R35 33 34 2.224404
C39 35 gnd 2.080806f
R36 34 35 2.224404
C40 36 gnd 2.080806f
R37 35 36 2.224404
C41 37 gnd 2.080806f
R38 36 37 2.224404
C42 38 gnd 2.080806f
R39 37 38 2.224404
C43 39 gnd 2.080806f
R40 38 39 2.224404
C44 40 gnd 2.080806f
R41 39 40 2.224404
C45 41 gnd 2.080806f
R42 40 41 2.224404
R43 41 g2_1 2.224404
R44 41 g2_3 2.224404
.ends

.subckt netg19 g19_0 g19_1 gnd
C1  g19_0 gnd 2.080806f
C2  g19_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g19_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
R44 g19_1 43 2.224404
.ends

.subckt netg141 g141_1 g141_0 gnd
C1  g141_1 gnd 2.080806f
C2  g141_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g141_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
R44 g141_1 43 2.224404
.ends

.subckt netg7518 g7518_1 g7518_0 gnd
C1  g7518_1 gnd 2.080806f
C2  g7518_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7518_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
R44 g7518_1 43 2.224404
.ends

.subckt netg5 g5_0 g5_2 g5_1 gnd
C1  g5_0 gnd 2.080806f
C2  g5_2 gnd 2.080806f
C3  g5_1 gnd 2.080806f
R1 g5_0 g5_2 2.224404
C4 1 gnd 2.080806f
R2 1 g5_2 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
R44 g5_1 42 2.224404
.ends

.subckt netg66 g66_2 g66_0 g66_1 gnd
C1  g66_2 gnd 2.080806f
C2  g66_0 gnd 2.080806f
C3  g66_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g66_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
R7 g66_1 6 2.224404
C10 7 gnd 2.080806f
R8 7 g66_0 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
R53 g66_2 51 2.224404
.ends

.subckt netg7457 g7457_0 g7457_1 gnd
C1  g7457_0 gnd 2.080806f
C2  g7457_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7457_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
R44 43 g7457_1 2.224404
.ends

.subckt netg27 g27_1 g27_0 gnd
C1  g27_1 gnd 2.080806f
C2  g27_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g27_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
R45 g27_1 44 2.224404
.ends

.subckt netg6787 g6787_1 g6787_2 g6787_0 gnd
C1  g6787_1 gnd 2.080806f
C2  g6787_2 gnd 2.080806f
C3  g6787_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g6787_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
R11 10 g6787_2 2.224404
C14 11 gnd 2.080806f
R12 11 g6787_0 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
R45 g6787_1 43 2.224404
.ends

.subckt netg49 g49_4 g49_0 g49_2 g49_3 g49_1 gnd
C1  g49_4 gnd 2.080806f
C2  g49_0 gnd 2.080806f
C3  g49_2 gnd 2.080806f
C4  g49_3 gnd 2.080806f
C5  g49_1 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g49_0 1 2.224404
R2 1 g49_4 2.224404
C7 2 gnd 2.080806f
R3 2 g49_4 2.224404
C8 3 gnd 2.080806f
R4 2 3 2.224404
C9 4 gnd 2.080806f
R5 3 4 2.224404
R6 4 g49_3 2.224404
R7 g49_3 g49_2 2.224404
C10 5 gnd 2.080806f
R8 5 g49_0 2.224404
C11 6 gnd 2.080806f
R9 6 5 2.224404
C12 7 gnd 2.080806f
R10 7 6 2.224404
C13 8 gnd 2.080806f
R11 8 7 2.224404
C14 9 gnd 2.080806f
R12 9 8 2.224404
C15 10 gnd 2.080806f
R13 10 9 2.224404
C16 11 gnd 2.080806f
R14 11 10 2.224404
C17 12 gnd 2.080806f
R15 12 11 2.224404
C18 13 gnd 2.080806f
R16 13 12 2.224404
C19 14 gnd 2.080806f
R17 14 13 2.224404
C20 15 gnd 2.080806f
R18 15 14 2.224404
C21 16 gnd 2.080806f
R19 16 15 2.224404
C22 17 gnd 2.080806f
R20 17 16 2.224404
C23 18 gnd 2.080806f
R21 18 17 2.224404
C24 19 gnd 2.080806f
R22 19 18 2.224404
C25 20 gnd 2.080806f
R23 20 19 2.224404
C26 21 gnd 2.080806f
R24 21 20 2.224404
C27 22 gnd 2.080806f
R25 22 21 2.224404
C28 23 gnd 2.080806f
R26 23 22 2.224404
C29 24 gnd 2.080806f
R27 24 23 2.224404
C30 25 gnd 2.080806f
R28 25 24 2.224404
C31 26 gnd 2.080806f
R29 26 25 2.224404
C32 27 gnd 2.080806f
R30 27 26 2.224404
C33 28 gnd 2.080806f
R31 28 27 2.224404
C34 29 gnd 2.080806f
R32 29 28 2.224404
C35 30 gnd 2.080806f
R33 30 29 2.224404
C36 31 gnd 2.080806f
R34 31 30 2.224404
C37 32 gnd 2.080806f
R35 32 31 2.224404
C38 33 gnd 2.080806f
R36 33 32 2.224404
C39 34 gnd 2.080806f
R37 34 33 2.224404
C40 35 gnd 2.080806f
R38 35 34 2.224404
C41 36 gnd 2.080806f
R39 36 35 2.224404
C42 37 gnd 2.080806f
R40 37 36 2.224404
C43 38 gnd 2.080806f
R41 38 37 2.224404
C44 39 gnd 2.080806f
R42 39 38 2.224404
C45 40 gnd 2.080806f
R43 40 39 2.224404
C46 41 gnd 2.080806f
R44 41 40 2.224404
C47 42 gnd 2.080806f
R45 42 41 2.224404
C48 43 gnd 2.080806f
R46 43 42 2.224404
R47 g49_1 43 2.224404
.ends

.subckt netg17 g17_0 g17_1 gnd
C1  g17_0 gnd 2.080806f
C2  g17_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g17_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
R45 44 g17_1 2.224404
.ends

.subckt netg76 g76_0 g76_1 gnd
C1  g76_0 gnd 2.080806f
C2  g76_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g76_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
R45 44 g76_1 2.224404
.ends

.subckt netg7536 g7536_0 g7536_1 gnd
C1  g7536_0 gnd 2.080806f
C2  g7536_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7536_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
R45 44 g7536_1 2.224404
.ends

.subckt netg7464 g7464_1 g7464_0 gnd
C1  g7464_1 gnd 2.080806f
C2  g7464_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7464_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
R46 g7464_1 45 2.224404
.ends

.subckt netg7468 g7468_1 g7468_0 gnd
C1  g7468_1 gnd 2.080806f
C2  g7468_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7468_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
R46 45 g7468_1 2.224404
.ends

.subckt netg7509 g7509_1 g7509_0 gnd
C1  g7509_1 gnd 2.080806f
C2  g7509_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7509_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
R47 46 g7509_1 2.224404
.ends

.subckt netg6771 g6771_4 g6771_6 g6771_5 g6771_0 g6771_3 g6771_1 g6771_2 gnd
C1  g6771_4 gnd 2.080806f
C2  g6771_6 gnd 2.080806f
C3  g6771_5 gnd 2.080806f
C4  g6771_0 gnd 2.080806f
C5  g6771_3 gnd 2.080806f
C6  g6771_1 gnd 2.080806f
C7  g6771_2 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g6771_0 1 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
C10 3 gnd 2.080806f
R3 2 3 2.224404
R4 g6771_5 3 2.224404
C11 4 gnd 2.080806f
R5 4 g6771_5 2.224404
R6 g6771_3 4 2.224404
R7 g6771_6 g6771_3 2.224404
C12 5 gnd 2.080806f
R8 g6771_3 5 2.224404
R9 5 g6771_2 2.224404
C13 6 gnd 2.080806f
R10 6 g6771_6 2.224404
C14 7 gnd 2.080806f
R11 7 6 2.224404
C15 8 gnd 2.080806f
R12 8 7 2.224404
C16 9 gnd 2.080806f
R13 9 8 2.224404
C17 10 gnd 2.080806f
R14 10 9 2.224404
C18 11 gnd 2.080806f
R15 11 10 2.224404
C19 12 gnd 2.080806f
R16 12 11 2.224404
C20 13 gnd 2.080806f
R17 13 12 2.224404
C21 14 gnd 2.080806f
R18 14 13 2.224404
C22 15 gnd 2.080806f
R19 14 15 2.224404
C23 16 gnd 2.080806f
R20 16 15 2.224404
C24 17 gnd 2.080806f
R21 17 16 2.224404
C25 18 gnd 2.080806f
R22 18 17 2.224404
C26 19 gnd 2.080806f
R23 19 18 2.224404
C27 20 gnd 2.080806f
R24 20 19 2.224404
C28 21 gnd 2.080806f
R25 21 20 2.224404
C29 22 gnd 2.080806f
R26 22 21 2.224404
C30 23 gnd 2.080806f
R27 23 22 2.224404
C31 24 gnd 2.080806f
R28 23 24 2.224404
R29 g6771_4 24 2.224404
C32 25 gnd 2.080806f
R30 g6771_4 25 2.224404
C33 26 gnd 2.080806f
R31 26 25 2.224404
C34 27 gnd 2.080806f
R32 27 26 2.224404
C35 28 gnd 2.080806f
R33 28 27 2.224404
C36 29 gnd 2.080806f
R34 29 28 2.224404
C37 30 gnd 2.080806f
R35 29 30 2.224404
C38 31 gnd 2.080806f
R36 30 31 2.224404
C39 32 gnd 2.080806f
R37 31 32 2.224404
C40 33 gnd 2.080806f
R38 32 33 2.224404
C41 34 gnd 2.080806f
R39 33 34 2.224404
C42 35 gnd 2.080806f
R40 35 34 2.224404
C43 36 gnd 2.080806f
R41 36 35 2.224404
C44 37 gnd 2.080806f
R42 37 36 2.224404
C45 38 gnd 2.080806f
R43 37 38 2.224404
C46 39 gnd 2.080806f
R44 38 39 2.224404
C47 40 gnd 2.080806f
R45 39 40 2.224404
C48 41 gnd 2.080806f
R46 40 41 2.224404
C49 42 gnd 2.080806f
R47 41 42 2.224404
C50 43 gnd 2.080806f
R48 42 43 2.224404
C51 44 gnd 2.080806f
R49 44 43 2.224404
C52 45 gnd 2.080806f
R50 44 45 2.224404
R51 g6771_1 45 2.224404
.ends

.subckt netg7505 g7505_1 g7505_0 gnd
C1  g7505_1 gnd 2.080806f
C2  g7505_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7505_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
R47 g7505_1 46 2.224404
.ends

.subckt netg118 g118_0 g118_1 gnd
C1  g118_0 gnd 2.080806f
C2  g118_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g118_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
R47 46 g118_1 2.224404
.ends

.subckt netg7463 g7463_0 g7463_1 gnd
C1  g7463_0 gnd 2.080806f
C2  g7463_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7463_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
R47 g7463_1 46 2.224404
.ends

.subckt netg7469 g7469_0 g7469_1 gnd
C1  g7469_0 gnd 2.080806f
C2  g7469_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7469_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
R48 47 g7469_1 2.224404
.ends

.subckt netg7508 g7508_1 g7508_0 gnd
C1  g7508_1 gnd 2.080806f
C2  g7508_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7508_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
R48 47 g7508_1 2.224404
.ends

.subckt netg7544 g7544_1 g7544_0 gnd
C1  g7544_1 gnd 2.080806f
C2  g7544_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7544_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
R48 g7544_1 47 2.224404
.ends

.subckt netg5370 g5370_3 g5370_2 g5370_9 g5370_8 g5370_7 g5370_6 g5370_0 g5370_1 g5370_4 g5370_5 gnd
C1  g5370_3 gnd 2.080806f
C2  g5370_2 gnd 2.080806f
C3  g5370_9 gnd 2.080806f
C4  g5370_8 gnd 2.080806f
C5  g5370_7 gnd 2.080806f
C6  g5370_6 gnd 2.080806f
C7  g5370_0 gnd 2.080806f
C8  g5370_1 gnd 2.080806f
C9  g5370_4 gnd 2.080806f
C10  g5370_5 gnd 2.080806f
C11 1 gnd 2.080806f
R1 g5370_0 1 2.224404
C12 2 gnd 2.080806f
R2 1 2 2.224404
C13 3 gnd 2.080806f
R3 2 3 2.224404
R4 g5370_7 3 2.224404
C14 4 gnd 2.080806f
R5 4 g5370_0 2.224404
C15 5 gnd 2.080806f
R6 4 5 2.224404
R7 g5370_3 5 2.224404
C16 6 gnd 2.080806f
R8 6 g5370_3 2.224404
C17 7 gnd 2.080806f
R9 7 6 2.224404
C18 8 gnd 2.080806f
R10 7 8 2.224404
C19 9 gnd 2.080806f
R11 8 9 2.224404
C20 10 gnd 2.080806f
R12 9 10 2.224404
R13 10 g5370_5 2.224404
C21 11 gnd 2.080806f
R14 9 11 2.224404
C22 12 gnd 2.080806f
R15 11 12 2.224404
R16 12 g5370_8 2.224404
C23 13 gnd 2.080806f
R17 g5370_8 13 2.224404
C24 14 gnd 2.080806f
R18 13 14 2.224404
C25 15 gnd 2.080806f
R19 14 15 2.224404
C26 16 gnd 2.080806f
R20 15 16 2.224404
R21 g5370_2 16 2.224404
C27 17 gnd 2.080806f
R22 g5370_2 17 2.224404
R23 g5370_4 17 2.224404
R24 g5370_9 7 2.224404
R25 g5370_6 8 2.224404
C28 18 gnd 2.080806f
R26 g5370_4 18 2.224404
C29 19 gnd 2.080806f
R27 18 19 2.224404
C30 20 gnd 2.080806f
R28 19 20 2.224404
C31 21 gnd 2.080806f
R29 21 20 2.224404
C32 22 gnd 2.080806f
R30 22 21 2.224404
C33 23 gnd 2.080806f
R31 23 22 2.224404
C34 24 gnd 2.080806f
R32 24 23 2.224404
C35 25 gnd 2.080806f
R33 24 25 2.224404
C36 26 gnd 2.080806f
R34 26 25 2.224404
C37 27 gnd 2.080806f
R35 27 26 2.224404
C38 28 gnd 2.080806f
R36 28 27 2.224404
C39 29 gnd 2.080806f
R37 28 29 2.224404
C40 30 gnd 2.080806f
R38 29 30 2.224404
C41 31 gnd 2.080806f
R39 30 31 2.224404
C42 32 gnd 2.080806f
R40 32 31 2.224404
C43 33 gnd 2.080806f
R41 33 32 2.224404
C44 34 gnd 2.080806f
R42 34 33 2.224404
C45 35 gnd 2.080806f
R43 35 34 2.224404
C46 36 gnd 2.080806f
R44 36 35 2.224404
C47 37 gnd 2.080806f
R45 37 36 2.224404
C48 38 gnd 2.080806f
R46 38 37 2.224404
C49 39 gnd 2.080806f
R47 39 38 2.224404
C50 40 gnd 2.080806f
R48 40 39 2.224404
C51 41 gnd 2.080806f
R49 41 40 2.224404
C52 42 gnd 2.080806f
R50 42 41 2.224404
C53 43 gnd 2.080806f
R51 43 42 2.224404
C54 44 gnd 2.080806f
R52 43 44 2.224404
C55 45 gnd 2.080806f
R53 44 45 2.224404
C56 46 gnd 2.080806f
R54 46 45 2.224404
C57 47 gnd 2.080806f
R55 47 46 2.224404
C58 48 gnd 2.080806f
R56 48 47 2.224404
C59 49 gnd 2.080806f
R57 49 48 2.224404
C60 50 gnd 2.080806f
R58 50 49 2.224404
C61 51 gnd 2.080806f
R59 51 50 2.224404
C62 52 gnd 2.080806f
R60 52 51 2.224404
C63 53 gnd 2.080806f
R61 53 52 2.224404
C64 54 gnd 2.080806f
R62 54 53 2.224404
C65 55 gnd 2.080806f
R63 55 54 2.224404
C66 56 gnd 2.080806f
R64 55 56 2.224404
C67 57 gnd 2.080806f
R65 57 56 2.224404
R66 57 g5370_1 2.224404
.ends

.subckt netg1698 g1698_2 g1698_5 g1698_1 g1698_3 g1698_0 g1698_4 gnd
C1  g1698_2 gnd 2.080806f
C2  g1698_5 gnd 2.080806f
C3  g1698_1 gnd 2.080806f
C4  g1698_3 gnd 2.080806f
C5  g1698_0 gnd 2.080806f
C6  g1698_4 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1698_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
C10 4 gnd 2.080806f
R4 3 4 2.224404
C11 5 gnd 2.080806f
R5 4 5 2.224404
C12 6 gnd 2.080806f
R6 5 6 2.224404
C13 7 gnd 2.080806f
R7 6 7 2.224404
C14 8 gnd 2.080806f
R8 7 8 2.224404
C15 9 gnd 2.080806f
R9 8 9 2.224404
C16 10 gnd 2.080806f
R10 9 10 2.224404
R11 10 g1698_2 2.224404
C17 11 gnd 2.080806f
R12 11 g1698_0 2.224404
C18 12 gnd 2.080806f
R13 12 11 2.224404
C19 13 gnd 2.080806f
R14 13 12 2.224404
C20 14 gnd 2.080806f
R15 14 13 2.224404
C21 15 gnd 2.080806f
R16 15 14 2.224404
C22 16 gnd 2.080806f
R17 16 15 2.224404
C23 17 gnd 2.080806f
R18 17 16 2.224404
C24 18 gnd 2.080806f
R19 18 17 2.224404
C25 19 gnd 2.080806f
R20 19 18 2.224404
C26 20 gnd 2.080806f
R21 20 19 2.224404
C27 21 gnd 2.080806f
R22 21 20 2.224404
C28 22 gnd 2.080806f
R23 22 21 2.224404
C29 23 gnd 2.080806f
R24 23 22 2.224404
C30 24 gnd 2.080806f
R25 24 23 2.224404
R26 g1698_3 24 2.224404
C31 25 gnd 2.080806f
R27 25 g1698_3 2.224404
C32 26 gnd 2.080806f
R28 26 25 2.224404
C33 27 gnd 2.080806f
R29 27 26 2.224404
C34 28 gnd 2.080806f
R30 28 27 2.224404
C35 29 gnd 2.080806f
R31 29 28 2.224404
C36 30 gnd 2.080806f
R32 30 29 2.224404
C37 31 gnd 2.080806f
R33 31 30 2.224404
C38 32 gnd 2.080806f
R34 32 31 2.224404
C39 33 gnd 2.080806f
R35 33 32 2.224404
C40 34 gnd 2.080806f
R36 34 33 2.224404
C41 35 gnd 2.080806f
R37 35 34 2.224404
C42 36 gnd 2.080806f
R38 36 35 2.224404
C43 37 gnd 2.080806f
R39 37 36 2.224404
C44 38 gnd 2.080806f
R40 38 37 2.224404
C45 39 gnd 2.080806f
R41 39 38 2.224404
C46 40 gnd 2.080806f
R42 40 39 2.224404
R43 g1698_4 40 2.224404
C47 41 gnd 2.080806f
R44 41 g1698_4 2.224404
R45 g1698_1 41 2.224404
C48 42 gnd 2.080806f
R46 42 g1698_1 2.224404
C49 43 gnd 2.080806f
R47 43 42 2.224404
R48 g1698_5 43 2.224404
.ends

.subckt netg23 g23_1 g23_0 gnd
C1  g23_1 gnd 2.080806f
C2  g23_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g23_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
R48 g23_1 47 2.224404
.ends

.subckt netg7489 g7489_1 g7489_0 gnd
C1  g7489_1 gnd 2.080806f
C2  g7489_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7489_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
R48 g7489_1 47 2.224404
.ends

.subckt netg121 g121_1 g121_0 gnd
C1  g121_1 gnd 2.080806f
C2  g121_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g121_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
R48 47 g121_1 2.224404
.ends

.subckt netg7461 g7461_0 g7461_1 gnd
C1  g7461_0 gnd 2.080806f
C2  g7461_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7461_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
R48 g7461_1 47 2.224404
.ends

.subckt netg7459 g7459_1 g7459_0 gnd
C1  g7459_1 gnd 2.080806f
C2  g7459_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7459_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
R48 g7459_1 47 2.224404
.ends

.subckt netg7481 g7481_1 g7481_0 gnd
C1  g7481_1 gnd 2.080806f
C2  g7481_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7481_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
R48 47 g7481_1 2.224404
.ends

.subckt netg7447 g7447_1 g7447_0 gnd
C1  g7447_1 gnd 2.080806f
C2  g7447_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7447_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
R49 48 g7447_1 2.224404
.ends

.subckt netg7523 g7523_1 g7523_0 gnd
C1  g7523_1 gnd 2.080806f
C2  g7523_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7523_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
R49 g7523_1 48 2.224404
.ends

.subckt netg7446 g7446_0 g7446_1 gnd
C1  g7446_0 gnd 2.080806f
C2  g7446_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7446_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
R49 g7446_1 48 2.224404
.ends

.subckt netg22 g22_1 g22_0 gnd
C1  g22_1 gnd 2.080806f
C2  g22_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g22_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
R49 g22_1 48 2.224404
.ends

.subckt netg50 g50_1 g50_0 g50_2 gnd
C1  g50_1 gnd 2.080806f
C2  g50_0 gnd 2.080806f
C3  g50_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g50_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 34 35 2.224404
C39 36 gnd 2.080806f
R36 35 36 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 38 39 2.224404
C43 40 gnd 2.080806f
R40 39 40 2.224404
C44 41 gnd 2.080806f
R41 40 41 2.224404
C45 42 gnd 2.080806f
R42 41 42 2.224404
C46 43 gnd 2.080806f
R43 42 43 2.224404
C47 44 gnd 2.080806f
R44 43 44 2.224404
C48 45 gnd 2.080806f
R45 44 45 2.224404
C49 46 gnd 2.080806f
R46 45 46 2.224404
C50 47 gnd 2.080806f
R47 46 47 2.224404
R48 47 g50_1 2.224404
R49 g50_1 g50_2 2.224404
.ends

.subckt netg157 g157_1 g157_0 gnd
C1  g157_1 gnd 2.080806f
C2  g157_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g157_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
R49 g157_1 48 2.224404
.ends

.subckt netg7452 g7452_1 g7452_0 gnd
C1  g7452_1 gnd 2.080806f
C2  g7452_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7452_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
R49 g7452_1 48 2.224404
.ends

.subckt netg7543 g7543_1 g7543_0 gnd
C1  g7543_1 gnd 2.080806f
C2  g7543_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7543_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
R49 g7543_1 48 2.224404
.ends

.subckt netg148 g148_0 g148_1 gnd
C1  g148_0 gnd 2.080806f
C2  g148_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g148_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
R49 g148_1 48 2.224404
.ends

.subckt netg2244 g2244_4 g2244_2 g2244_1 g2244_0 g2244_5 g2244_3 gnd
C1  g2244_4 gnd 2.080806f
C2  g2244_2 gnd 2.080806f
C3  g2244_1 gnd 2.080806f
C4  g2244_0 gnd 2.080806f
C5  g2244_5 gnd 2.080806f
C6  g2244_3 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2244_0 2.224404
R2 g2244_5 1 2.224404
C8 2 gnd 2.080806f
R3 2 g2244_5 2.224404
C9 3 gnd 2.080806f
R4 2 3 2.224404
R5 g2244_2 3 2.224404
C10 4 gnd 2.080806f
R6 g2244_5 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
R11 8 g2244_1 2.224404
C15 9 gnd 2.080806f
R12 9 g2244_2 2.224404
C16 10 gnd 2.080806f
R13 10 9 2.224404
C17 11 gnd 2.080806f
R14 11 10 2.224404
C18 12 gnd 2.080806f
R15 12 11 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
R18 g2244_4 14 2.224404
C21 15 gnd 2.080806f
R19 g2244_1 15 2.224404
C22 16 gnd 2.080806f
R20 15 16 2.224404
C23 17 gnd 2.080806f
R21 16 17 2.224404
C24 18 gnd 2.080806f
R22 17 18 2.224404
C25 19 gnd 2.080806f
R23 18 19 2.224404
C26 20 gnd 2.080806f
R24 19 20 2.224404
C27 21 gnd 2.080806f
R25 20 21 2.224404
C28 22 gnd 2.080806f
R26 21 22 2.224404
C29 23 gnd 2.080806f
R27 22 23 2.224404
C30 24 gnd 2.080806f
R28 23 24 2.224404
C31 25 gnd 2.080806f
R29 24 25 2.224404
C32 26 gnd 2.080806f
R30 25 26 2.224404
C33 27 gnd 2.080806f
R31 26 27 2.224404
C34 28 gnd 2.080806f
R32 27 28 2.224404
C35 29 gnd 2.080806f
R33 28 29 2.224404
C36 30 gnd 2.080806f
R34 29 30 2.224404
C37 31 gnd 2.080806f
R35 30 31 2.224404
C38 32 gnd 2.080806f
R36 31 32 2.224404
C39 33 gnd 2.080806f
R37 32 33 2.224404
C40 34 gnd 2.080806f
R38 33 34 2.224404
C41 35 gnd 2.080806f
R39 34 35 2.224404
C42 36 gnd 2.080806f
R40 35 36 2.224404
C43 37 gnd 2.080806f
R41 36 37 2.224404
C44 38 gnd 2.080806f
R42 37 38 2.224404
C45 39 gnd 2.080806f
R43 38 39 2.224404
C46 40 gnd 2.080806f
R44 39 40 2.224404
C47 41 gnd 2.080806f
R45 40 41 2.224404
C48 42 gnd 2.080806f
R46 41 42 2.224404
C49 43 gnd 2.080806f
R47 42 43 2.224404
C50 44 gnd 2.080806f
R48 43 44 2.224404
C51 45 gnd 2.080806f
R49 44 45 2.224404
C52 46 gnd 2.080806f
R50 45 46 2.224404
C53 47 gnd 2.080806f
R51 46 47 2.224404
C54 48 gnd 2.080806f
R52 47 48 2.224404
C55 49 gnd 2.080806f
R53 48 49 2.224404
R54 49 g2244_3 2.224404
.ends

.subckt netg7443 g7443_1 g7443_0 gnd
C1  g7443_1 gnd 2.080806f
C2  g7443_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7443_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
R50 49 g7443_1 2.224404
.ends

.subckt netg158 g158_1 g158_0 gnd
C1  g158_1 gnd 2.080806f
C2  g158_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g158_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
R50 g158_1 49 2.224404
.ends

.subckt netg7453 g7453_0 g7453_1 gnd
C1  g7453_0 gnd 2.080806f
C2  g7453_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7453_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
R50 49 g7453_1 2.224404
.ends

.subckt netg190 g190_1 g190_2 g190_0 gnd
C1  g190_1 gnd 2.080806f
C2  g190_2 gnd 2.080806f
C3  g190_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g190_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 45 44 2.224404
R46 g190_2 45 2.224404
C49 46 gnd 2.080806f
R47 46 g190_2 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
R51 49 g190_1 2.224404
.ends

.subckt netg1704 g1704_5 g1704_1 g1704_2 g1704_0 g1704_4 g1704_3 gnd
C1  g1704_5 gnd 2.080806f
C2  g1704_1 gnd 2.080806f
C3  g1704_2 gnd 2.080806f
C4  g1704_0 gnd 2.080806f
C5  g1704_4 gnd 2.080806f
C6  g1704_3 gnd 2.080806f
R1 g1704_1 g1704_0 2.224404
C7 1 gnd 2.080806f
R2 g1704_0 1 2.224404
R3 1 g1704_3 2.224404
C8 2 gnd 2.080806f
R4 g1704_0 2 2.224404
C9 3 gnd 2.080806f
R5 3 2 2.224404
C10 4 gnd 2.080806f
R6 3 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
R15 12 g1704_2 2.224404
C19 13 gnd 2.080806f
R16 13 g1704_2 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 19 18 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 44 43 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 46 45 2.224404
R50 46 g1704_4 2.224404
C53 47 gnd 2.080806f
R51 g1704_4 47 2.224404
C54 48 gnd 2.080806f
R52 47 48 2.224404
C55 49 gnd 2.080806f
R53 48 49 2.224404
C56 50 gnd 2.080806f
R54 49 50 2.224404
C57 51 gnd 2.080806f
R55 50 51 2.224404
C58 52 gnd 2.080806f
R56 51 52 2.224404
C59 53 gnd 2.080806f
R57 52 53 2.224404
C60 54 gnd 2.080806f
R58 53 54 2.224404
C61 55 gnd 2.080806f
R59 54 55 2.224404
C62 56 gnd 2.080806f
R60 55 56 2.224404
C63 57 gnd 2.080806f
R61 56 57 2.224404
R62 57 g1704_5 2.224404
.ends

.subckt netg7530 g7530_1 g7530_0 gnd
C1  g7530_1 gnd 2.080806f
C2  g7530_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7530_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
R51 50 g7530_1 2.224404
.ends

.subckt netg149 g149_1 g149_0 gnd
C1  g149_1 gnd 2.080806f
C2  g149_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g149_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
R51 50 g149_1 2.224404
.ends

.subckt netg7542 g7542_1 g7542_0 gnd
C1  g7542_1 gnd 2.080806f
C2  g7542_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7542_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
R51 50 g7542_1 2.224404
.ends

.subckt netg189 g189_0 g189_2 g189_1 gnd
C1  g189_0 gnd 2.080806f
C2  g189_2 gnd 2.080806f
C3  g189_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g189_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g189_2 3 2.224404
C7 4 gnd 2.080806f
R5 g189_0 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
R51 49 g189_1 2.224404
.ends

.subckt netg7462 g7462_0 g7462_1 gnd
C1  g7462_0 gnd 2.080806f
C2  g7462_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7462_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
R51 g7462_1 50 2.224404
.ends

.subckt netg119 g119_1 g119_0 gnd
C1  g119_1 gnd 2.080806f
C2  g119_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g119_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
R51 50 g119_1 2.224404
.ends

.subckt netg7487 g7487_1 g7487_0 gnd
C1  g7487_1 gnd 2.080806f
C2  g7487_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7487_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
R52 g7487_1 51 2.224404
.ends

.subckt netg159 g159_0 g159_1 gnd
C1  g159_0 gnd 2.080806f
C2  g159_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g159_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
R52 g159_1 51 2.224404
.ends

.subckt netg163 g163_0 g163_1 gnd
C1  g163_0 gnd 2.080806f
C2  g163_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g163_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
R52 51 g163_1 2.224404
.ends

.subckt netg170 g170_1 g170_2 gnd
C1  g170_1 gnd 2.080806f
C2  g170_2 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g170_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
R53 52 g170_1 2.224404
.ends

.subckt netg7485 g7485_0 g7485_1 gnd
C1  g7485_0 gnd 2.080806f
C2  g7485_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7485_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
R53 g7485_1 52 2.224404
.ends

.subckt netg7472 g7472_1 g7472_0 gnd
C1  g7472_1 gnd 2.080806f
C2  g7472_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7472_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
R53 g7472_1 52 2.224404
.ends

.subckt netg7488 g7488_1 g7488_0 gnd
C1  g7488_1 gnd 2.080806f
C2  g7488_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7488_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
R53 g7488_1 52 2.224404
.ends

.subckt netg7480 g7480_0 g7480_1 gnd
C1  g7480_0 gnd 2.080806f
C2  g7480_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7480_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
R53 g7480_1 52 2.224404
.ends

.subckt netg51 g51_2 g51_1 g51_0 gnd
C1  g51_2 gnd 2.080806f
C2  g51_1 gnd 2.080806f
C3  g51_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g51_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 g51_1 2 2.224404
C6 3 gnd 2.080806f
R4 3 g51_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
R54 g51_2 52 2.224404
.ends

.subckt netg7477 g7477_0 g7477_1 gnd
C1  g7477_0 gnd 2.080806f
C2  g7477_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7477_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
R53 g7477_1 52 2.224404
.ends

.subckt netg2141 g2141_3 g2141_2 g2141_0 g2141_1 g2141_4 g2141_5 gnd
C1  g2141_3 gnd 2.080806f
C2  g2141_2 gnd 2.080806f
C3  g2141_0 gnd 2.080806f
C4  g2141_1 gnd 2.080806f
C5  g2141_4 gnd 2.080806f
C6  g2141_5 gnd 2.080806f
R1 g2141_4 g2141_0 2.224404
C7 1 gnd 2.080806f
R2 1 g2141_4 2.224404
C8 2 gnd 2.080806f
R3 2 1 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
R7 g2141_5 5 2.224404
R8 g2141_3 g2141_5 2.224404
C12 6 gnd 2.080806f
R9 g2141_0 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 12 11 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 36 35 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 40 39 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
R46 42 g2141_1 2.224404
C49 43 gnd 2.080806f
R47 43 g2141_1 2.224404
C50 44 gnd 2.080806f
R48 43 44 2.224404
C51 45 gnd 2.080806f
R49 44 45 2.224404
C52 46 gnd 2.080806f
R50 45 46 2.224404
C53 47 gnd 2.080806f
R51 46 47 2.224404
C54 48 gnd 2.080806f
R52 47 48 2.224404
C55 49 gnd 2.080806f
R53 48 49 2.224404
C56 50 gnd 2.080806f
R54 49 50 2.224404
C57 51 gnd 2.080806f
R55 51 50 2.224404
C58 52 gnd 2.080806f
R56 51 52 2.224404
C59 53 gnd 2.080806f
R57 52 53 2.224404
C60 54 gnd 2.080806f
R58 53 54 2.224404
C61 55 gnd 2.080806f
R59 54 55 2.224404
C62 56 gnd 2.080806f
R60 55 56 2.224404
R61 g2141_2 56 2.224404
.ends

.subckt netg162 g162_1 g162_0 gnd
C1  g162_1 gnd 2.080806f
C2  g162_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g162_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
R53 g162_1 52 2.224404
.ends

.subckt netg193 g193_1 g193_2 g193_0 gnd
C1  g193_1 gnd 2.080806f
C2  g193_2 gnd 2.080806f
C3  g193_0 gnd 2.080806f
R1 g193_1 g193_0 2.224404
C4 1 gnd 2.080806f
R2 g193_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
R54 52 g193_2 2.224404
.ends

.subckt netg151 g151_0 g151_1 gnd
C1  g151_0 gnd 2.080806f
C2  g151_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g151_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
R54 g151_1 53 2.224404
.ends

.subckt netg161 g161_0 g161_1 gnd
C1  g161_0 gnd 2.080806f
C2  g161_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g161_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
R54 53 g161_1 2.224404
.ends

.subckt netg155 g155_1 g155_0 gnd
C1  g155_1 gnd 2.080806f
C2  g155_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g155_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
R56 g155_1 55 2.224404
.ends

.subckt netg171 g171_2 g171_0 g171_1 gnd
C1  g171_2 gnd 2.080806f
C2  g171_0 gnd 2.080806f
C3  g171_1 gnd 2.080806f
R1 g171_0 g171_1 2.224404
C4 1 gnd 2.080806f
R2 g171_1 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
R54 52 g171_2 2.224404
.ends

.subckt netg153 g153_1 g153_0 gnd
C1  g153_1 gnd 2.080806f
C2  g153_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g153_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
R54 53 g153_1 2.224404
.ends

.subckt netg150 g150_1 g150_0 gnd
C1  g150_1 gnd 2.080806f
C2  g150_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g150_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
R56 55 g150_1 2.224404
.ends

.subckt netg7516 g7516_1 g7516_0 gnd
C1  g7516_1 gnd 2.080806f
C2  g7516_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7516_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
R54 g7516_1 53 2.224404
.ends

.subckt netg7479 g7479_0 g7479_1 gnd
C1  g7479_0 gnd 2.080806f
C2  g7479_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7479_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
R55 g7479_1 54 2.224404
.ends

.subckt netg188 g188_1 g188_0 g188_2 gnd
C1  g188_1 gnd 2.080806f
C2  g188_0 gnd 2.080806f
C3  g188_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g188_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
R5 g188_1 4 2.224404
C8 5 gnd 2.080806f
R6 g188_0 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
R57 55 g188_2 2.224404
.ends

.subckt netg526 g526_5 g526_3 g526_0 g526_4 g526_1 g526_2 gnd
C1  g526_5 gnd 2.080806f
C2  g526_3 gnd 2.080806f
C3  g526_0 gnd 2.080806f
C4  g526_4 gnd 2.080806f
C5  g526_1 gnd 2.080806f
C6  g526_2 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g526_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
R4 g526_3 3 2.224404
C10 4 gnd 2.080806f
R5 g526_3 4 2.224404
R6 4 g526_5 2.224404
C11 5 gnd 2.080806f
R7 g526_0 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
C13 7 gnd 2.080806f
R9 6 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
C19 13 gnd 2.080806f
R15 12 13 2.224404
C20 14 gnd 2.080806f
R16 13 14 2.224404
C21 15 gnd 2.080806f
R17 14 15 2.224404
C22 16 gnd 2.080806f
R18 15 16 2.224404
C23 17 gnd 2.080806f
R19 16 17 2.224404
C24 18 gnd 2.080806f
R20 17 18 2.224404
C25 19 gnd 2.080806f
R21 18 19 2.224404
C26 20 gnd 2.080806f
R22 19 20 2.224404
C27 21 gnd 2.080806f
R23 20 21 2.224404
R24 21 g526_1 2.224404
C28 22 gnd 2.080806f
R25 22 g526_1 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 39 38 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
R45 41 g526_2 2.224404
C48 42 gnd 2.080806f
R46 g526_1 42 2.224404
C49 43 gnd 2.080806f
R47 42 43 2.224404
C50 44 gnd 2.080806f
R48 43 44 2.224404
C51 45 gnd 2.080806f
R49 44 45 2.224404
C52 46 gnd 2.080806f
R50 45 46 2.224404
C53 47 gnd 2.080806f
R51 46 47 2.224404
C54 48 gnd 2.080806f
R52 47 48 2.224404
C55 49 gnd 2.080806f
R53 48 49 2.224404
C56 50 gnd 2.080806f
R54 49 50 2.224404
C57 51 gnd 2.080806f
R55 50 51 2.224404
C58 52 gnd 2.080806f
R56 51 52 2.224404
C59 53 gnd 2.080806f
R57 52 53 2.224404
C60 54 gnd 2.080806f
R58 53 54 2.224404
C61 55 gnd 2.080806f
R59 54 55 2.224404
C62 56 gnd 2.080806f
R60 55 56 2.224404
C63 57 gnd 2.080806f
R61 56 57 2.224404
C64 58 gnd 2.080806f
R62 57 58 2.224404
C65 59 gnd 2.080806f
R63 58 59 2.224404
C66 60 gnd 2.080806f
R64 59 60 2.224404
C67 61 gnd 2.080806f
R65 60 61 2.224404
C68 62 gnd 2.080806f
R66 61 62 2.224404
C69 63 gnd 2.080806f
R67 62 63 2.224404
C70 64 gnd 2.080806f
R68 63 64 2.224404
R69 64 g526_4 2.224404
.ends

.subckt netg7473 g7473_0 g7473_1 gnd
C1  g7473_0 gnd 2.080806f
C2  g7473_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7473_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
R56 55 g7473_1 2.224404
.ends

.subckt netg7476 g7476_1 g7476_0 gnd
C1  g7476_1 gnd 2.080806f
C2  g7476_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7476_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
R56 g7476_1 55 2.224404
.ends

.subckt netg7517 g7517_0 g7517_1 gnd
C1  g7517_0 gnd 2.080806f
C2  g7517_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7517_0 1 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
R58 g7517_1 57 2.224404
.ends

.subckt netg1691 g1691_6 g1691_3 g1691_5 g1691_2 g1691_1 g1691_4 g1691_0 gnd
C1  g1691_6 gnd 2.080806f
C2  g1691_3 gnd 2.080806f
C3  g1691_5 gnd 2.080806f
C4  g1691_2 gnd 2.080806f
C5  g1691_1 gnd 2.080806f
C6  g1691_4 gnd 2.080806f
C7  g1691_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g1691_0 1 2.224404
C9 2 gnd 2.080806f
R2 2 1 2.224404
C10 3 gnd 2.080806f
R3 2 3 2.224404
C11 4 gnd 2.080806f
R4 3 4 2.224404
C12 5 gnd 2.080806f
R5 4 5 2.224404
R6 5 g1691_3 2.224404
C13 6 gnd 2.080806f
R7 6 g1691_0 2.224404
C14 7 gnd 2.080806f
R8 7 6 2.224404
C15 8 gnd 2.080806f
R9 8 7 2.224404
C16 9 gnd 2.080806f
R10 9 8 2.224404
C17 10 gnd 2.080806f
R11 10 9 2.224404
C18 11 gnd 2.080806f
R12 11 10 2.224404
C19 12 gnd 2.080806f
R13 12 11 2.224404
C20 13 gnd 2.080806f
R14 13 12 2.224404
C21 14 gnd 2.080806f
R15 14 13 2.224404
C22 15 gnd 2.080806f
R16 15 14 2.224404
C23 16 gnd 2.080806f
R17 16 15 2.224404
C24 17 gnd 2.080806f
R18 17 16 2.224404
C25 18 gnd 2.080806f
R19 18 17 2.224404
C26 19 gnd 2.080806f
R20 19 18 2.224404
R21 g1691_4 19 2.224404
C27 20 gnd 2.080806f
R22 20 g1691_4 2.224404
C28 21 gnd 2.080806f
R23 21 20 2.224404
C29 22 gnd 2.080806f
R24 22 21 2.224404
C30 23 gnd 2.080806f
R25 23 22 2.224404
R26 g1691_5 23 2.224404
C31 24 gnd 2.080806f
R27 24 g1691_5 2.224404
R28 g1691_2 24 2.224404
C32 25 gnd 2.080806f
R29 g1691_3 25 2.224404
C33 26 gnd 2.080806f
R30 25 26 2.224404
C34 27 gnd 2.080806f
R31 26 27 2.224404
C35 28 gnd 2.080806f
R32 27 28 2.224404
C36 29 gnd 2.080806f
R33 28 29 2.224404
C37 30 gnd 2.080806f
R34 29 30 2.224404
C38 31 gnd 2.080806f
R35 30 31 2.224404
C39 32 gnd 2.080806f
R36 31 32 2.224404
C40 33 gnd 2.080806f
R37 32 33 2.224404
C41 34 gnd 2.080806f
R38 33 34 2.224404
C42 35 gnd 2.080806f
R39 34 35 2.224404
C43 36 gnd 2.080806f
R40 35 36 2.224404
C44 37 gnd 2.080806f
R41 36 37 2.224404
C45 38 gnd 2.080806f
R42 37 38 2.224404
C46 39 gnd 2.080806f
R43 38 39 2.224404
C47 40 gnd 2.080806f
R44 39 40 2.224404
C48 41 gnd 2.080806f
R45 40 41 2.224404
C49 42 gnd 2.080806f
R46 41 42 2.224404
C50 43 gnd 2.080806f
R47 43 42 2.224404
C51 44 gnd 2.080806f
R48 44 43 2.224404
C52 45 gnd 2.080806f
R49 44 45 2.224404
C53 46 gnd 2.080806f
R50 45 46 2.224404
C54 47 gnd 2.080806f
R51 46 47 2.224404
C55 48 gnd 2.080806f
R52 47 48 2.224404
C56 49 gnd 2.080806f
R53 48 49 2.224404
C57 50 gnd 2.080806f
R54 49 50 2.224404
C58 51 gnd 2.080806f
R55 50 51 2.224404
C59 52 gnd 2.080806f
R56 51 52 2.224404
R57 g1691_6 52 2.224404
C60 53 gnd 2.080806f
R58 53 g1691_6 2.224404
C61 54 gnd 2.080806f
R59 54 53 2.224404
C62 55 gnd 2.080806f
R60 55 54 2.224404
C63 56 gnd 2.080806f
R61 55 56 2.224404
C64 57 gnd 2.080806f
R62 57 56 2.224404
C65 58 gnd 2.080806f
R63 57 58 2.224404
C66 59 gnd 2.080806f
R64 58 59 2.224404
R65 59 g1691_1 2.224404
.ends

.subckt netg7458 g7458_0 g7458_1 gnd
C1  g7458_0 gnd 2.080806f
C2  g7458_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7458_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
R56 g7458_1 55 2.224404
.ends

.subckt netg7541 g7541_0 g7541_1 gnd
C1  g7541_0 gnd 2.080806f
C2  g7541_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7541_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
R57 56 g7541_1 2.224404
.ends

.subckt netg479 g479_1 g479_5 g479_3 g479_2 g479_4 g479_0 gnd
C1  g479_1 gnd 2.080806f
C2  g479_5 gnd 2.080806f
C3  g479_3 gnd 2.080806f
C4  g479_2 gnd 2.080806f
C5  g479_4 gnd 2.080806f
C6  g479_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g479_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
C10 4 gnd 2.080806f
R4 4 3 2.224404
C11 5 gnd 2.080806f
R5 5 4 2.224404
R6 g479_3 5 2.224404
C12 6 gnd 2.080806f
R7 6 g479_3 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
R9 g479_1 7 2.224404
C14 8 gnd 2.080806f
R10 8 7 2.224404
C15 9 gnd 2.080806f
R11 9 8 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 11 10 2.224404
C18 12 gnd 2.080806f
R14 12 11 2.224404
C19 13 gnd 2.080806f
R15 13 12 2.224404
R16 g479_4 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
C54 48 gnd 2.080806f
R51 47 48 2.224404
C55 49 gnd 2.080806f
R52 48 49 2.224404
C56 50 gnd 2.080806f
R53 49 50 2.224404
C57 51 gnd 2.080806f
R54 50 51 2.224404
C58 52 gnd 2.080806f
R55 52 51 2.224404
R56 52 g479_5 2.224404
C59 53 gnd 2.080806f
R57 g479_5 53 2.224404
C60 54 gnd 2.080806f
R58 53 54 2.224404
C61 55 gnd 2.080806f
R59 54 55 2.224404
C62 56 gnd 2.080806f
R60 55 56 2.224404
C63 57 gnd 2.080806f
R61 56 57 2.224404
C64 58 gnd 2.080806f
R62 57 58 2.224404
C65 59 gnd 2.080806f
R63 58 59 2.224404
C66 60 gnd 2.080806f
R64 59 60 2.224404
C67 61 gnd 2.080806f
R65 60 61 2.224404
C68 62 gnd 2.080806f
R66 61 62 2.224404
C69 63 gnd 2.080806f
R67 62 63 2.224404
C70 64 gnd 2.080806f
R68 63 64 2.224404
C71 65 gnd 2.080806f
R69 64 65 2.224404
C72 66 gnd 2.080806f
R70 65 66 2.224404
C73 67 gnd 2.080806f
R71 66 67 2.224404
R72 67 g479_2 2.224404
.ends

.subckt netg156 g156_0 g156_1 gnd
C1  g156_0 gnd 2.080806f
C2  g156_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g156_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
R57 56 g156_1 2.224404
.ends

.subckt netg164 g164_1 g164_0 gnd
C1  g164_1 gnd 2.080806f
C2  g164_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g164_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 57 58 2.224404
C61 59 gnd 2.080806f
R59 58 59 2.224404
C62 60 gnd 2.080806f
R60 59 60 2.224404
C63 61 gnd 2.080806f
R61 60 61 2.224404
C64 62 gnd 2.080806f
R62 61 62 2.224404
C65 63 gnd 2.080806f
R63 62 63 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
R67 66 g164_1 2.224404
.ends

.subckt netg7514 g7514_0 g7514_1 gnd
C1  g7514_0 gnd 2.080806f
C2  g7514_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7514_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
R57 56 g7514_1 2.224404
.ends

.subckt netg160 g160_1 g160_0 gnd
C1  g160_1 gnd 2.080806f
C2  g160_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g160_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
R57 g160_1 56 2.224404
.ends

.subckt netg152 g152_1 g152_0 gnd
C1  g152_1 gnd 2.080806f
C2  g152_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g152_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 57 58 2.224404
C61 59 gnd 2.080806f
R59 58 59 2.224404
C62 60 gnd 2.080806f
R60 59 60 2.224404
C63 61 gnd 2.080806f
R61 60 61 2.224404
C64 62 gnd 2.080806f
R62 61 62 2.224404
C65 63 gnd 2.080806f
R63 62 63 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 66 67 2.224404
C70 68 gnd 2.080806f
R68 67 68 2.224404
C71 69 gnd 2.080806f
R69 68 69 2.224404
C72 70 gnd 2.080806f
R70 69 70 2.224404
C73 71 gnd 2.080806f
R71 70 71 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
C77 75 gnd 2.080806f
R75 74 75 2.224404
C78 76 gnd 2.080806f
R76 75 76 2.224404
C79 77 gnd 2.080806f
R77 76 77 2.224404
C80 78 gnd 2.080806f
R78 77 78 2.224404
C81 79 gnd 2.080806f
R79 78 79 2.224404
C82 80 gnd 2.080806f
R80 79 80 2.224404
R81 80 g152_1 2.224404
.ends

.subckt netg169 g169_1 g169_0 g169_2 gnd
C1  g169_1 gnd 2.080806f
C2  g169_0 gnd 2.080806f
C3  g169_2 gnd 2.080806f
R1 g169_1 g169_0 2.224404
C4 1 gnd 2.080806f
R2 g169_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
R57 55 g169_2 2.224404
.ends

.subckt netg12 g12_0 g12_2 g12_1 gnd
C1  g12_0 gnd 2.080806f
C2  g12_2 gnd 2.080806f
C3  g12_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g12_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
R23 g12_2 22 2.224404
C26 23 gnd 2.080806f
R24 g12_0 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
R58 56 g12_1 2.224404
.ends

.subckt netg7474 g7474_1 g7474_0 gnd
C1  g7474_1 gnd 2.080806f
C2  g7474_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7474_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
R58 57 g7474_1 2.224404
.ends

.subckt netg53 g53_2 g53_1 g53_0 gnd
C1  g53_2 gnd 2.080806f
C2  g53_1 gnd 2.080806f
C3  g53_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g53_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g53_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 g53_2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
R58 g53_1 56 2.224404
.ends

.subckt netg2258 g2258_4 g2258_3 g2258_2 g2258_1 g2258_5 gnd
C1  g2258_4 gnd 2.080806f
C2  g2258_3 gnd 2.080806f
C3  g2258_2 gnd 2.080806f
C4  g2258_1 gnd 2.080806f
C5  g2258_5 gnd 2.080806f
C6 1 gnd 2.080806f
R1 1 g2258_2 2.224404
R2 g2258_3 1 2.224404
C7 2 gnd 2.080806f
R3 g2258_3 2 2.224404
R4 2 g2258_5 2.224404
C8 3 gnd 2.080806f
R5 g2258_2 3 2.224404
C9 4 gnd 2.080806f
R6 3 4 2.224404
C10 5 gnd 2.080806f
R7 4 5 2.224404
C11 6 gnd 2.080806f
R8 5 6 2.224404
C12 7 gnd 2.080806f
R9 6 7 2.224404
C13 8 gnd 2.080806f
R10 7 8 2.224404
C14 9 gnd 2.080806f
R11 8 9 2.224404
C15 10 gnd 2.080806f
R12 9 10 2.224404
C16 11 gnd 2.080806f
R13 10 11 2.224404
C17 12 gnd 2.080806f
R14 11 12 2.224404
C18 13 gnd 2.080806f
R15 12 13 2.224404
C19 14 gnd 2.080806f
R16 13 14 2.224404
C20 15 gnd 2.080806f
R17 14 15 2.224404
C21 16 gnd 2.080806f
R18 15 16 2.224404
C22 17 gnd 2.080806f
R19 16 17 2.224404
C23 18 gnd 2.080806f
R20 17 18 2.224404
C24 19 gnd 2.080806f
R21 18 19 2.224404
C25 20 gnd 2.080806f
R22 19 20 2.224404
C26 21 gnd 2.080806f
R23 20 21 2.224404
C27 22 gnd 2.080806f
R24 21 22 2.224404
C28 23 gnd 2.080806f
R25 22 23 2.224404
C29 24 gnd 2.080806f
R26 23 24 2.224404
C30 25 gnd 2.080806f
R27 24 25 2.224404
C31 26 gnd 2.080806f
R28 25 26 2.224404
C32 27 gnd 2.080806f
R29 26 27 2.224404
C33 28 gnd 2.080806f
R30 27 28 2.224404
C34 29 gnd 2.080806f
R31 28 29 2.224404
C35 30 gnd 2.080806f
R32 29 30 2.224404
C36 31 gnd 2.080806f
R33 30 31 2.224404
C37 32 gnd 2.080806f
R34 31 32 2.224404
C38 33 gnd 2.080806f
R35 32 33 2.224404
C39 34 gnd 2.080806f
R36 33 34 2.224404
R37 34 g2258_1 2.224404
C40 35 gnd 2.080806f
R38 g2258_1 35 2.224404
C41 36 gnd 2.080806f
R39 35 36 2.224404
C42 37 gnd 2.080806f
R40 36 37 2.224404
C43 38 gnd 2.080806f
R41 37 38 2.224404
C44 39 gnd 2.080806f
R42 38 39 2.224404
C45 40 gnd 2.080806f
R43 39 40 2.224404
C46 41 gnd 2.080806f
R44 40 41 2.224404
C47 42 gnd 2.080806f
R45 41 42 2.224404
C48 43 gnd 2.080806f
R46 42 43 2.224404
C49 44 gnd 2.080806f
R47 43 44 2.224404
C50 45 gnd 2.080806f
R48 44 45 2.224404
C51 46 gnd 2.080806f
R49 45 46 2.224404
C52 47 gnd 2.080806f
R50 46 47 2.224404
C53 48 gnd 2.080806f
R51 47 48 2.224404
C54 49 gnd 2.080806f
R52 48 49 2.224404
C55 50 gnd 2.080806f
R53 49 50 2.224404
C56 51 gnd 2.080806f
R54 50 51 2.224404
C57 52 gnd 2.080806f
R55 51 52 2.224404
C58 53 gnd 2.080806f
R56 52 53 2.224404
C59 54 gnd 2.080806f
R57 53 54 2.224404
C60 55 gnd 2.080806f
R58 54 55 2.224404
C61 56 gnd 2.080806f
R59 55 56 2.224404
R60 56 g2258_4 2.224404
.ends

.subckt netg194 g194_2 g194_0 g194_1 gnd
C1  g194_2 gnd 2.080806f
C2  g194_0 gnd 2.080806f
C3  g194_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g194_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
R5 g194_2 4 2.224404
C8 5 gnd 2.080806f
R6 g194_0 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
R59 57 g194_1 2.224404
.ends

.subckt netg7478 g7478_1 g7478_0 gnd
C1  g7478_1 gnd 2.080806f
C2  g7478_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7478_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
R59 g7478_1 58 2.224404
.ends

.subckt netg2250 g2250_1 g2250_4 g2250_2 g2250_6 g2250_7 g2250_5 g2250_3 gnd
C1  g2250_1 gnd 2.080806f
C2  g2250_4 gnd 2.080806f
C3  g2250_2 gnd 2.080806f
C4  g2250_6 gnd 2.080806f
C5  g2250_7 gnd 2.080806f
C6  g2250_5 gnd 2.080806f
C7  g2250_3 gnd 2.080806f
C8 1 gnd 2.080806f
R1 1 g2250_1 2.224404
R2 g2250_5 1 2.224404
C9 2 gnd 2.080806f
R3 g2250_1 2 2.224404
C10 3 gnd 2.080806f
R4 2 3 2.224404
C11 4 gnd 2.080806f
R5 3 4 2.224404
C12 5 gnd 2.080806f
R6 4 5 2.224404
C13 6 gnd 2.080806f
R7 5 6 2.224404
C14 7 gnd 2.080806f
R8 6 7 2.224404
C15 8 gnd 2.080806f
R9 7 8 2.224404
C16 9 gnd 2.080806f
R10 8 9 2.224404
C17 10 gnd 2.080806f
R11 9 10 2.224404
R12 10 g2250_6 2.224404
C18 11 gnd 2.080806f
R13 11 g2250_6 2.224404
C19 12 gnd 2.080806f
R14 11 12 2.224404
R15 12 g2250_3 2.224404
C20 13 gnd 2.080806f
R16 13 g2250_3 2.224404
C21 14 gnd 2.080806f
R17 14 13 2.224404
C22 15 gnd 2.080806f
R18 14 15 2.224404
C23 16 gnd 2.080806f
R19 15 16 2.224404
C24 17 gnd 2.080806f
R20 16 17 2.224404
C25 18 gnd 2.080806f
R21 18 17 2.224404
C26 19 gnd 2.080806f
R22 18 19 2.224404
R23 19 g2250_2 2.224404
C27 20 gnd 2.080806f
R24 20 g2250_2 2.224404
C28 21 gnd 2.080806f
R25 20 21 2.224404
C29 22 gnd 2.080806f
R26 21 22 2.224404
C30 23 gnd 2.080806f
R27 22 23 2.224404
C31 24 gnd 2.080806f
R28 23 24 2.224404
C32 25 gnd 2.080806f
R29 24 25 2.224404
C33 26 gnd 2.080806f
R30 25 26 2.224404
C34 27 gnd 2.080806f
R31 26 27 2.224404
C35 28 gnd 2.080806f
R32 27 28 2.224404
C36 29 gnd 2.080806f
R33 28 29 2.224404
C37 30 gnd 2.080806f
R34 29 30 2.224404
C38 31 gnd 2.080806f
R35 30 31 2.224404
C39 32 gnd 2.080806f
R36 31 32 2.224404
C40 33 gnd 2.080806f
R37 32 33 2.224404
C41 34 gnd 2.080806f
R38 33 34 2.224404
C42 35 gnd 2.080806f
R39 34 35 2.224404
C43 36 gnd 2.080806f
R40 35 36 2.224404
C44 37 gnd 2.080806f
R41 36 37 2.224404
C45 38 gnd 2.080806f
R42 37 38 2.224404
C46 39 gnd 2.080806f
R43 38 39 2.224404
C47 40 gnd 2.080806f
R44 39 40 2.224404
C48 41 gnd 2.080806f
R45 40 41 2.224404
C49 42 gnd 2.080806f
R46 41 42 2.224404
C50 43 gnd 2.080806f
R47 42 43 2.224404
C51 44 gnd 2.080806f
R48 43 44 2.224404
C52 45 gnd 2.080806f
R49 44 45 2.224404
R50 45 g2250_7 2.224404
C53 46 gnd 2.080806f
R51 g2250_7 46 2.224404
C54 47 gnd 2.080806f
R52 46 47 2.224404
C55 48 gnd 2.080806f
R53 47 48 2.224404
C56 49 gnd 2.080806f
R54 48 49 2.224404
C57 50 gnd 2.080806f
R55 49 50 2.224404
C58 51 gnd 2.080806f
R56 50 51 2.224404
C59 52 gnd 2.080806f
R57 51 52 2.224404
C60 53 gnd 2.080806f
R58 52 53 2.224404
C61 54 gnd 2.080806f
R59 53 54 2.224404
C62 55 gnd 2.080806f
R60 54 55 2.224404
C63 56 gnd 2.080806f
R61 55 56 2.224404
C64 57 gnd 2.080806f
R62 56 57 2.224404
C65 58 gnd 2.080806f
R63 57 58 2.224404
C66 59 gnd 2.080806f
R64 58 59 2.224404
C67 60 gnd 2.080806f
R65 59 60 2.224404
C68 61 gnd 2.080806f
R66 60 61 2.224404
C69 62 gnd 2.080806f
R67 61 62 2.224404
C70 63 gnd 2.080806f
R68 62 63 2.224404
R69 63 g2250_4 2.224404
.ends

.subckt netg2133 g2133_7 g2133_0 g2133_6 g2133_4 g2133_3 g2133_2 g2133_1 gnd
C1  g2133_7 gnd 2.080806f
C2  g2133_0 gnd 2.080806f
C3  g2133_6 gnd 2.080806f
C4  g2133_4 gnd 2.080806f
C5  g2133_3 gnd 2.080806f
C6  g2133_2 gnd 2.080806f
C7  g2133_1 gnd 2.080806f
R1 g2133_2 g2133_0 2.224404
R2 g2133_0 g2133_7 2.224404
R3 g2133_7 g2133_4 2.224404
C8 1 gnd 2.080806f
R4 g2133_4 1 2.224404
R5 1 g2133_3 2.224404
C9 2 gnd 2.080806f
R6 g2133_3 2 2.224404
C10 3 gnd 2.080806f
R7 2 3 2.224404
C11 4 gnd 2.080806f
R8 3 4 2.224404
C12 5 gnd 2.080806f
R9 4 5 2.224404
C13 6 gnd 2.080806f
R10 5 6 2.224404
C14 7 gnd 2.080806f
R11 6 7 2.224404
C15 8 gnd 2.080806f
R12 7 8 2.224404
C16 9 gnd 2.080806f
R13 8 9 2.224404
C17 10 gnd 2.080806f
R14 9 10 2.224404
C18 11 gnd 2.080806f
R15 10 11 2.224404
C19 12 gnd 2.080806f
R16 11 12 2.224404
C20 13 gnd 2.080806f
R17 12 13 2.224404
C21 14 gnd 2.080806f
R18 13 14 2.224404
C22 15 gnd 2.080806f
R19 14 15 2.224404
C23 16 gnd 2.080806f
R20 15 16 2.224404
C24 17 gnd 2.080806f
R21 16 17 2.224404
C25 18 gnd 2.080806f
R22 17 18 2.224404
C26 19 gnd 2.080806f
R23 18 19 2.224404
C27 20 gnd 2.080806f
R24 19 20 2.224404
C28 21 gnd 2.080806f
R25 20 21 2.224404
C29 22 gnd 2.080806f
R26 21 22 2.224404
C30 23 gnd 2.080806f
R27 22 23 2.224404
C31 24 gnd 2.080806f
R28 23 24 2.224404
C32 25 gnd 2.080806f
R29 24 25 2.224404
C33 26 gnd 2.080806f
R30 25 26 2.224404
C34 27 gnd 2.080806f
R31 26 27 2.224404
C35 28 gnd 2.080806f
R32 27 28 2.224404
C36 29 gnd 2.080806f
R33 28 29 2.224404
C37 30 gnd 2.080806f
R34 29 30 2.224404
C38 31 gnd 2.080806f
R35 30 31 2.224404
C39 32 gnd 2.080806f
R36 31 32 2.224404
C40 33 gnd 2.080806f
R37 32 33 2.224404
C41 34 gnd 2.080806f
R38 33 34 2.224404
C42 35 gnd 2.080806f
R39 34 35 2.224404
C43 36 gnd 2.080806f
R40 35 36 2.224404
C44 37 gnd 2.080806f
R41 36 37 2.224404
C45 38 gnd 2.080806f
R42 37 38 2.224404
C46 39 gnd 2.080806f
R43 38 39 2.224404
C47 40 gnd 2.080806f
R44 39 40 2.224404
C48 41 gnd 2.080806f
R45 40 41 2.224404
C49 42 gnd 2.080806f
R46 41 42 2.224404
C50 43 gnd 2.080806f
R47 42 43 2.224404
C51 44 gnd 2.080806f
R48 43 44 2.224404
C52 45 gnd 2.080806f
R49 44 45 2.224404
C53 46 gnd 2.080806f
R50 45 46 2.224404
C54 47 gnd 2.080806f
R51 46 47 2.224404
C55 48 gnd 2.080806f
R52 47 48 2.224404
C56 49 gnd 2.080806f
R53 48 49 2.224404
C57 50 gnd 2.080806f
R54 49 50 2.224404
C58 51 gnd 2.080806f
R55 50 51 2.224404
C59 52 gnd 2.080806f
R56 51 52 2.224404
C60 53 gnd 2.080806f
R57 52 53 2.224404
C61 54 gnd 2.080806f
R58 54 53 2.224404
C62 55 gnd 2.080806f
R59 55 54 2.224404
R60 55 g2133_1 2.224404
C63 56 gnd 2.080806f
R61 g2133_1 56 2.224404
C64 57 gnd 2.080806f
R62 56 57 2.224404
C65 58 gnd 2.080806f
R63 58 57 2.224404
C66 59 gnd 2.080806f
R64 58 59 2.224404
C67 60 gnd 2.080806f
R65 59 60 2.224404
C68 61 gnd 2.080806f
R66 60 61 2.224404
R67 g2133_6 61 2.224404
.ends

.subckt netg52 g52_2 g52_1 g52_0 gnd
C1  g52_2 gnd 2.080806f
C2  g52_1 gnd 2.080806f
C3  g52_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g52_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
R35 34 g52_1 2.224404
C38 35 gnd 2.080806f
R36 35 5 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
R68 g52_2 66 2.224404
.ends

.subckt netg2264 g2264_4 g2264_3 g2264_5 g2264_2 g2264_1 g2264_0 gnd
C1  g2264_4 gnd 2.080806f
C2  g2264_3 gnd 2.080806f
C3  g2264_5 gnd 2.080806f
C4  g2264_2 gnd 2.080806f
C5  g2264_1 gnd 2.080806f
C6  g2264_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2264_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
R3 g2264_3 2 2.224404
C9 3 gnd 2.080806f
R4 3 g2264_3 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
C16 10 gnd 2.080806f
R11 10 9 2.224404
C17 11 gnd 2.080806f
R12 11 10 2.224404
C18 12 gnd 2.080806f
R13 12 11 2.224404
R14 g2264_5 12 2.224404
C19 13 gnd 2.080806f
R15 g2264_5 13 2.224404
C20 14 gnd 2.080806f
R16 13 14 2.224404
R17 g2264_2 14 2.224404
C21 15 gnd 2.080806f
R18 g2264_0 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 38 37 2.224404
C45 39 gnd 2.080806f
R42 39 38 2.224404
C46 40 gnd 2.080806f
R43 40 39 2.224404
R44 g2264_1 40 2.224404
C47 41 gnd 2.080806f
R45 37 41 2.224404
C48 42 gnd 2.080806f
R46 41 42 2.224404
C49 43 gnd 2.080806f
R47 42 43 2.224404
C50 44 gnd 2.080806f
R48 43 44 2.224404
C51 45 gnd 2.080806f
R49 44 45 2.224404
C52 46 gnd 2.080806f
R50 45 46 2.224404
C53 47 gnd 2.080806f
R51 46 47 2.224404
C54 48 gnd 2.080806f
R52 47 48 2.224404
C55 49 gnd 2.080806f
R53 48 49 2.224404
C56 50 gnd 2.080806f
R54 49 50 2.224404
C57 51 gnd 2.080806f
R55 50 51 2.224404
C58 52 gnd 2.080806f
R56 51 52 2.224404
C59 53 gnd 2.080806f
R57 52 53 2.224404
C60 54 gnd 2.080806f
R58 53 54 2.224404
C61 55 gnd 2.080806f
R59 54 55 2.224404
C62 56 gnd 2.080806f
R60 55 56 2.224404
C63 57 gnd 2.080806f
R61 56 57 2.224404
C64 58 gnd 2.080806f
R62 57 58 2.224404
C65 59 gnd 2.080806f
R63 58 59 2.224404
C66 60 gnd 2.080806f
R64 59 60 2.224404
C67 61 gnd 2.080806f
R65 60 61 2.224404
R66 61 g2264_4 2.224404
.ends

.subckt netg2153 g2153_1 g2153_3 g2153_2 g2153_5 g2153_4 g2153_0 gnd
C1  g2153_1 gnd 2.080806f
C2  g2153_3 gnd 2.080806f
C3  g2153_2 gnd 2.080806f
C4  g2153_5 gnd 2.080806f
C5  g2153_4 gnd 2.080806f
C6  g2153_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g2153_0 1 2.224404
R2 1 g2153_3 2.224404
R3 g2153_3 g2153_1 2.224404
C8 2 gnd 2.080806f
R4 2 g2153_0 2.224404
R5 2 g2153_5 2.224404
C9 3 gnd 2.080806f
R6 g2153_5 3 2.224404
C10 4 gnd 2.080806f
R7 3 4 2.224404
C11 5 gnd 2.080806f
R8 4 5 2.224404
C12 6 gnd 2.080806f
R9 5 6 2.224404
C13 7 gnd 2.080806f
R10 6 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 40 39 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
R45 g2153_2 41 2.224404
C48 42 gnd 2.080806f
R46 42 g2153_2 2.224404
C49 43 gnd 2.080806f
R47 43 42 2.224404
C50 44 gnd 2.080806f
R48 44 43 2.224404
C51 45 gnd 2.080806f
R49 44 45 2.224404
C52 46 gnd 2.080806f
R50 46 45 2.224404
C53 47 gnd 2.080806f
R51 46 47 2.224404
C54 48 gnd 2.080806f
R52 47 48 2.224404
C55 49 gnd 2.080806f
R53 48 49 2.224404
C56 50 gnd 2.080806f
R54 49 50 2.224404
C57 51 gnd 2.080806f
R55 50 51 2.224404
C58 52 gnd 2.080806f
R56 52 51 2.224404
C59 53 gnd 2.080806f
R57 52 53 2.224404
C60 54 gnd 2.080806f
R58 53 54 2.224404
C61 55 gnd 2.080806f
R59 54 55 2.224404
C62 56 gnd 2.080806f
R60 55 56 2.224404
C63 57 gnd 2.080806f
R61 56 57 2.224404
C64 58 gnd 2.080806f
R62 57 58 2.224404
C65 59 gnd 2.080806f
R63 58 59 2.224404
C66 60 gnd 2.080806f
R64 59 60 2.224404
C67 61 gnd 2.080806f
R65 60 61 2.224404
C68 62 gnd 2.080806f
R66 61 62 2.224404
C69 63 gnd 2.080806f
R67 62 63 2.224404
C70 64 gnd 2.080806f
R68 63 64 2.224404
C71 65 gnd 2.080806f
R69 64 65 2.224404
C72 66 gnd 2.080806f
R70 65 66 2.224404
C73 67 gnd 2.080806f
R71 66 67 2.224404
C74 68 gnd 2.080806f
R72 67 68 2.224404
C75 69 gnd 2.080806f
R73 68 69 2.224404
C76 70 gnd 2.080806f
R74 69 70 2.224404
C77 71 gnd 2.080806f
R75 70 71 2.224404
C78 72 gnd 2.080806f
R76 71 72 2.224404
R77 72 g2153_4 2.224404
.ends

.subckt netg65 g65_2 g65_0 g65_1 gnd
C1  g65_2 gnd 2.080806f
C2  g65_0 gnd 2.080806f
C3  g65_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g65_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
R36 35 g65_1 2.224404
C39 36 gnd 2.080806f
R37 36 7 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
R75 g65_2 73 2.224404
.ends

.subckt netg394 g394_1 g394_0 g394_2 gnd
C1  g394_1 gnd 2.080806f
C2  g394_0 gnd 2.080806f
C3  g394_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g394_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
R38 g394_1 37 2.224404
C41 38 gnd 2.080806f
R39 g394_1 38 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
R71 g394_2 69 2.224404
.ends

.subckt netg1652 g1652_0 g1652_5 g1652_2 g1652_3 g1652_4 g1652_1 gnd
C1  g1652_0 gnd 2.080806f
C2  g1652_5 gnd 2.080806f
C3  g1652_2 gnd 2.080806f
C4  g1652_3 gnd 2.080806f
C5  g1652_4 gnd 2.080806f
C6  g1652_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1652_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
R3 g1652_1 2 2.224404
C9 3 gnd 2.080806f
R4 g1652_0 3 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
C16 10 gnd 2.080806f
R11 10 9 2.224404
C17 11 gnd 2.080806f
R12 11 10 2.224404
C18 12 gnd 2.080806f
R13 12 11 2.224404
C19 13 gnd 2.080806f
R14 13 12 2.224404
C20 14 gnd 2.080806f
R15 14 13 2.224404
C21 15 gnd 2.080806f
R16 15 14 2.224404
C22 16 gnd 2.080806f
R17 16 15 2.224404
C23 17 gnd 2.080806f
R18 17 16 2.224404
C24 18 gnd 2.080806f
R19 18 17 2.224404
C25 19 gnd 2.080806f
R20 19 18 2.224404
C26 20 gnd 2.080806f
R21 20 19 2.224404
C27 21 gnd 2.080806f
R22 21 20 2.224404
C28 22 gnd 2.080806f
R23 22 21 2.224404
C29 23 gnd 2.080806f
R24 23 22 2.224404
C30 24 gnd 2.080806f
R25 24 23 2.224404
C31 25 gnd 2.080806f
R26 25 24 2.224404
C32 26 gnd 2.080806f
R27 26 25 2.224404
C33 27 gnd 2.080806f
R28 27 26 2.224404
C34 28 gnd 2.080806f
R29 28 27 2.224404
C35 29 gnd 2.080806f
R30 29 28 2.224404
C36 30 gnd 2.080806f
R31 30 29 2.224404
C37 31 gnd 2.080806f
R32 31 30 2.224404
C38 32 gnd 2.080806f
R33 32 31 2.224404
C39 33 gnd 2.080806f
R34 33 32 2.224404
C40 34 gnd 2.080806f
R35 34 33 2.224404
C41 35 gnd 2.080806f
R36 35 34 2.224404
C42 36 gnd 2.080806f
R37 36 35 2.224404
C43 37 gnd 2.080806f
R38 37 36 2.224404
C44 38 gnd 2.080806f
R39 38 37 2.224404
C45 39 gnd 2.080806f
R40 39 38 2.224404
C46 40 gnd 2.080806f
R41 40 39 2.224404
C47 41 gnd 2.080806f
R42 41 40 2.224404
C48 42 gnd 2.080806f
R43 42 41 2.224404
C49 43 gnd 2.080806f
R44 43 42 2.224404
C50 44 gnd 2.080806f
R45 44 43 2.224404
C51 45 gnd 2.080806f
R46 45 44 2.224404
C52 46 gnd 2.080806f
R47 46 45 2.224404
C53 47 gnd 2.080806f
R48 47 46 2.224404
C54 48 gnd 2.080806f
R49 48 47 2.224404
C55 49 gnd 2.080806f
R50 49 48 2.224404
C56 50 gnd 2.080806f
R51 50 49 2.224404
C57 51 gnd 2.080806f
R52 51 50 2.224404
C58 52 gnd 2.080806f
R53 52 51 2.224404
C59 53 gnd 2.080806f
R54 53 52 2.224404
C60 54 gnd 2.080806f
R55 54 53 2.224404
C61 55 gnd 2.080806f
R56 55 54 2.224404
C62 56 gnd 2.080806f
R57 56 55 2.224404
C63 57 gnd 2.080806f
R58 57 56 2.224404
C64 58 gnd 2.080806f
R59 58 57 2.224404
C65 59 gnd 2.080806f
R60 58 59 2.224404
R61 g1652_4 59 2.224404
R62 g1652_4 g1652_2 2.224404
C66 60 gnd 2.080806f
R63 60 g1652_2 2.224404
C67 61 gnd 2.080806f
R64 61 60 2.224404
R65 g1652_5 61 2.224404
C68 62 gnd 2.080806f
R66 62 g1652_4 2.224404
C69 63 gnd 2.080806f
R67 63 62 2.224404
C70 64 gnd 2.080806f
R68 64 63 2.224404
C71 65 gnd 2.080806f
R69 65 64 2.224404
C72 66 gnd 2.080806f
R70 66 65 2.224404
R71 g1652_3 66 2.224404
.ends

.subckt netg400 g400_1 g400_0 g400_2 gnd
C1  g400_1 gnd 2.080806f
C2  g400_0 gnd 2.080806f
C3  g400_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g400_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
R31 30 g400_1 2.224404
C34 31 gnd 2.080806f
R32 g400_1 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
R67 65 g400_2 2.224404
.ends

.subckt netg7520 g7520_0 g7520_1 gnd
C1  g7520_0 gnd 2.080806f
C2  g7520_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7520_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
R69 g7520_1 68 2.224404
.ends

.subckt netg7475 g7475_1 g7475_0 gnd
C1  g7475_1 gnd 2.080806f
C2  g7475_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7475_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
R66 65 g7475_1 2.224404
.ends

.subckt netg7451 g7451_1 g7451_0 gnd
C1  g7451_1 gnd 2.080806f
C2  g7451_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7451_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
R67 66 g7451_1 2.224404
.ends

.subckt netg553 g553_5 g553_1 g553_4 g553_0 g553_3 g553_2 gnd
C1  g553_5 gnd 2.080806f
C2  g553_1 gnd 2.080806f
C3  g553_4 gnd 2.080806f
C4  g553_0 gnd 2.080806f
C5  g553_3 gnd 2.080806f
C6  g553_2 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g553_0 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
C10 4 gnd 2.080806f
R4 3 4 2.224404
C11 5 gnd 2.080806f
R5 5 4 2.224404
C12 6 gnd 2.080806f
R6 6 5 2.224404
C13 7 gnd 2.080806f
R7 7 6 2.224404
C14 8 gnd 2.080806f
R8 7 8 2.224404
C15 9 gnd 2.080806f
R9 8 9 2.224404
C16 10 gnd 2.080806f
R10 9 10 2.224404
C17 11 gnd 2.080806f
R11 10 11 2.224404
C18 12 gnd 2.080806f
R12 11 12 2.224404
C19 13 gnd 2.080806f
R13 12 13 2.224404
C20 14 gnd 2.080806f
R14 14 13 2.224404
C21 15 gnd 2.080806f
R15 14 15 2.224404
R16 g553_5 15 2.224404
C22 16 gnd 2.080806f
R17 16 g553_5 2.224404
C23 17 gnd 2.080806f
R18 17 16 2.224404
C24 18 gnd 2.080806f
R19 18 17 2.224404
C25 19 gnd 2.080806f
R20 19 18 2.224404
C26 20 gnd 2.080806f
R21 20 19 2.224404
C27 21 gnd 2.080806f
R22 21 20 2.224404
C28 22 gnd 2.080806f
R23 22 21 2.224404
C29 23 gnd 2.080806f
R24 23 22 2.224404
C30 24 gnd 2.080806f
R25 24 23 2.224404
C31 25 gnd 2.080806f
R26 25 24 2.224404
C32 26 gnd 2.080806f
R27 26 25 2.224404
C33 27 gnd 2.080806f
R28 27 26 2.224404
C34 28 gnd 2.080806f
R29 28 27 2.224404
C35 29 gnd 2.080806f
R30 29 28 2.224404
C36 30 gnd 2.080806f
R31 30 29 2.224404
C37 31 gnd 2.080806f
R32 31 30 2.224404
C38 32 gnd 2.080806f
R33 32 31 2.224404
C39 33 gnd 2.080806f
R34 33 32 2.224404
C40 34 gnd 2.080806f
R35 34 33 2.224404
C41 35 gnd 2.080806f
R36 35 34 2.224404
C42 36 gnd 2.080806f
R37 36 35 2.224404
C43 37 gnd 2.080806f
R38 37 36 2.224404
C44 38 gnd 2.080806f
R39 38 37 2.224404
C45 39 gnd 2.080806f
R40 39 38 2.224404
C46 40 gnd 2.080806f
R41 40 39 2.224404
C47 41 gnd 2.080806f
R42 41 40 2.224404
C48 42 gnd 2.080806f
R43 42 41 2.224404
C49 43 gnd 2.080806f
R44 43 42 2.224404
C50 44 gnd 2.080806f
R45 44 43 2.224404
C51 45 gnd 2.080806f
R46 45 44 2.224404
C52 46 gnd 2.080806f
R47 46 45 2.224404
C53 47 gnd 2.080806f
R48 47 46 2.224404
C54 48 gnd 2.080806f
R49 48 47 2.224404
C55 49 gnd 2.080806f
R50 49 48 2.224404
C56 50 gnd 2.080806f
R51 50 49 2.224404
C57 51 gnd 2.080806f
R52 51 50 2.224404
C58 52 gnd 2.080806f
R53 52 51 2.224404
C59 53 gnd 2.080806f
R54 53 52 2.224404
C60 54 gnd 2.080806f
R55 54 53 2.224404
R56 g553_2 54 2.224404
C61 55 gnd 2.080806f
R57 55 g553_2 2.224404
C62 56 gnd 2.080806f
R58 56 55 2.224404
C63 57 gnd 2.080806f
R59 57 56 2.224404
C64 58 gnd 2.080806f
R60 58 57 2.224404
C65 59 gnd 2.080806f
R61 59 58 2.224404
C66 60 gnd 2.080806f
R62 60 59 2.224404
C67 61 gnd 2.080806f
R63 61 60 2.224404
C68 62 gnd 2.080806f
R64 62 61 2.224404
C69 63 gnd 2.080806f
R65 63 62 2.224404
R66 g553_3 63 2.224404
C70 64 gnd 2.080806f
R67 64 g553_3 2.224404
C71 65 gnd 2.080806f
R68 65 64 2.224404
C72 66 gnd 2.080806f
R69 66 65 2.224404
C73 67 gnd 2.080806f
R70 66 67 2.224404
C74 68 gnd 2.080806f
R71 68 67 2.224404
C75 69 gnd 2.080806f
R72 69 68 2.224404
C76 70 gnd 2.080806f
R73 70 69 2.224404
R74 g553_1 70 2.224404
C77 71 gnd 2.080806f
R75 71 g553_1 2.224404
C78 72 gnd 2.080806f
R76 72 71 2.224404
C79 73 gnd 2.080806f
R77 73 72 2.224404
C80 74 gnd 2.080806f
R78 74 73 2.224404
C81 75 gnd 2.080806f
R79 75 74 2.224404
R80 g553_4 75 2.224404
.ends

.subckt netg172 g172_1 g172_2 g172_0 gnd
C1  g172_1 gnd 2.080806f
C2  g172_2 gnd 2.080806f
C3  g172_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g172_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
R6 g172_1 5 2.224404
C9 6 gnd 2.080806f
R7 g172_1 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
R70 68 g172_2 2.224404
.ends

.subckt netg397 g397_1 g397_0 g397_2 gnd
C1  g397_1 gnd 2.080806f
C2  g397_0 gnd 2.080806f
C3  g397_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g397_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
R44 g397_1 43 2.224404
C47 44 gnd 2.080806f
R45 44 g397_1 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
R81 g397_2 79 2.224404
.ends

.subckt netg545 g545_5 g545_0 g545_6 g545_4 g545_7 g545_1 g545_2 g545_3 gnd
C1  g545_5 gnd 2.080806f
C2  g545_0 gnd 2.080806f
C3  g545_6 gnd 2.080806f
C4  g545_4 gnd 2.080806f
C5  g545_7 gnd 2.080806f
C6  g545_1 gnd 2.080806f
C7  g545_2 gnd 2.080806f
C8  g545_3 gnd 2.080806f
C9 1 gnd 2.080806f
R1 1 g545_0 2.224404
R2 g545_6 1 2.224404
C10 2 gnd 2.080806f
R3 g545_0 2 2.224404
C11 3 gnd 2.080806f
R4 2 3 2.224404
C12 4 gnd 2.080806f
R5 3 4 2.224404
C13 5 gnd 2.080806f
R6 4 5 2.224404
C14 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g545_7 2.224404
C15 7 gnd 2.080806f
R9 7 g545_6 2.224404
C16 8 gnd 2.080806f
R10 8 7 2.224404
C17 9 gnd 2.080806f
R11 9 8 2.224404
C18 10 gnd 2.080806f
R12 10 9 2.224404
C19 11 gnd 2.080806f
R13 11 10 2.224404
C20 12 gnd 2.080806f
R14 12 11 2.224404
C21 13 gnd 2.080806f
R15 13 12 2.224404
C22 14 gnd 2.080806f
R16 14 13 2.224404
C23 15 gnd 2.080806f
R17 15 14 2.224404
C24 16 gnd 2.080806f
R18 16 15 2.224404
C25 17 gnd 2.080806f
R19 17 16 2.224404
C26 18 gnd 2.080806f
R20 18 17 2.224404
R21 g545_4 18 2.224404
R22 g545_5 g545_4 2.224404
R23 g545_2 g545_5 2.224404
C27 19 gnd 2.080806f
R24 g545_7 19 2.224404
C28 20 gnd 2.080806f
R25 19 20 2.224404
C29 21 gnd 2.080806f
R26 20 21 2.224404
C30 22 gnd 2.080806f
R27 21 22 2.224404
C31 23 gnd 2.080806f
R28 22 23 2.224404
C32 24 gnd 2.080806f
R29 23 24 2.224404
C33 25 gnd 2.080806f
R30 24 25 2.224404
C34 26 gnd 2.080806f
R31 25 26 2.224404
C35 27 gnd 2.080806f
R32 26 27 2.224404
C36 28 gnd 2.080806f
R33 27 28 2.224404
C37 29 gnd 2.080806f
R34 28 29 2.224404
C38 30 gnd 2.080806f
R35 29 30 2.224404
C39 31 gnd 2.080806f
R36 30 31 2.224404
C40 32 gnd 2.080806f
R37 31 32 2.224404
C41 33 gnd 2.080806f
R38 32 33 2.224404
C42 34 gnd 2.080806f
R39 33 34 2.224404
C43 35 gnd 2.080806f
R40 34 35 2.224404
C44 36 gnd 2.080806f
R41 35 36 2.224404
C45 37 gnd 2.080806f
R42 36 37 2.224404
C46 38 gnd 2.080806f
R43 37 38 2.224404
C47 39 gnd 2.080806f
R44 38 39 2.224404
C48 40 gnd 2.080806f
R45 39 40 2.224404
C49 41 gnd 2.080806f
R46 40 41 2.224404
C50 42 gnd 2.080806f
R47 41 42 2.224404
C51 43 gnd 2.080806f
R48 42 43 2.224404
C52 44 gnd 2.080806f
R49 43 44 2.224404
C53 45 gnd 2.080806f
R50 44 45 2.224404
C54 46 gnd 2.080806f
R51 45 46 2.224404
C55 47 gnd 2.080806f
R52 46 47 2.224404
C56 48 gnd 2.080806f
R53 47 48 2.224404
C57 49 gnd 2.080806f
R54 48 49 2.224404
C58 50 gnd 2.080806f
R55 49 50 2.224404
R56 50 g545_1 2.224404
C59 51 gnd 2.080806f
R57 g545_1 51 2.224404
C60 52 gnd 2.080806f
R58 51 52 2.224404
C61 53 gnd 2.080806f
R59 53 52 2.224404
C62 54 gnd 2.080806f
R60 54 53 2.224404
C63 55 gnd 2.080806f
R61 55 54 2.224404
C64 56 gnd 2.080806f
R62 55 56 2.224404
C65 57 gnd 2.080806f
R63 56 57 2.224404
C66 58 gnd 2.080806f
R64 57 58 2.224404
C67 59 gnd 2.080806f
R65 58 59 2.224404
C68 60 gnd 2.080806f
R66 60 59 2.224404
C69 61 gnd 2.080806f
R67 61 60 2.224404
C70 62 gnd 2.080806f
R68 62 61 2.224404
C71 63 gnd 2.080806f
R69 62 63 2.224404
C72 64 gnd 2.080806f
R70 63 64 2.224404
C73 65 gnd 2.080806f
R71 64 65 2.224404
C74 66 gnd 2.080806f
R72 66 65 2.224404
C75 67 gnd 2.080806f
R73 67 66 2.224404
C76 68 gnd 2.080806f
R74 68 67 2.224404
C77 69 gnd 2.080806f
R75 69 68 2.224404
C78 70 gnd 2.080806f
R76 69 70 2.224404
C79 71 gnd 2.080806f
R77 70 71 2.224404
C80 72 gnd 2.080806f
R78 71 72 2.224404
R79 72 g545_3 2.224404
.ends

.subckt netg175 g175_1 g175_0 g175_2 gnd
C1  g175_1 gnd 2.080806f
C2  g175_0 gnd 2.080806f
C3  g175_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g175_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
R17 16 g175_1 2.224404
C20 17 gnd 2.080806f
R18 g175_1 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
R70 68 g175_2 2.224404
.ends

.subckt netg1658 g1658_4 g1658_1 g1658_2 g1658_5 g1658_3 g1658_0 gnd
C1  g1658_4 gnd 2.080806f
C2  g1658_1 gnd 2.080806f
C3  g1658_2 gnd 2.080806f
C4  g1658_5 gnd 2.080806f
C5  g1658_3 gnd 2.080806f
C6  g1658_0 gnd 2.080806f
R1 g1658_3 g1658_0 2.224404
C7 1 gnd 2.080806f
R2 g1658_3 1 2.224404
C8 2 gnd 2.080806f
R3 1 2 2.224404
C9 3 gnd 2.080806f
R4 3 2 2.224404
C10 4 gnd 2.080806f
R5 4 3 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
C14 8 gnd 2.080806f
R9 8 7 2.224404
R10 g1658_1 8 2.224404
C15 9 gnd 2.080806f
R11 9 g1658_1 2.224404
C16 10 gnd 2.080806f
R12 10 9 2.224404
C17 11 gnd 2.080806f
R13 11 10 2.224404
R14 g1658_2 11 2.224404
C18 12 gnd 2.080806f
R15 g1658_0 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
C54 48 gnd 2.080806f
R51 47 48 2.224404
C55 49 gnd 2.080806f
R52 48 49 2.224404
C56 50 gnd 2.080806f
R53 49 50 2.224404
C57 51 gnd 2.080806f
R54 50 51 2.224404
C58 52 gnd 2.080806f
R55 51 52 2.224404
C59 53 gnd 2.080806f
R56 52 53 2.224404
C60 54 gnd 2.080806f
R57 53 54 2.224404
C61 55 gnd 2.080806f
R58 54 55 2.224404
C62 56 gnd 2.080806f
R59 55 56 2.224404
C63 57 gnd 2.080806f
R60 56 57 2.224404
C64 58 gnd 2.080806f
R61 57 58 2.224404
C65 59 gnd 2.080806f
R62 58 59 2.224404
C66 60 gnd 2.080806f
R63 59 60 2.224404
C67 61 gnd 2.080806f
R64 60 61 2.224404
C68 62 gnd 2.080806f
R65 61 62 2.224404
C69 63 gnd 2.080806f
R66 62 63 2.224404
C70 64 gnd 2.080806f
R67 63 64 2.224404
C71 65 gnd 2.080806f
R68 65 64 2.224404
C72 66 gnd 2.080806f
R69 66 65 2.224404
C73 67 gnd 2.080806f
R70 66 67 2.224404
R71 67 g1658_4 2.224404
C74 68 gnd 2.080806f
R72 g1658_4 68 2.224404
C75 69 gnd 2.080806f
R73 68 69 2.224404
C76 70 gnd 2.080806f
R74 69 70 2.224404
C77 71 gnd 2.080806f
R75 70 71 2.224404
C78 72 gnd 2.080806f
R76 71 72 2.224404
C79 73 gnd 2.080806f
R77 72 73 2.224404
C80 74 gnd 2.080806f
R78 73 74 2.224404
R79 74 g1658_5 2.224404
.ends

.subckt netg7454 g7454_0 g7454_1 gnd
C1  g7454_0 gnd 2.080806f
C2  g7454_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7454_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 60 61 2.224404
C64 62 gnd 2.080806f
R62 61 62 2.224404
C65 63 gnd 2.080806f
R63 62 63 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 68 69 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
R71 g7454_1 70 2.224404
.ends

.subckt netg168 g168_2 g168_1 g168_0 gnd
C1  g168_2 gnd 2.080806f
C2  g168_1 gnd 2.080806f
C3  g168_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g168_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 45 44 2.224404
C49 46 gnd 2.080806f
R46 46 45 2.224404
C50 47 gnd 2.080806f
R47 47 46 2.224404
C51 48 gnd 2.080806f
R48 48 47 2.224404
C52 49 gnd 2.080806f
R49 49 48 2.224404
C53 50 gnd 2.080806f
R50 50 49 2.224404
R51 g168_1 50 2.224404
C54 51 gnd 2.080806f
R52 51 g168_1 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
R71 g168_2 69 2.224404
.ends

.subckt netg1646 g1646_2 g1646_0 g1646_4 g1646_5 g1646_3 g1646_1 gnd
C1  g1646_2 gnd 2.080806f
C2  g1646_0 gnd 2.080806f
C3  g1646_4 gnd 2.080806f
C4  g1646_5 gnd 2.080806f
C5  g1646_3 gnd 2.080806f
C6  g1646_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1646_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1646_2 2.224404
C9 3 gnd 2.080806f
R4 3 g1646_2 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
C14 8 gnd 2.080806f
R9 7 8 2.224404
R10 8 g1646_1 2.224404
C15 9 gnd 2.080806f
R11 g1646_1 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
C19 13 gnd 2.080806f
R15 12 13 2.224404
C20 14 gnd 2.080806f
R16 13 14 2.224404
C21 15 gnd 2.080806f
R17 14 15 2.224404
C22 16 gnd 2.080806f
R18 15 16 2.224404
C23 17 gnd 2.080806f
R19 16 17 2.224404
R20 17 g1646_3 2.224404
C24 18 gnd 2.080806f
R21 g1646_3 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
C54 48 gnd 2.080806f
R51 47 48 2.224404
C55 49 gnd 2.080806f
R52 48 49 2.224404
C56 50 gnd 2.080806f
R53 49 50 2.224404
C57 51 gnd 2.080806f
R54 50 51 2.224404
C58 52 gnd 2.080806f
R55 51 52 2.224404
C59 53 gnd 2.080806f
R56 52 53 2.224404
C60 54 gnd 2.080806f
R57 53 54 2.224404
C61 55 gnd 2.080806f
R58 54 55 2.224404
C62 56 gnd 2.080806f
R59 55 56 2.224404
C63 57 gnd 2.080806f
R60 56 57 2.224404
C64 58 gnd 2.080806f
R61 57 58 2.224404
C65 59 gnd 2.080806f
R62 58 59 2.224404
C66 60 gnd 2.080806f
R63 59 60 2.224404
C67 61 gnd 2.080806f
R64 60 61 2.224404
C68 62 gnd 2.080806f
R65 61 62 2.224404
C69 63 gnd 2.080806f
R66 62 63 2.224404
C70 64 gnd 2.080806f
R67 63 64 2.224404
C71 65 gnd 2.080806f
R68 65 64 2.224404
C72 66 gnd 2.080806f
R69 66 65 2.224404
C73 67 gnd 2.080806f
R70 66 67 2.224404
C74 68 gnd 2.080806f
R71 68 67 2.224404
C75 69 gnd 2.080806f
R72 68 69 2.224404
C76 70 gnd 2.080806f
R73 69 70 2.224404
C77 71 gnd 2.080806f
R74 70 71 2.224404
R75 g1646_5 71 2.224404
C78 72 gnd 2.080806f
R76 g1646_5 72 2.224404
C79 73 gnd 2.080806f
R77 72 73 2.224404
C80 74 gnd 2.080806f
R78 73 74 2.224404
C81 75 gnd 2.080806f
R79 74 75 2.224404
R80 75 g1646_4 2.224404
.ends

.subckt netg7486 g7486_1 g7486_0 gnd
C1  g7486_1 gnd 2.080806f
C2  g7486_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7486_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
R72 g7486_1 71 2.224404
.ends

.subckt netg470 g470_1 g470_0 g470_2 gnd
C1  g470_1 gnd 2.080806f
C2  g470_0 gnd 2.080806f
C3  g470_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g470_0 1 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
R7 g470_1 6 2.224404
C10 7 gnd 2.080806f
R8 g470_0 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
R72 70 g470_2 2.224404
.ends

.subckt netg7455 g7455_0 g7455_1 gnd
C1  g7455_0 gnd 2.080806f
C2  g7455_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7455_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 61 62 2.224404
C65 63 gnd 2.080806f
R63 62 63 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 70 71 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
R73 72 g7455_1 2.224404
.ends

.subckt netg473 g473_4 g473_3 g473_0 g473_5 g473_2 g473_1 gnd
C1  g473_4 gnd 2.080806f
C2  g473_3 gnd 2.080806f
C3  g473_0 gnd 2.080806f
C4  g473_5 gnd 2.080806f
C5  g473_2 gnd 2.080806f
C6  g473_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g473_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g473_4 2.224404
C10 4 gnd 2.080806f
R5 g473_4 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
C14 8 gnd 2.080806f
R9 7 8 2.224404
C15 9 gnd 2.080806f
R10 8 9 2.224404
C16 10 gnd 2.080806f
R11 9 10 2.224404
C17 11 gnd 2.080806f
R12 10 11 2.224404
C18 12 gnd 2.080806f
R13 11 12 2.224404
R14 12 g473_3 2.224404
C19 13 gnd 2.080806f
R15 13 12 2.224404
C20 14 gnd 2.080806f
R16 13 14 2.224404
C21 15 gnd 2.080806f
R17 15 14 2.224404
C22 16 gnd 2.080806f
R18 16 15 2.224404
C23 17 gnd 2.080806f
R19 17 16 2.224404
C24 18 gnd 2.080806f
R20 18 17 2.224404
C25 19 gnd 2.080806f
R21 19 18 2.224404
C26 20 gnd 2.080806f
R22 19 20 2.224404
C27 21 gnd 2.080806f
R23 21 20 2.224404
C28 22 gnd 2.080806f
R24 21 22 2.224404
C29 23 gnd 2.080806f
R25 22 23 2.224404
C30 24 gnd 2.080806f
R26 24 23 2.224404
C31 25 gnd 2.080806f
R27 24 25 2.224404
C32 26 gnd 2.080806f
R28 25 26 2.224404
C33 27 gnd 2.080806f
R29 27 26 2.224404
C34 28 gnd 2.080806f
R30 27 28 2.224404
R31 g473_2 28 2.224404
C35 29 gnd 2.080806f
R32 29 g473_4 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 35 34 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
C54 48 gnd 2.080806f
R51 47 48 2.224404
C55 49 gnd 2.080806f
R52 48 49 2.224404
C56 50 gnd 2.080806f
R53 49 50 2.224404
C57 51 gnd 2.080806f
R54 50 51 2.224404
C58 52 gnd 2.080806f
R55 51 52 2.224404
C59 53 gnd 2.080806f
R56 52 53 2.224404
C60 54 gnd 2.080806f
R57 53 54 2.224404
C61 55 gnd 2.080806f
R58 54 55 2.224404
C62 56 gnd 2.080806f
R59 55 56 2.224404
C63 57 gnd 2.080806f
R60 56 57 2.224404
C64 58 gnd 2.080806f
R61 57 58 2.224404
C65 59 gnd 2.080806f
R62 58 59 2.224404
C66 60 gnd 2.080806f
R63 59 60 2.224404
C67 61 gnd 2.080806f
R64 60 61 2.224404
C68 62 gnd 2.080806f
R65 61 62 2.224404
C69 63 gnd 2.080806f
R66 62 63 2.224404
C70 64 gnd 2.080806f
R67 63 64 2.224404
C71 65 gnd 2.080806f
R68 64 65 2.224404
C72 66 gnd 2.080806f
R69 65 66 2.224404
C73 67 gnd 2.080806f
R70 66 67 2.224404
C74 68 gnd 2.080806f
R71 68 67 2.224404
C75 69 gnd 2.080806f
R72 69 68 2.224404
C76 70 gnd 2.080806f
R73 69 70 2.224404
C77 71 gnd 2.080806f
R74 71 70 2.224404
C78 72 gnd 2.080806f
R75 71 72 2.224404
C79 73 gnd 2.080806f
R76 72 73 2.224404
R77 g473_1 73 2.224404
C80 74 gnd 2.080806f
R78 73 74 2.224404
C81 75 gnd 2.080806f
R79 74 75 2.224404
C82 76 gnd 2.080806f
R80 75 76 2.224404
C83 77 gnd 2.080806f
R81 76 77 2.224404
C84 78 gnd 2.080806f
R82 77 78 2.224404
C85 79 gnd 2.080806f
R83 78 79 2.224404
C86 80 gnd 2.080806f
R84 79 80 2.224404
C87 81 gnd 2.080806f
R85 80 81 2.224404
C88 82 gnd 2.080806f
R86 81 82 2.224404
C89 83 gnd 2.080806f
R87 82 83 2.224404
C90 84 gnd 2.080806f
R88 83 84 2.224404
C91 85 gnd 2.080806f
R89 84 85 2.224404
C92 86 gnd 2.080806f
R90 85 86 2.224404
C93 87 gnd 2.080806f
R91 86 87 2.224404
C94 88 gnd 2.080806f
R92 87 88 2.224404
C95 89 gnd 2.080806f
R93 88 89 2.224404
C96 90 gnd 2.080806f
R94 89 90 2.224404
C97 91 gnd 2.080806f
R95 90 91 2.224404
C98 92 gnd 2.080806f
R96 91 92 2.224404
C99 93 gnd 2.080806f
R97 92 93 2.224404
C100 94 gnd 2.080806f
R98 93 94 2.224404
C101 95 gnd 2.080806f
R99 94 95 2.224404
C102 96 gnd 2.080806f
R100 95 96 2.224404
R101 96 g473_5 2.224404
.ends

.subckt netg1638 g1638_4 g1638_2 g1638_0 g1638_7 g1638_1 g1638_5 g1638_3 gnd
C1  g1638_4 gnd 2.080806f
C2  g1638_2 gnd 2.080806f
C3  g1638_0 gnd 2.080806f
C4  g1638_7 gnd 2.080806f
C5  g1638_1 gnd 2.080806f
C6  g1638_5 gnd 2.080806f
C7  g1638_3 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g1638_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1638_4 2.224404
C10 3 gnd 2.080806f
R4 g1638_4 3 2.224404
C11 4 gnd 2.080806f
R5 3 4 2.224404
C12 5 gnd 2.080806f
R6 4 5 2.224404
R7 5 g1638_3 2.224404
C13 6 gnd 2.080806f
R8 6 g1638_0 2.224404
C14 7 gnd 2.080806f
R9 7 6 2.224404
C15 8 gnd 2.080806f
R10 8 7 2.224404
C16 9 gnd 2.080806f
R11 9 8 2.224404
C17 10 gnd 2.080806f
R12 10 9 2.224404
C18 11 gnd 2.080806f
R13 11 10 2.224404
C19 12 gnd 2.080806f
R14 12 11 2.224404
C20 13 gnd 2.080806f
R15 13 12 2.224404
C21 14 gnd 2.080806f
R16 14 13 2.224404
C22 15 gnd 2.080806f
R17 15 14 2.224404
C23 16 gnd 2.080806f
R18 16 15 2.224404
C24 17 gnd 2.080806f
R19 17 16 2.224404
C25 18 gnd 2.080806f
R20 18 17 2.224404
C26 19 gnd 2.080806f
R21 19 18 2.224404
R22 g1638_7 19 2.224404
R23 g1638_5 g1638_7 2.224404
C27 20 gnd 2.080806f
R24 g1638_3 20 2.224404
C28 21 gnd 2.080806f
R25 20 21 2.224404
C29 22 gnd 2.080806f
R26 21 22 2.224404
C30 23 gnd 2.080806f
R27 22 23 2.224404
C31 24 gnd 2.080806f
R28 23 24 2.224404
C32 25 gnd 2.080806f
R29 24 25 2.224404
C33 26 gnd 2.080806f
R30 25 26 2.224404
C34 27 gnd 2.080806f
R31 26 27 2.224404
C35 28 gnd 2.080806f
R32 27 28 2.224404
C36 29 gnd 2.080806f
R33 28 29 2.224404
C37 30 gnd 2.080806f
R34 29 30 2.224404
C38 31 gnd 2.080806f
R35 30 31 2.224404
C39 32 gnd 2.080806f
R36 31 32 2.224404
C40 33 gnd 2.080806f
R37 32 33 2.224404
C41 34 gnd 2.080806f
R38 33 34 2.224404
C42 35 gnd 2.080806f
R39 34 35 2.224404
C43 36 gnd 2.080806f
R40 35 36 2.224404
C44 37 gnd 2.080806f
R41 36 37 2.224404
C45 38 gnd 2.080806f
R42 37 38 2.224404
C46 39 gnd 2.080806f
R43 38 39 2.224404
C47 40 gnd 2.080806f
R44 39 40 2.224404
C48 41 gnd 2.080806f
R45 40 41 2.224404
C49 42 gnd 2.080806f
R46 41 42 2.224404
C50 43 gnd 2.080806f
R47 43 42 2.224404
C51 44 gnd 2.080806f
R48 43 44 2.224404
C52 45 gnd 2.080806f
R49 44 45 2.224404
C53 46 gnd 2.080806f
R50 46 45 2.224404
C54 47 gnd 2.080806f
R51 46 47 2.224404
C55 48 gnd 2.080806f
R52 47 48 2.224404
C56 49 gnd 2.080806f
R53 48 49 2.224404
C57 50 gnd 2.080806f
R54 49 50 2.224404
C58 51 gnd 2.080806f
R55 50 51 2.224404
C59 52 gnd 2.080806f
R56 51 52 2.224404
C60 53 gnd 2.080806f
R57 52 53 2.224404
C61 54 gnd 2.080806f
R58 53 54 2.224404
C62 55 gnd 2.080806f
R59 54 55 2.224404
C63 56 gnd 2.080806f
R60 55 56 2.224404
C64 57 gnd 2.080806f
R61 56 57 2.224404
C65 58 gnd 2.080806f
R62 57 58 2.224404
C66 59 gnd 2.080806f
R63 58 59 2.224404
C67 60 gnd 2.080806f
R64 59 60 2.224404
C68 61 gnd 2.080806f
R65 60 61 2.224404
C69 62 gnd 2.080806f
R66 61 62 2.224404
C70 63 gnd 2.080806f
R67 62 63 2.224404
C71 64 gnd 2.080806f
R68 63 64 2.224404
C72 65 gnd 2.080806f
R69 64 65 2.224404
C73 66 gnd 2.080806f
R70 65 66 2.224404
C74 67 gnd 2.080806f
R71 67 66 2.224404
C75 68 gnd 2.080806f
R72 68 67 2.224404
C76 69 gnd 2.080806f
R73 68 69 2.224404
C77 70 gnd 2.080806f
R74 69 70 2.224404
C78 71 gnd 2.080806f
R75 70 71 2.224404
C79 72 gnd 2.080806f
R76 71 72 2.224404
C80 73 gnd 2.080806f
R77 72 73 2.224404
C81 74 gnd 2.080806f
R78 73 74 2.224404
C82 75 gnd 2.080806f
R79 74 75 2.224404
C83 76 gnd 2.080806f
R80 76 75 2.224404
C84 77 gnd 2.080806f
R81 77 76 2.224404
C85 78 gnd 2.080806f
R82 78 77 2.224404
C86 79 gnd 2.080806f
R83 79 78 2.224404
R84 79 g1638_1 2.224404
C87 80 gnd 2.080806f
R85 80 g1638_1 2.224404
C88 81 gnd 2.080806f
R86 80 81 2.224404
C89 82 gnd 2.080806f
R87 81 82 2.224404
C90 83 gnd 2.080806f
R88 83 82 2.224404
C91 84 gnd 2.080806f
R89 84 83 2.224404
R90 g1638_2 84 2.224404
.ends

.subckt netg7470 g7470_1 g7470_0 gnd
C1  g7470_1 gnd 2.080806f
C2  g7470_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7470_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
R75 74 g7470_1 2.224404
.ends

.subckt netg7471 g7471_1 g7471_0 gnd
C1  g7471_1 gnd 2.080806f
C2  g7471_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7471_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
R75 74 g7471_1 2.224404
.ends

.subckt netg205 g205_2 g205_0 g205_1 gnd
C1  g205_2 gnd 2.080806f
C2  g205_0 gnd 2.080806f
C3  g205_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g205_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
R31 30 g205_2 2.224404
C34 31 gnd 2.080806f
R32 g205_2 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
R84 82 g205_1 2.224404
.ends

.subckt netg7460 g7460_1 g7460_0 gnd
C1  g7460_1 gnd 2.080806f
C2  g7460_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7460_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 57 58 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
C77 75 gnd 2.080806f
R75 74 75 2.224404
R76 75 g7460_1 2.224404
.ends

.subckt netg2270 g2270_0 g2270_3 g2270_4 g2270_5 g2270_2 g2270_1 gnd
C1  g2270_0 gnd 2.080806f
C2  g2270_3 gnd 2.080806f
C3  g2270_4 gnd 2.080806f
C4  g2270_5 gnd 2.080806f
C5  g2270_2 gnd 2.080806f
C6  g2270_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g2270_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
C10 4 gnd 2.080806f
R4 4 3 2.224404
C11 5 gnd 2.080806f
R5 5 4 2.224404
C12 6 gnd 2.080806f
R6 6 5 2.224404
C13 7 gnd 2.080806f
R7 7 6 2.224404
R8 g2270_4 7 2.224404
C14 8 gnd 2.080806f
R9 8 g2270_4 2.224404
C15 9 gnd 2.080806f
R10 9 8 2.224404
C16 10 gnd 2.080806f
R11 10 9 2.224404
R12 g2270_3 10 2.224404
C17 11 gnd 2.080806f
R13 11 g2270_3 2.224404
R14 g2270_5 11 2.224404
C18 12 gnd 2.080806f
R15 g2270_0 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 20 19 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 31 30 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 47 46 2.224404
R51 g2270_2 47 2.224404
C54 48 gnd 2.080806f
R52 46 48 2.224404
C55 49 gnd 2.080806f
R53 48 49 2.224404
C56 50 gnd 2.080806f
R54 49 50 2.224404
C57 51 gnd 2.080806f
R55 50 51 2.224404
C58 52 gnd 2.080806f
R56 51 52 2.224404
C59 53 gnd 2.080806f
R57 52 53 2.224404
C60 54 gnd 2.080806f
R58 53 54 2.224404
C61 55 gnd 2.080806f
R59 54 55 2.224404
C62 56 gnd 2.080806f
R60 55 56 2.224404
C63 57 gnd 2.080806f
R61 56 57 2.224404
C64 58 gnd 2.080806f
R62 57 58 2.224404
C65 59 gnd 2.080806f
R63 58 59 2.224404
C66 60 gnd 2.080806f
R64 59 60 2.224404
C67 61 gnd 2.080806f
R65 60 61 2.224404
C68 62 gnd 2.080806f
R66 61 62 2.224404
C69 63 gnd 2.080806f
R67 62 63 2.224404
C70 64 gnd 2.080806f
R68 63 64 2.224404
C71 65 gnd 2.080806f
R69 64 65 2.224404
C72 66 gnd 2.080806f
R70 65 66 2.224404
C73 67 gnd 2.080806f
R71 66 67 2.224404
C74 68 gnd 2.080806f
R72 67 68 2.224404
C75 69 gnd 2.080806f
R73 68 69 2.224404
C76 70 gnd 2.080806f
R74 69 70 2.224404
C77 71 gnd 2.080806f
R75 70 71 2.224404
C78 72 gnd 2.080806f
R76 71 72 2.224404
C79 73 gnd 2.080806f
R77 72 73 2.224404
C80 74 gnd 2.080806f
R78 73 74 2.224404
C81 75 gnd 2.080806f
R79 74 75 2.224404
C82 76 gnd 2.080806f
R80 75 76 2.224404
C83 77 gnd 2.080806f
R81 76 77 2.224404
R82 77 g2270_1 2.224404
.ends

.subckt netg7450 g7450_0 g7450_1 gnd
C1  g7450_0 gnd 2.080806f
C2  g7450_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7450_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 57 58 2.224404
C61 59 gnd 2.080806f
R59 58 59 2.224404
C62 60 gnd 2.080806f
R60 59 60 2.224404
C63 61 gnd 2.080806f
R61 60 61 2.224404
C64 62 gnd 2.080806f
R62 61 62 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 66 67 2.224404
C70 68 gnd 2.080806f
R68 67 68 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 70 71 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
R77 g7450_1 76 2.224404
.ends

.subckt netg7504 g7504_0 g7504_1 gnd
C1  g7504_0 gnd 2.080806f
C2  g7504_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7504_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 59 60 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 74 75 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
R77 g7504_1 76 2.224404
.ends

.subckt netg7449 g7449_1 g7449_0 gnd
C1  g7449_1 gnd 2.080806f
C2  g7449_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7449_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 58 59 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 66 67 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 74 75 2.224404
C78 76 gnd 2.080806f
R76 75 76 2.224404
R77 76 g7449_1 2.224404
.ends

.subckt netg7503 g7503_0 g7503_1 gnd
C1  g7503_0 gnd 2.080806f
C2  g7503_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7503_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
R77 g7503_1 76 2.224404
.ends

.subckt netg197 g197_0 g197_1 g197_2 gnd
C1  g197_0 gnd 2.080806f
C2  g197_1 gnd 2.080806f
C3  g197_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g197_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
R32 g197_1 31 2.224404
C35 32 gnd 2.080806f
R33 27 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
R80 g197_2 78 2.224404
.ends

.subckt netg4 g4_2 g4_1 g4_0 gnd
C1  g4_2 gnd 2.080806f
C2  g4_1 gnd 2.080806f
C3  g4_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g4_0 1 2.224404
R2 1 g4_2 2.224404
C5 2 gnd 2.080806f
R3 2 g4_0 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
R78 g4_1 76 2.224404
.ends

.subckt netg1750 g1750_4 g1750_0 g1750_2 g1750_5 g1750_3 g1750_1 gnd
C1  g1750_4 gnd 2.080806f
C2  g1750_0 gnd 2.080806f
C3  g1750_2 gnd 2.080806f
C4  g1750_5 gnd 2.080806f
C5  g1750_3 gnd 2.080806f
C6  g1750_1 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g1750_0 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 g1750_4 2 2.224404
C9 3 gnd 2.080806f
R4 g1750_0 3 2.224404
C10 4 gnd 2.080806f
R5 3 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
C13 7 gnd 2.080806f
R8 6 7 2.224404
C14 8 gnd 2.080806f
R9 7 8 2.224404
C15 9 gnd 2.080806f
R10 8 9 2.224404
C16 10 gnd 2.080806f
R11 9 10 2.224404
C17 11 gnd 2.080806f
R12 10 11 2.224404
C18 12 gnd 2.080806f
R13 11 12 2.224404
C19 13 gnd 2.080806f
R14 12 13 2.224404
R15 13 g1750_2 2.224404
C20 14 gnd 2.080806f
R16 14 13 2.224404
C21 15 gnd 2.080806f
R17 14 15 2.224404
C22 16 gnd 2.080806f
R18 16 15 2.224404
C23 17 gnd 2.080806f
R19 17 16 2.224404
C24 18 gnd 2.080806f
R20 18 17 2.224404
C25 19 gnd 2.080806f
R21 19 18 2.224404
C26 20 gnd 2.080806f
R22 20 19 2.224404
C27 21 gnd 2.080806f
R23 20 21 2.224404
C28 22 gnd 2.080806f
R24 22 21 2.224404
C29 23 gnd 2.080806f
R25 22 23 2.224404
C30 24 gnd 2.080806f
R26 23 24 2.224404
C31 25 gnd 2.080806f
R27 25 24 2.224404
C32 26 gnd 2.080806f
R28 25 26 2.224404
C33 27 gnd 2.080806f
R29 26 27 2.224404
C34 28 gnd 2.080806f
R30 28 27 2.224404
C35 29 gnd 2.080806f
R31 28 29 2.224404
R32 g1750_1 29 2.224404
C36 30 gnd 2.080806f
R33 g1750_2 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 33 32 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
C54 48 gnd 2.080806f
R51 47 48 2.224404
C55 49 gnd 2.080806f
R52 48 49 2.224404
C56 50 gnd 2.080806f
R53 49 50 2.224404
C57 51 gnd 2.080806f
R54 50 51 2.224404
C58 52 gnd 2.080806f
R55 51 52 2.224404
C59 53 gnd 2.080806f
R56 52 53 2.224404
C60 54 gnd 2.080806f
R57 53 54 2.224404
C61 55 gnd 2.080806f
R58 54 55 2.224404
C62 56 gnd 2.080806f
R59 55 56 2.224404
C63 57 gnd 2.080806f
R60 56 57 2.224404
C64 58 gnd 2.080806f
R61 57 58 2.224404
C65 59 gnd 2.080806f
R62 58 59 2.224404
C66 60 gnd 2.080806f
R63 59 60 2.224404
C67 61 gnd 2.080806f
R64 60 61 2.224404
C68 62 gnd 2.080806f
R65 61 62 2.224404
C69 63 gnd 2.080806f
R66 62 63 2.224404
C70 64 gnd 2.080806f
R67 63 64 2.224404
C71 65 gnd 2.080806f
R68 64 65 2.224404
C72 66 gnd 2.080806f
R69 65 66 2.224404
C73 67 gnd 2.080806f
R70 66 67 2.224404
C74 68 gnd 2.080806f
R71 67 68 2.224404
C75 69 gnd 2.080806f
R72 68 69 2.224404
C76 70 gnd 2.080806f
R73 69 70 2.224404
C77 71 gnd 2.080806f
R74 70 71 2.224404
C78 72 gnd 2.080806f
R75 71 72 2.224404
C79 73 gnd 2.080806f
R76 72 73 2.224404
C80 74 gnd 2.080806f
R77 73 74 2.224404
C81 75 gnd 2.080806f
R78 74 75 2.224404
C82 76 gnd 2.080806f
R79 75 76 2.224404
C83 77 gnd 2.080806f
R80 76 77 2.224404
C84 78 gnd 2.080806f
R81 77 78 2.224404
C85 79 gnd 2.080806f
R82 79 78 2.224404
C86 80 gnd 2.080806f
R83 80 79 2.224404
C87 81 gnd 2.080806f
R84 80 81 2.224404
C88 82 gnd 2.080806f
R85 82 81 2.224404
C89 83 gnd 2.080806f
R86 83 82 2.224404
C90 84 gnd 2.080806f
R87 84 83 2.224404
R88 g1750_5 84 2.224404
C91 85 gnd 2.080806f
R89 81 85 2.224404
C92 86 gnd 2.080806f
R90 85 86 2.224404
C93 87 gnd 2.080806f
R91 86 87 2.224404
C94 88 gnd 2.080806f
R92 87 88 2.224404
C95 89 gnd 2.080806f
R93 88 89 2.224404
C96 90 gnd 2.080806f
R94 89 90 2.224404
C97 91 gnd 2.080806f
R95 90 91 2.224404
C98 92 gnd 2.080806f
R96 91 92 2.224404
C99 93 gnd 2.080806f
R97 92 93 2.224404
C100 94 gnd 2.080806f
R98 93 94 2.224404
C101 95 gnd 2.080806f
R99 94 95 2.224404
C102 96 gnd 2.080806f
R100 95 96 2.224404
C103 97 gnd 2.080806f
R101 96 97 2.224404
C104 98 gnd 2.080806f
R102 98 97 2.224404
C105 99 gnd 2.080806f
R103 99 98 2.224404
R104 g1750_3 99 2.224404
.ends

.subckt netg457 g457_6 g457_2 g457_5 g457_1 g457_4 g457_3 g457_0 gnd
C1  g457_6 gnd 2.080806f
C2  g457_2 gnd 2.080806f
C3  g457_5 gnd 2.080806f
C4  g457_1 gnd 2.080806f
C5  g457_4 gnd 2.080806f
C6  g457_3 gnd 2.080806f
C7  g457_0 gnd 2.080806f
C8 1 gnd 2.080806f
R1 g457_0 1 2.224404
C9 2 gnd 2.080806f
R2 1 2 2.224404
C10 3 gnd 2.080806f
R3 3 2 2.224404
C11 4 gnd 2.080806f
R4 4 3 2.224404
C12 5 gnd 2.080806f
R5 4 5 2.224404
C13 6 gnd 2.080806f
R6 6 5 2.224404
C14 7 gnd 2.080806f
R7 6 7 2.224404
C15 8 gnd 2.080806f
R8 7 8 2.224404
R9 8 g457_1 2.224404
C16 9 gnd 2.080806f
R10 9 g457_0 2.224404
C17 10 gnd 2.080806f
R11 10 9 2.224404
C18 11 gnd 2.080806f
R12 11 10 2.224404
C19 12 gnd 2.080806f
R13 12 11 2.224404
C20 13 gnd 2.080806f
R14 13 12 2.224404
C21 14 gnd 2.080806f
R15 14 13 2.224404
C22 15 gnd 2.080806f
R16 15 14 2.224404
C23 16 gnd 2.080806f
R17 16 15 2.224404
C24 17 gnd 2.080806f
R18 17 16 2.224404
R19 g457_3 17 2.224404
C25 18 gnd 2.080806f
R20 g457_3 18 2.224404
C26 19 gnd 2.080806f
R21 18 19 2.224404
C27 20 gnd 2.080806f
R22 19 20 2.224404
C28 21 gnd 2.080806f
R23 20 21 2.224404
C29 22 gnd 2.080806f
R24 21 22 2.224404
C30 23 gnd 2.080806f
R25 22 23 2.224404
C31 24 gnd 2.080806f
R26 23 24 2.224404
C32 25 gnd 2.080806f
R27 24 25 2.224404
C33 26 gnd 2.080806f
R28 25 26 2.224404
C34 27 gnd 2.080806f
R29 26 27 2.224404
C35 28 gnd 2.080806f
R30 27 28 2.224404
C36 29 gnd 2.080806f
R31 28 29 2.224404
R32 29 g457_2 2.224404
C37 30 gnd 2.080806f
R33 g457_2 30 2.224404
C38 31 gnd 2.080806f
R34 30 31 2.224404
C39 32 gnd 2.080806f
R35 31 32 2.224404
C40 33 gnd 2.080806f
R36 32 33 2.224404
R37 33 g457_5 2.224404
C41 34 gnd 2.080806f
R38 g457_1 34 2.224404
C42 35 gnd 2.080806f
R39 34 35 2.224404
C43 36 gnd 2.080806f
R40 35 36 2.224404
C44 37 gnd 2.080806f
R41 36 37 2.224404
C45 38 gnd 2.080806f
R42 37 38 2.224404
C46 39 gnd 2.080806f
R43 38 39 2.224404
C47 40 gnd 2.080806f
R44 39 40 2.224404
C48 41 gnd 2.080806f
R45 40 41 2.224404
C49 42 gnd 2.080806f
R46 41 42 2.224404
C50 43 gnd 2.080806f
R47 42 43 2.224404
C51 44 gnd 2.080806f
R48 43 44 2.224404
C52 45 gnd 2.080806f
R49 44 45 2.224404
C53 46 gnd 2.080806f
R50 45 46 2.224404
C54 47 gnd 2.080806f
R51 46 47 2.224404
C55 48 gnd 2.080806f
R52 47 48 2.224404
C56 49 gnd 2.080806f
R53 48 49 2.224404
C57 50 gnd 2.080806f
R54 49 50 2.224404
C58 51 gnd 2.080806f
R55 50 51 2.224404
C59 52 gnd 2.080806f
R56 51 52 2.224404
C60 53 gnd 2.080806f
R57 52 53 2.224404
C61 54 gnd 2.080806f
R58 53 54 2.224404
C62 55 gnd 2.080806f
R59 54 55 2.224404
C63 56 gnd 2.080806f
R60 55 56 2.224404
C64 57 gnd 2.080806f
R61 56 57 2.224404
C65 58 gnd 2.080806f
R62 57 58 2.224404
C66 59 gnd 2.080806f
R63 58 59 2.224404
C67 60 gnd 2.080806f
R64 59 60 2.224404
C68 61 gnd 2.080806f
R65 60 61 2.224404
C69 62 gnd 2.080806f
R66 61 62 2.224404
C70 63 gnd 2.080806f
R67 62 63 2.224404
C71 64 gnd 2.080806f
R68 63 64 2.224404
C72 65 gnd 2.080806f
R69 64 65 2.224404
C73 66 gnd 2.080806f
R70 65 66 2.224404
C74 67 gnd 2.080806f
R71 66 67 2.224404
C75 68 gnd 2.080806f
R72 68 67 2.224404
C76 69 gnd 2.080806f
R73 68 69 2.224404
C77 70 gnd 2.080806f
R74 69 70 2.224404
C78 71 gnd 2.080806f
R75 70 71 2.224404
C79 72 gnd 2.080806f
R76 72 71 2.224404
C80 73 gnd 2.080806f
R77 72 73 2.224404
C81 74 gnd 2.080806f
R78 73 74 2.224404
C82 75 gnd 2.080806f
R79 75 74 2.224404
C83 76 gnd 2.080806f
R80 76 75 2.224404
C84 77 gnd 2.080806f
R81 76 77 2.224404
C85 78 gnd 2.080806f
R82 78 77 2.224404
C86 79 gnd 2.080806f
R83 79 78 2.224404
C87 80 gnd 2.080806f
R84 79 80 2.224404
R85 g457_6 80 2.224404
C88 81 gnd 2.080806f
R86 80 81 2.224404
C89 82 gnd 2.080806f
R87 81 82 2.224404
C90 83 gnd 2.080806f
R88 82 83 2.224404
C91 84 gnd 2.080806f
R89 83 84 2.224404
C92 85 gnd 2.080806f
R90 84 85 2.224404
C93 86 gnd 2.080806f
R91 85 86 2.224404
C94 87 gnd 2.080806f
R92 86 87 2.224404
C95 88 gnd 2.080806f
R93 87 88 2.224404
C96 89 gnd 2.080806f
R94 88 89 2.224404
C97 90 gnd 2.080806f
R95 89 90 2.224404
C98 91 gnd 2.080806f
R96 90 91 2.224404
C99 92 gnd 2.080806f
R97 91 92 2.224404
C100 93 gnd 2.080806f
R98 92 93 2.224404
C101 94 gnd 2.080806f
R99 93 94 2.224404
C102 95 gnd 2.080806f
R100 94 95 2.224404
C103 96 gnd 2.080806f
R101 95 96 2.224404
C104 97 gnd 2.080806f
R102 96 97 2.224404
C105 98 gnd 2.080806f
R103 97 98 2.224404
C106 99 gnd 2.080806f
R104 98 99 2.224404
C107 100 gnd 2.080806f
R105 99 100 2.224404
C108 101 gnd 2.080806f
R106 100 101 2.224404
C109 102 gnd 2.080806f
R107 101 102 2.224404
R108 102 g457_4 2.224404
.ends

.subckt netg1738 g1738_5 g1738_2 g1738_1 g1738_4 g1738_3 g1738_0 gnd
C1  g1738_5 gnd 2.080806f
C2  g1738_2 gnd 2.080806f
C3  g1738_1 gnd 2.080806f
C4  g1738_4 gnd 2.080806f
C5  g1738_3 gnd 2.080806f
C6  g1738_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1738_0 1 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
R4 g1738_3 3 2.224404
C10 4 gnd 2.080806f
R5 4 g1738_0 2.224404
C11 5 gnd 2.080806f
R6 5 4 2.224404
C12 6 gnd 2.080806f
R7 6 5 2.224404
C13 7 gnd 2.080806f
R8 7 6 2.224404
R9 g1738_4 7 2.224404
C14 8 gnd 2.080806f
R10 g1738_3 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
R14 g1738_5 11 2.224404
C18 12 gnd 2.080806f
R15 1 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
C54 48 gnd 2.080806f
R51 47 48 2.224404
C55 49 gnd 2.080806f
R52 48 49 2.224404
C56 50 gnd 2.080806f
R53 49 50 2.224404
C57 51 gnd 2.080806f
R54 50 51 2.224404
C58 52 gnd 2.080806f
R55 51 52 2.224404
C59 53 gnd 2.080806f
R56 52 53 2.224404
C60 54 gnd 2.080806f
R57 53 54 2.224404
C61 55 gnd 2.080806f
R58 54 55 2.224404
R59 55 g1738_1 2.224404
C62 56 gnd 2.080806f
R60 56 55 2.224404
C63 57 gnd 2.080806f
R61 57 56 2.224404
C64 58 gnd 2.080806f
R62 58 57 2.224404
C65 59 gnd 2.080806f
R63 59 58 2.224404
C66 60 gnd 2.080806f
R64 60 59 2.224404
C67 61 gnd 2.080806f
R65 61 60 2.224404
C68 62 gnd 2.080806f
R66 61 62 2.224404
C69 63 gnd 2.080806f
R67 62 63 2.224404
C70 64 gnd 2.080806f
R68 63 64 2.224404
C71 65 gnd 2.080806f
R69 64 65 2.224404
C72 66 gnd 2.080806f
R70 65 66 2.224404
C73 67 gnd 2.080806f
R71 66 67 2.224404
C74 68 gnd 2.080806f
R72 67 68 2.224404
C75 69 gnd 2.080806f
R73 68 69 2.224404
C76 70 gnd 2.080806f
R74 69 70 2.224404
C77 71 gnd 2.080806f
R75 70 71 2.224404
C78 72 gnd 2.080806f
R76 71 72 2.224404
C79 73 gnd 2.080806f
R77 72 73 2.224404
C80 74 gnd 2.080806f
R78 73 74 2.224404
C81 75 gnd 2.080806f
R79 74 75 2.224404
C82 76 gnd 2.080806f
R80 75 76 2.224404
C83 77 gnd 2.080806f
R81 76 77 2.224404
C84 78 gnd 2.080806f
R82 77 78 2.224404
C85 79 gnd 2.080806f
R83 78 79 2.224404
C86 80 gnd 2.080806f
R84 79 80 2.224404
C87 81 gnd 2.080806f
R85 80 81 2.224404
C88 82 gnd 2.080806f
R86 81 82 2.224404
C89 83 gnd 2.080806f
R87 82 83 2.224404
C90 84 gnd 2.080806f
R88 83 84 2.224404
C91 85 gnd 2.080806f
R89 84 85 2.224404
C92 86 gnd 2.080806f
R90 85 86 2.224404
C93 87 gnd 2.080806f
R91 86 87 2.224404
C94 88 gnd 2.080806f
R92 88 87 2.224404
R93 88 g1738_2 2.224404
.ends

.subckt netg183 g183_0 g183_1 g183_2 gnd
C1  g183_0 gnd 2.080806f
C2  g183_1 gnd 2.080806f
C3  g183_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g183_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
R33 32 g183_2 2.224404
C36 33 gnd 2.080806f
R34 g183_0 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
R85 83 g183_1 2.224404
.ends

.subckt netg7465 g7465_1 g7465_0 gnd
C1  g7465_1 gnd 2.080806f
C2  g7465_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7465_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 51 52 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 60 61 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 66 67 2.224404
C70 68 gnd 2.080806f
R68 67 68 2.224404
C71 69 gnd 2.080806f
R69 68 69 2.224404
C72 70 gnd 2.080806f
R70 69 70 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
C79 77 gnd 2.080806f
R77 77 76 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
R79 g7465_1 78 2.224404
.ends

.subckt netg3 g3_2 g3_1 g3_0 gnd
C1  g3_2 gnd 2.080806f
C2  g3_1 gnd 2.080806f
C3  g3_0 gnd 2.080806f
R1 g3_0 g3_2 2.224404
C4 1 gnd 2.080806f
R2 1 g3_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
R81 g3_1 79 2.224404
.ends

.subckt netg1 g1_3 g1_1 g1_0 g1_2 gnd
C1  g1_3 gnd 2.080806f
C2  g1_1 gnd 2.080806f
C3  g1_0 gnd 2.080806f
C4  g1_2 gnd 2.080806f
R1 g1_0 g1_1 2.224404
C5 1 gnd 2.080806f
R2 1 g1_0 2.224404
C6 2 gnd 2.080806f
R3 2 1 2.224404
C7 3 gnd 2.080806f
R4 3 2 2.224404
C8 4 gnd 2.080806f
R5 4 3 2.224404
C9 5 gnd 2.080806f
R6 4 5 2.224404
C10 6 gnd 2.080806f
R7 6 5 2.224404
C11 7 gnd 2.080806f
R8 7 6 2.224404
C12 8 gnd 2.080806f
R9 8 7 2.224404
C13 9 gnd 2.080806f
R10 9 8 2.224404
C14 10 gnd 2.080806f
R11 10 9 2.224404
C15 11 gnd 2.080806f
R12 11 10 2.224404
C16 12 gnd 2.080806f
R13 12 11 2.224404
C17 13 gnd 2.080806f
R14 13 12 2.224404
C18 14 gnd 2.080806f
R15 14 13 2.224404
C19 15 gnd 2.080806f
R16 15 14 2.224404
C20 16 gnd 2.080806f
R17 16 15 2.224404
C21 17 gnd 2.080806f
R18 17 16 2.224404
C22 18 gnd 2.080806f
R19 18 17 2.224404
C23 19 gnd 2.080806f
R20 19 18 2.224404
C24 20 gnd 2.080806f
R21 20 19 2.224404
C25 21 gnd 2.080806f
R22 21 20 2.224404
C26 22 gnd 2.080806f
R23 22 21 2.224404
C27 23 gnd 2.080806f
R24 23 22 2.224404
C28 24 gnd 2.080806f
R25 24 23 2.224404
C29 25 gnd 2.080806f
R26 25 24 2.224404
C30 26 gnd 2.080806f
R27 26 25 2.224404
C31 27 gnd 2.080806f
R28 27 26 2.224404
C32 28 gnd 2.080806f
R29 28 27 2.224404
C33 29 gnd 2.080806f
R30 29 28 2.224404
C34 30 gnd 2.080806f
R31 30 29 2.224404
C35 31 gnd 2.080806f
R32 31 30 2.224404
C36 32 gnd 2.080806f
R33 32 31 2.224404
C37 33 gnd 2.080806f
R34 33 32 2.224404
C38 34 gnd 2.080806f
R35 34 33 2.224404
C39 35 gnd 2.080806f
R36 35 34 2.224404
C40 36 gnd 2.080806f
R37 36 35 2.224404
C41 37 gnd 2.080806f
R38 37 36 2.224404
C42 38 gnd 2.080806f
R39 38 37 2.224404
R40 g1_3 38 2.224404
C43 39 gnd 2.080806f
R41 39 g1_3 2.224404
C44 40 gnd 2.080806f
R42 40 39 2.224404
C45 41 gnd 2.080806f
R43 41 40 2.224404
C46 42 gnd 2.080806f
R44 42 41 2.224404
C47 43 gnd 2.080806f
R45 43 42 2.224404
C48 44 gnd 2.080806f
R46 44 43 2.224404
C49 45 gnd 2.080806f
R47 45 44 2.224404
C50 46 gnd 2.080806f
R48 46 45 2.224404
C51 47 gnd 2.080806f
R49 47 46 2.224404
C52 48 gnd 2.080806f
R50 48 47 2.224404
C53 49 gnd 2.080806f
R51 49 48 2.224404
C54 50 gnd 2.080806f
R52 50 49 2.224404
C55 51 gnd 2.080806f
R53 51 50 2.224404
C56 52 gnd 2.080806f
R54 52 51 2.224404
C57 53 gnd 2.080806f
R55 53 52 2.224404
C58 54 gnd 2.080806f
R56 54 53 2.224404
C59 55 gnd 2.080806f
R57 55 54 2.224404
C60 56 gnd 2.080806f
R58 56 55 2.224404
C61 57 gnd 2.080806f
R59 57 56 2.224404
C62 58 gnd 2.080806f
R60 58 57 2.224404
C63 59 gnd 2.080806f
R61 59 58 2.224404
C64 60 gnd 2.080806f
R62 60 59 2.224404
C65 61 gnd 2.080806f
R63 61 60 2.224404
C66 62 gnd 2.080806f
R64 62 61 2.224404
C67 63 gnd 2.080806f
R65 63 62 2.224404
C68 64 gnd 2.080806f
R66 64 63 2.224404
C69 65 gnd 2.080806f
R67 65 64 2.224404
C70 66 gnd 2.080806f
R68 66 65 2.224404
C71 67 gnd 2.080806f
R69 67 66 2.224404
C72 68 gnd 2.080806f
R70 68 67 2.224404
C73 69 gnd 2.080806f
R71 69 68 2.224404
C74 70 gnd 2.080806f
R72 70 69 2.224404
C75 71 gnd 2.080806f
R73 71 70 2.224404
C76 72 gnd 2.080806f
R74 72 71 2.224404
C77 73 gnd 2.080806f
R75 73 72 2.224404
C78 74 gnd 2.080806f
R76 74 73 2.224404
C79 75 gnd 2.080806f
R77 75 74 2.224404
C80 76 gnd 2.080806f
R78 76 75 2.224404
C81 77 gnd 2.080806f
R79 77 76 2.224404
C82 78 gnd 2.080806f
R80 78 77 2.224404
C83 79 gnd 2.080806f
R81 79 78 2.224404
R82 g1_2 79 2.224404
.ends

.subckt netg167 g167_1 g167_2 g167_0 gnd
C1  g167_1 gnd 2.080806f
C2  g167_2 gnd 2.080806f
C3  g167_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g167_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
R21 g167_2 20 2.224404
C24 21 gnd 2.080806f
R22 g167_0 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
R80 78 g167_1 2.224404
.ends

.subckt netg7448 g7448_0 g7448_1 gnd
C1  g7448_0 gnd 2.080806f
C2  g7448_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7448_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 69 70 2.224404
C73 71 gnd 2.080806f
R71 70 71 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
C77 75 gnd 2.080806f
R75 74 75 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
C79 77 gnd 2.080806f
R77 77 76 2.224404
C80 78 gnd 2.080806f
R78 77 78 2.224404
C81 79 gnd 2.080806f
R79 79 78 2.224404
R80 g7448_1 79 2.224404
.ends

.subckt netg7490 g7490_1 g7490_0 gnd
C1  g7490_1 gnd 2.080806f
C2  g7490_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7490_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 58 59 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 70 71 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 75 76 2.224404
C79 77 gnd 2.080806f
R77 76 77 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
C81 79 gnd 2.080806f
R79 78 79 2.224404
C82 80 gnd 2.080806f
R80 80 79 2.224404
R81 g7490_1 80 2.224404
.ends

.subckt netg1744 g1744_1 g1744_0 g1744_4 g1744_3 g1744_2 g1744_5 gnd
C1  g1744_1 gnd 2.080806f
C2  g1744_0 gnd 2.080806f
C3  g1744_4 gnd 2.080806f
C4  g1744_3 gnd 2.080806f
C5  g1744_2 gnd 2.080806f
C6  g1744_5 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1744_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g1744_1 2.224404
C9 3 gnd 2.080806f
R4 1 3 2.224404
R5 3 g1744_4 2.224404
C10 4 gnd 2.080806f
R6 g1744_1 4 2.224404
C11 5 gnd 2.080806f
R7 4 5 2.224404
C12 6 gnd 2.080806f
R8 5 6 2.224404
R9 6 g1744_3 2.224404
C13 7 gnd 2.080806f
R10 g1744_4 7 2.224404
C14 8 gnd 2.080806f
R11 7 8 2.224404
C15 9 gnd 2.080806f
R12 8 9 2.224404
C16 10 gnd 2.080806f
R13 9 10 2.224404
C17 11 gnd 2.080806f
R14 10 11 2.224404
C18 12 gnd 2.080806f
R15 11 12 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 21 20 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 40 39 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
C54 48 gnd 2.080806f
R51 47 48 2.224404
C55 49 gnd 2.080806f
R52 48 49 2.224404
C56 50 gnd 2.080806f
R53 49 50 2.224404
C57 51 gnd 2.080806f
R54 50 51 2.224404
C58 52 gnd 2.080806f
R55 51 52 2.224404
C59 53 gnd 2.080806f
R56 52 53 2.224404
C60 54 gnd 2.080806f
R57 53 54 2.224404
C61 55 gnd 2.080806f
R58 54 55 2.224404
C62 56 gnd 2.080806f
R59 55 56 2.224404
C63 57 gnd 2.080806f
R60 57 56 2.224404
C64 58 gnd 2.080806f
R61 58 57 2.224404
C65 59 gnd 2.080806f
R62 59 58 2.224404
C66 60 gnd 2.080806f
R63 59 60 2.224404
C67 61 gnd 2.080806f
R64 60 61 2.224404
C68 62 gnd 2.080806f
R65 61 62 2.224404
C69 63 gnd 2.080806f
R66 62 63 2.224404
C70 64 gnd 2.080806f
R67 63 64 2.224404
C71 65 gnd 2.080806f
R68 64 65 2.224404
C72 66 gnd 2.080806f
R69 65 66 2.224404
C73 67 gnd 2.080806f
R70 66 67 2.224404
C74 68 gnd 2.080806f
R71 67 68 2.224404
C75 69 gnd 2.080806f
R72 68 69 2.224404
C76 70 gnd 2.080806f
R73 70 69 2.224404
C77 71 gnd 2.080806f
R74 70 71 2.224404
C78 72 gnd 2.080806f
R75 71 72 2.224404
C79 73 gnd 2.080806f
R76 73 72 2.224404
C80 74 gnd 2.080806f
R77 73 74 2.224404
C81 75 gnd 2.080806f
R78 74 75 2.224404
C82 76 gnd 2.080806f
R79 75 76 2.224404
C83 77 gnd 2.080806f
R80 77 76 2.224404
C84 78 gnd 2.080806f
R81 77 78 2.224404
C85 79 gnd 2.080806f
R82 78 79 2.224404
C86 80 gnd 2.080806f
R83 79 80 2.224404
C87 81 gnd 2.080806f
R84 80 81 2.224404
C88 82 gnd 2.080806f
R85 81 82 2.224404
C89 83 gnd 2.080806f
R86 82 83 2.224404
C90 84 gnd 2.080806f
R87 83 84 2.224404
C91 85 gnd 2.080806f
R88 84 85 2.224404
C92 86 gnd 2.080806f
R89 85 86 2.224404
C93 87 gnd 2.080806f
R90 86 87 2.224404
C94 88 gnd 2.080806f
R91 87 88 2.224404
C95 89 gnd 2.080806f
R92 88 89 2.224404
C96 90 gnd 2.080806f
R93 89 90 2.224404
C97 91 gnd 2.080806f
R94 90 91 2.224404
C98 92 gnd 2.080806f
R95 91 92 2.224404
R96 92 g1744_5 2.224404
C99 93 gnd 2.080806f
R97 g1744_5 93 2.224404
C100 94 gnd 2.080806f
R98 93 94 2.224404
C101 95 gnd 2.080806f
R99 94 95 2.224404
R100 95 g1744_2 2.224404
.ends

.subckt netg7466 g7466_1 g7466_0 gnd
C1  g7466_1 gnd 2.080806f
C2  g7466_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7466_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 52 53 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 58 59 2.224404
C62 60 gnd 2.080806f
R60 59 60 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 62 63 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 66 67 2.224404
C70 68 gnd 2.080806f
R68 67 68 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
C77 75 gnd 2.080806f
R75 74 75 2.224404
C78 76 gnd 2.080806f
R76 75 76 2.224404
C79 77 gnd 2.080806f
R77 76 77 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
C81 79 gnd 2.080806f
R79 79 78 2.224404
C82 80 gnd 2.080806f
R80 79 80 2.224404
C83 81 gnd 2.080806f
R81 81 80 2.224404
R82 g7466_1 81 2.224404
.ends

.subckt netg178 g178_2 g178_1 g178_0 gnd
C1  g178_2 gnd 2.080806f
C2  g178_1 gnd 2.080806f
C3  g178_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g178_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
R34 33 g178_1 2.224404
C37 34 gnd 2.080806f
R35 g178_0 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
R90 88 g178_2 2.224404
.ends

.subckt netg30 g30_0 g30_2 g30_1 gnd
C1  g30_0 gnd 2.080806f
C2  g30_2 gnd 2.080806f
C3  g30_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g30_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 34 35 2.224404
C39 36 gnd 2.080806f
R36 35 36 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 38 39 2.224404
C43 40 gnd 2.080806f
R40 39 40 2.224404
C44 41 gnd 2.080806f
R41 40 41 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 42 43 2.224404
C47 44 gnd 2.080806f
R44 43 44 2.224404
C48 45 gnd 2.080806f
R45 44 45 2.224404
C49 46 gnd 2.080806f
R46 45 46 2.224404
C50 47 gnd 2.080806f
R47 46 47 2.224404
C51 48 gnd 2.080806f
R48 47 48 2.224404
C52 49 gnd 2.080806f
R49 48 49 2.224404
C53 50 gnd 2.080806f
R50 49 50 2.224404
C54 51 gnd 2.080806f
R51 50 51 2.224404
C55 52 gnd 2.080806f
R52 51 52 2.224404
C56 53 gnd 2.080806f
R53 52 53 2.224404
C57 54 gnd 2.080806f
R54 53 54 2.224404
C58 55 gnd 2.080806f
R55 54 55 2.224404
C59 56 gnd 2.080806f
R56 55 56 2.224404
C60 57 gnd 2.080806f
R57 56 57 2.224404
C61 58 gnd 2.080806f
R58 57 58 2.224404
C62 59 gnd 2.080806f
R59 58 59 2.224404
C63 60 gnd 2.080806f
R60 59 60 2.224404
C64 61 gnd 2.080806f
R61 60 61 2.224404
C65 62 gnd 2.080806f
R62 61 62 2.224404
C66 63 gnd 2.080806f
R63 62 63 2.224404
C67 64 gnd 2.080806f
R64 63 64 2.224404
C68 65 gnd 2.080806f
R65 64 65 2.224404
C69 66 gnd 2.080806f
R66 65 66 2.224404
C70 67 gnd 2.080806f
R67 66 67 2.224404
C71 68 gnd 2.080806f
R68 67 68 2.224404
C72 69 gnd 2.080806f
R69 68 69 2.224404
C73 70 gnd 2.080806f
R70 69 70 2.224404
C74 71 gnd 2.080806f
R71 70 71 2.224404
C75 72 gnd 2.080806f
R72 71 72 2.224404
C76 73 gnd 2.080806f
R73 72 73 2.224404
C77 74 gnd 2.080806f
R74 73 74 2.224404
C78 75 gnd 2.080806f
R75 74 75 2.224404
C79 76 gnd 2.080806f
R76 75 76 2.224404
C80 77 gnd 2.080806f
R77 76 77 2.224404
C81 78 gnd 2.080806f
R78 77 78 2.224404
C82 79 gnd 2.080806f
R79 78 79 2.224404
C83 80 gnd 2.080806f
R80 79 80 2.224404
C84 81 gnd 2.080806f
R81 80 81 2.224404
C85 82 gnd 2.080806f
R82 81 82 2.224404
C86 83 gnd 2.080806f
R83 82 83 2.224404
C87 84 gnd 2.080806f
R84 83 84 2.224404
C88 85 gnd 2.080806f
R85 84 85 2.224404
C89 86 gnd 2.080806f
R86 85 86 2.224404
R87 g30_1 86 2.224404
C90 87 gnd 2.080806f
R88 87 g30_1 2.224404
C91 88 gnd 2.080806f
R89 88 87 2.224404
R90 g30_2 88 2.224404
.ends

.subckt netg7467 g7467_0 g7467_1 gnd
C1  g7467_0 gnd 2.080806f
C2  g7467_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7467_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 49 50 2.224404
C53 51 gnd 2.080806f
R51 50 51 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 58 59 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 60 61 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 62 63 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 66 67 2.224404
C70 68 gnd 2.080806f
R68 67 68 2.224404
C71 69 gnd 2.080806f
R69 68 69 2.224404
C72 70 gnd 2.080806f
R70 69 70 2.224404
C73 71 gnd 2.080806f
R71 70 71 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
C79 77 gnd 2.080806f
R77 77 76 2.224404
C80 78 gnd 2.080806f
R78 77 78 2.224404
C81 79 gnd 2.080806f
R79 78 79 2.224404
C82 80 gnd 2.080806f
R80 80 79 2.224404
C83 81 gnd 2.080806f
R81 80 81 2.224404
C84 82 gnd 2.080806f
R82 81 82 2.224404
R83 82 g7467_1 2.224404
.ends

.subckt netg191 g191_2 g191_1 g191_0 gnd
C1  g191_2 gnd 2.080806f
C2  g191_1 gnd 2.080806f
C3  g191_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g191_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
R39 g191_1 38 2.224404
C42 39 gnd 2.080806f
R40 g191_0 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
R85 83 g191_2 2.224404
.ends

.subckt netg464 g464_0 g464_4 g464_3 g464_2 g464_1 g464_5 gnd
C1  g464_0 gnd 2.080806f
C2  g464_4 gnd 2.080806f
C3  g464_3 gnd 2.080806f
C4  g464_2 gnd 2.080806f
C5  g464_1 gnd 2.080806f
C6  g464_5 gnd 2.080806f
C7 1 gnd 2.080806f
R1 1 g464_0 2.224404
C8 2 gnd 2.080806f
R2 2 1 2.224404
C9 3 gnd 2.080806f
R3 3 2 2.224404
R4 g464_4 3 2.224404
C10 4 gnd 2.080806f
R5 g464_4 4 2.224404
C11 5 gnd 2.080806f
R6 4 5 2.224404
C12 6 gnd 2.080806f
R7 5 6 2.224404
R8 6 g464_2 2.224404
C13 7 gnd 2.080806f
R9 g464_2 7 2.224404
C14 8 gnd 2.080806f
R10 7 8 2.224404
C15 9 gnd 2.080806f
R11 8 9 2.224404
C16 10 gnd 2.080806f
R12 9 10 2.224404
C17 11 gnd 2.080806f
R13 10 11 2.224404
C18 12 gnd 2.080806f
R14 11 12 2.224404
R15 12 g464_5 2.224404
C19 13 gnd 2.080806f
R16 12 13 2.224404
C20 14 gnd 2.080806f
R17 13 14 2.224404
C21 15 gnd 2.080806f
R18 14 15 2.224404
C22 16 gnd 2.080806f
R19 15 16 2.224404
C23 17 gnd 2.080806f
R20 16 17 2.224404
C24 18 gnd 2.080806f
R21 17 18 2.224404
C25 19 gnd 2.080806f
R22 18 19 2.224404
C26 20 gnd 2.080806f
R23 19 20 2.224404
C27 21 gnd 2.080806f
R24 20 21 2.224404
C28 22 gnd 2.080806f
R25 21 22 2.224404
C29 23 gnd 2.080806f
R26 22 23 2.224404
C30 24 gnd 2.080806f
R27 23 24 2.224404
C31 25 gnd 2.080806f
R28 24 25 2.224404
C32 26 gnd 2.080806f
R29 25 26 2.224404
C33 27 gnd 2.080806f
R30 26 27 2.224404
C34 28 gnd 2.080806f
R31 27 28 2.224404
C35 29 gnd 2.080806f
R32 28 29 2.224404
C36 30 gnd 2.080806f
R33 29 30 2.224404
C37 31 gnd 2.080806f
R34 30 31 2.224404
C38 32 gnd 2.080806f
R35 31 32 2.224404
C39 33 gnd 2.080806f
R36 32 33 2.224404
C40 34 gnd 2.080806f
R37 33 34 2.224404
C41 35 gnd 2.080806f
R38 34 35 2.224404
C42 36 gnd 2.080806f
R39 35 36 2.224404
C43 37 gnd 2.080806f
R40 36 37 2.224404
C44 38 gnd 2.080806f
R41 37 38 2.224404
C45 39 gnd 2.080806f
R42 38 39 2.224404
C46 40 gnd 2.080806f
R43 39 40 2.224404
C47 41 gnd 2.080806f
R44 40 41 2.224404
C48 42 gnd 2.080806f
R45 41 42 2.224404
C49 43 gnd 2.080806f
R46 42 43 2.224404
C50 44 gnd 2.080806f
R47 43 44 2.224404
C51 45 gnd 2.080806f
R48 44 45 2.224404
C52 46 gnd 2.080806f
R49 45 46 2.224404
C53 47 gnd 2.080806f
R50 46 47 2.224404
C54 48 gnd 2.080806f
R51 47 48 2.224404
C55 49 gnd 2.080806f
R52 48 49 2.224404
C56 50 gnd 2.080806f
R53 49 50 2.224404
C57 51 gnd 2.080806f
R54 50 51 2.224404
C58 52 gnd 2.080806f
R55 51 52 2.224404
C59 53 gnd 2.080806f
R56 52 53 2.224404
C60 54 gnd 2.080806f
R57 53 54 2.224404
C61 55 gnd 2.080806f
R58 54 55 2.224404
C62 56 gnd 2.080806f
R59 55 56 2.224404
C63 57 gnd 2.080806f
R60 56 57 2.224404
C64 58 gnd 2.080806f
R61 57 58 2.224404
C65 59 gnd 2.080806f
R62 58 59 2.224404
C66 60 gnd 2.080806f
R63 59 60 2.224404
C67 61 gnd 2.080806f
R64 60 61 2.224404
C68 62 gnd 2.080806f
R65 61 62 2.224404
C69 63 gnd 2.080806f
R66 62 63 2.224404
C70 64 gnd 2.080806f
R67 63 64 2.224404
C71 65 gnd 2.080806f
R68 64 65 2.224404
C72 66 gnd 2.080806f
R69 65 66 2.224404
C73 67 gnd 2.080806f
R70 66 67 2.224404
R71 67 g464_1 2.224404
C74 68 gnd 2.080806f
R72 68 g464_1 2.224404
C75 69 gnd 2.080806f
R73 69 68 2.224404
C76 70 gnd 2.080806f
R74 70 69 2.224404
C77 71 gnd 2.080806f
R75 71 70 2.224404
C78 72 gnd 2.080806f
R76 71 72 2.224404
C79 73 gnd 2.080806f
R77 73 72 2.224404
C80 74 gnd 2.080806f
R78 74 73 2.224404
C81 75 gnd 2.080806f
R79 75 74 2.224404
C82 76 gnd 2.080806f
R80 76 75 2.224404
C83 77 gnd 2.080806f
R81 77 76 2.224404
C84 78 gnd 2.080806f
R82 78 77 2.224404
C85 79 gnd 2.080806f
R83 79 78 2.224404
C86 80 gnd 2.080806f
R84 80 79 2.224404
C87 81 gnd 2.080806f
R85 81 80 2.224404
C88 82 gnd 2.080806f
R86 82 81 2.224404
C89 83 gnd 2.080806f
R87 83 82 2.224404
C90 84 gnd 2.080806f
R88 84 83 2.224404
C91 85 gnd 2.080806f
R89 85 84 2.224404
C92 86 gnd 2.080806f
R90 86 85 2.224404
C93 87 gnd 2.080806f
R91 87 86 2.224404
C94 88 gnd 2.080806f
R92 88 87 2.224404
C95 89 gnd 2.080806f
R93 88 89 2.224404
C96 90 gnd 2.080806f
R94 90 89 2.224404
C97 91 gnd 2.080806f
R95 91 90 2.224404
C98 92 gnd 2.080806f
R96 91 92 2.224404
C99 93 gnd 2.080806f
R97 93 92 2.224404
C100 94 gnd 2.080806f
R98 94 93 2.224404
C101 95 gnd 2.080806f
R99 95 94 2.224404
C102 96 gnd 2.080806f
R100 95 96 2.224404
R101 96 g464_3 2.224404
.ends

.subckt netg179 g179_2 g179_1 g179_0 gnd
C1  g179_2 gnd 2.080806f
C2  g179_1 gnd 2.080806f
C3  g179_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g179_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
R44 g179_2 43 2.224404
C47 44 gnd 2.080806f
R45 44 g179_2 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 81 80 2.224404
C85 82 gnd 2.080806f
R83 82 81 2.224404
R84 g179_1 82 2.224404
.ends

.subckt netg195 g195_0 g195_2 g195_1 gnd
C1  g195_0 gnd 2.080806f
C2  g195_2 gnd 2.080806f
C3  g195_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g195_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
R29 28 g195_1 2.224404
C32 29 gnd 2.080806f
R30 g195_1 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
R90 88 g195_2 2.224404
.ends

.subckt netg7456 g7456_0 g7456_1 gnd
C1  g7456_0 gnd 2.080806f
C2  g7456_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7456_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 26 27 2.224404
C30 28 gnd 2.080806f
R28 27 28 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 47 48 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 53 54 2.224404
C57 55 gnd 2.080806f
R55 54 55 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 56 57 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 58 59 2.224404
C62 60 gnd 2.080806f
R60 59 60 2.224404
C63 61 gnd 2.080806f
R61 60 61 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 69 70 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 74 75 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
C79 77 gnd 2.080806f
R77 77 76 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
C81 79 gnd 2.080806f
R79 78 79 2.224404
C82 80 gnd 2.080806f
R80 79 80 2.224404
C83 81 gnd 2.080806f
R81 81 80 2.224404
C84 82 gnd 2.080806f
R82 81 82 2.224404
C85 83 gnd 2.080806f
R83 82 83 2.224404
R84 83 g7456_1 2.224404
.ends

.subckt netg7484 g7484_0 g7484_1 gnd
C1  g7484_0 gnd 2.080806f
C2  g7484_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g7484_0 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 35 36 2.224404
C39 37 gnd 2.080806f
R37 36 37 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 41 42 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 44 45 2.224404
C48 46 gnd 2.080806f
R46 45 46 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 48 49 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 67 68 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 71 72 2.224404
C75 73 gnd 2.080806f
R73 72 73 2.224404
C76 74 gnd 2.080806f
R74 73 74 2.224404
C77 75 gnd 2.080806f
R75 74 75 2.224404
C78 76 gnd 2.080806f
R76 75 76 2.224404
C79 77 gnd 2.080806f
R77 76 77 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
C81 79 gnd 2.080806f
R79 78 79 2.224404
C82 80 gnd 2.080806f
R80 79 80 2.224404
C83 81 gnd 2.080806f
R81 81 80 2.224404
C84 82 gnd 2.080806f
R82 81 82 2.224404
C85 83 gnd 2.080806f
R83 83 82 2.224404
R84 g7484_1 83 2.224404
.ends

.subckt netg192 g192_2 g192_1 g192_0 gnd
C1  g192_2 gnd 2.080806f
C2  g192_1 gnd 2.080806f
C3  g192_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g192_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
R33 32 g192_2 2.224404
C36 33 gnd 2.080806f
R34 g192_2 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
R91 89 g192_1 2.224404
.ends

.subckt netg199 g199_0 g199_1 g199_2 gnd
C1  g199_0 gnd 2.080806f
C2  g199_1 gnd 2.080806f
C3  g199_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g199_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 45 44 2.224404
C49 46 gnd 2.080806f
R46 46 45 2.224404
C50 47 gnd 2.080806f
R47 47 46 2.224404
C51 48 gnd 2.080806f
R48 48 47 2.224404
C52 49 gnd 2.080806f
R49 49 48 2.224404
C53 50 gnd 2.080806f
R50 50 49 2.224404
C54 51 gnd 2.080806f
R51 51 50 2.224404
C55 52 gnd 2.080806f
R52 52 51 2.224404
C56 53 gnd 2.080806f
R53 53 52 2.224404
C57 54 gnd 2.080806f
R54 54 53 2.224404
C58 55 gnd 2.080806f
R55 55 54 2.224404
C59 56 gnd 2.080806f
R56 56 55 2.224404
C60 57 gnd 2.080806f
R57 57 56 2.224404
C61 58 gnd 2.080806f
R58 58 57 2.224404
C62 59 gnd 2.080806f
R59 59 58 2.224404
C63 60 gnd 2.080806f
R60 60 59 2.224404
R61 g199_2 60 2.224404
C64 61 gnd 2.080806f
R62 61 g199_2 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 83 82 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 85 84 2.224404
C89 86 gnd 2.080806f
R87 86 85 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 88 87 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 91 90 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 93 92 2.224404
C97 94 gnd 2.080806f
R95 94 93 2.224404
C98 95 gnd 2.080806f
R96 95 94 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 98 97 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
R102 100 g199_1 2.224404
.ends

.subckt netg202 g202_0 g202_2 g202_1 gnd
C1  g202_0 gnd 2.080806f
C2  g202_2 gnd 2.080806f
C3  g202_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g202_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 45 44 2.224404
C49 46 gnd 2.080806f
R46 46 45 2.224404
C50 47 gnd 2.080806f
R47 47 46 2.224404
C51 48 gnd 2.080806f
R48 48 47 2.224404
C52 49 gnd 2.080806f
R49 49 48 2.224404
C53 50 gnd 2.080806f
R50 50 49 2.224404
C54 51 gnd 2.080806f
R51 51 50 2.224404
C55 52 gnd 2.080806f
R52 52 51 2.224404
C56 53 gnd 2.080806f
R53 53 52 2.224404
C57 54 gnd 2.080806f
R54 54 53 2.224404
C58 55 gnd 2.080806f
R55 55 54 2.224404
C59 56 gnd 2.080806f
R56 56 55 2.224404
C60 57 gnd 2.080806f
R57 57 56 2.224404
C61 58 gnd 2.080806f
R58 58 57 2.224404
C62 59 gnd 2.080806f
R59 59 58 2.224404
C63 60 gnd 2.080806f
R60 60 59 2.224404
C64 61 gnd 2.080806f
R61 61 60 2.224404
C65 62 gnd 2.080806f
R62 62 61 2.224404
C66 63 gnd 2.080806f
R63 63 62 2.224404
C67 64 gnd 2.080806f
R64 64 63 2.224404
C68 65 gnd 2.080806f
R65 65 64 2.224404
R66 g202_1 65 2.224404
C69 66 gnd 2.080806f
R67 66 g202_1 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 96 95 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 98 97 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 102 101 2.224404
C106 103 gnd 2.080806f
R104 103 102 2.224404
C107 104 gnd 2.080806f
R105 104 103 2.224404
C108 105 gnd 2.080806f
R106 104 105 2.224404
C109 106 gnd 2.080806f
R107 106 105 2.224404
R108 106 g202_2 2.224404
.ends

.subckt netg14 g14_0 g14_2 g14_1 gnd
C1  g14_0 gnd 2.080806f
C2  g14_2 gnd 2.080806f
C3  g14_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g14_0 2.224404
R2 g14_1 1 2.224404
C5 2 gnd 2.080806f
R3 2 g14_1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 81 80 2.224404
C85 82 gnd 2.080806f
R83 82 81 2.224404
C86 83 gnd 2.080806f
R84 83 82 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 85 84 2.224404
R87 g14_2 85 2.224404
.ends

.subckt netg176 g176_2 g176_1 g176_0 gnd
C1  g176_2 gnd 2.080806f
C2  g176_1 gnd 2.080806f
C3  g176_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g176_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
R41 40 g176_2 2.224404
C44 41 gnd 2.080806f
R42 g176_0 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
R100 98 g176_1 2.224404
.ends

.subckt netg13 g13_2 g13_1 g13_0 gnd
C1  g13_2 gnd 2.080806f
C2  g13_1 gnd 2.080806f
C3  g13_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g13_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
R3 2 g13_1 2.224404
C6 3 gnd 2.080806f
R4 3 g13_0 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 81 80 2.224404
C85 82 gnd 2.080806f
R83 82 81 2.224404
C86 83 gnd 2.080806f
R84 83 82 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 85 84 2.224404
R87 g13_2 85 2.224404
.ends

.subckt netg1731 g1731_5 g1731_4 g1731_0 g1731_3 g1731_1 g1731_2 g1731_6 gnd
C1  g1731_5 gnd 2.080806f
C2  g1731_4 gnd 2.080806f
C3  g1731_0 gnd 2.080806f
C4  g1731_3 gnd 2.080806f
C5  g1731_1 gnd 2.080806f
C6  g1731_2 gnd 2.080806f
C7  g1731_6 gnd 2.080806f
R1 g1731_4 g1731_0 2.224404
C8 1 gnd 2.080806f
R2 g1731_4 1 2.224404
C9 2 gnd 2.080806f
R3 2 1 2.224404
C10 3 gnd 2.080806f
R4 3 2 2.224404
C11 4 gnd 2.080806f
R5 4 3 2.224404
C12 5 gnd 2.080806f
R6 5 4 2.224404
C13 6 gnd 2.080806f
R7 6 5 2.224404
C14 7 gnd 2.080806f
R8 7 6 2.224404
C15 8 gnd 2.080806f
R9 8 7 2.224404
C16 9 gnd 2.080806f
R10 9 8 2.224404
C17 10 gnd 2.080806f
R11 10 9 2.224404
C18 11 gnd 2.080806f
R12 11 10 2.224404
C19 12 gnd 2.080806f
R13 12 11 2.224404
C20 13 gnd 2.080806f
R14 12 13 2.224404
C21 14 gnd 2.080806f
R15 13 14 2.224404
C22 15 gnd 2.080806f
R16 15 14 2.224404
R17 g1731_1 15 2.224404
C23 16 gnd 2.080806f
R18 14 16 2.224404
C24 17 gnd 2.080806f
R19 16 17 2.224404
C25 18 gnd 2.080806f
R20 17 18 2.224404
C26 19 gnd 2.080806f
R21 18 19 2.224404
R22 19 g1731_2 2.224404
C27 20 gnd 2.080806f
R23 20 g1731_2 2.224404
C28 21 gnd 2.080806f
R24 20 21 2.224404
C29 22 gnd 2.080806f
R25 22 21 2.224404
C30 23 gnd 2.080806f
R26 22 23 2.224404
C31 24 gnd 2.080806f
R27 23 24 2.224404
C32 25 gnd 2.080806f
R28 25 24 2.224404
C33 26 gnd 2.080806f
R29 25 26 2.224404
C34 27 gnd 2.080806f
R30 26 27 2.224404
R31 27 g1731_3 2.224404
C35 28 gnd 2.080806f
R32 g1731_3 28 2.224404
C36 29 gnd 2.080806f
R33 28 29 2.224404
C37 30 gnd 2.080806f
R34 29 30 2.224404
C38 31 gnd 2.080806f
R35 30 31 2.224404
C39 32 gnd 2.080806f
R36 31 32 2.224404
C40 33 gnd 2.080806f
R37 32 33 2.224404
C41 34 gnd 2.080806f
R38 33 34 2.224404
C42 35 gnd 2.080806f
R39 34 35 2.224404
C43 36 gnd 2.080806f
R40 35 36 2.224404
C44 37 gnd 2.080806f
R41 36 37 2.224404
C45 38 gnd 2.080806f
R42 37 38 2.224404
C46 39 gnd 2.080806f
R43 38 39 2.224404
C47 40 gnd 2.080806f
R44 39 40 2.224404
C48 41 gnd 2.080806f
R45 40 41 2.224404
C49 42 gnd 2.080806f
R46 41 42 2.224404
C50 43 gnd 2.080806f
R47 42 43 2.224404
C51 44 gnd 2.080806f
R48 43 44 2.224404
C52 45 gnd 2.080806f
R49 44 45 2.224404
C53 46 gnd 2.080806f
R50 45 46 2.224404
C54 47 gnd 2.080806f
R51 46 47 2.224404
C55 48 gnd 2.080806f
R52 47 48 2.224404
C56 49 gnd 2.080806f
R53 48 49 2.224404
C57 50 gnd 2.080806f
R54 49 50 2.224404
C58 51 gnd 2.080806f
R55 50 51 2.224404
C59 52 gnd 2.080806f
R56 51 52 2.224404
C60 53 gnd 2.080806f
R57 52 53 2.224404
C61 54 gnd 2.080806f
R58 53 54 2.224404
C62 55 gnd 2.080806f
R59 54 55 2.224404
C63 56 gnd 2.080806f
R60 55 56 2.224404
C64 57 gnd 2.080806f
R61 56 57 2.224404
C65 58 gnd 2.080806f
R62 57 58 2.224404
C66 59 gnd 2.080806f
R63 58 59 2.224404
C67 60 gnd 2.080806f
R64 59 60 2.224404
C68 61 gnd 2.080806f
R65 60 61 2.224404
C69 62 gnd 2.080806f
R66 61 62 2.224404
C70 63 gnd 2.080806f
R67 62 63 2.224404
C71 64 gnd 2.080806f
R68 63 64 2.224404
C72 65 gnd 2.080806f
R69 64 65 2.224404
C73 66 gnd 2.080806f
R70 65 66 2.224404
C74 67 gnd 2.080806f
R71 66 67 2.224404
C75 68 gnd 2.080806f
R72 67 68 2.224404
C76 69 gnd 2.080806f
R73 68 69 2.224404
C77 70 gnd 2.080806f
R74 69 70 2.224404
C78 71 gnd 2.080806f
R75 70 71 2.224404
C79 72 gnd 2.080806f
R76 71 72 2.224404
C80 73 gnd 2.080806f
R77 72 73 2.224404
C81 74 gnd 2.080806f
R78 73 74 2.224404
C82 75 gnd 2.080806f
R79 74 75 2.224404
C83 76 gnd 2.080806f
R80 75 76 2.224404
C84 77 gnd 2.080806f
R81 76 77 2.224404
C85 78 gnd 2.080806f
R82 77 78 2.224404
C86 79 gnd 2.080806f
R83 78 79 2.224404
C87 80 gnd 2.080806f
R84 79 80 2.224404
C88 81 gnd 2.080806f
R85 81 80 2.224404
C89 82 gnd 2.080806f
R86 81 82 2.224404
C90 83 gnd 2.080806f
R87 82 83 2.224404
C91 84 gnd 2.080806f
R88 84 83 2.224404
C92 85 gnd 2.080806f
R89 85 84 2.224404
C93 86 gnd 2.080806f
R90 85 86 2.224404
C94 87 gnd 2.080806f
R91 86 87 2.224404
C95 88 gnd 2.080806f
R92 87 88 2.224404
C96 89 gnd 2.080806f
R93 88 89 2.224404
C97 90 gnd 2.080806f
R94 89 90 2.224404
C98 91 gnd 2.080806f
R95 90 91 2.224404
C99 92 gnd 2.080806f
R96 91 92 2.224404
C100 93 gnd 2.080806f
R97 92 93 2.224404
C101 94 gnd 2.080806f
R98 93 94 2.224404
C102 95 gnd 2.080806f
R99 94 95 2.224404
R100 95 g1731_5 2.224404
C103 96 gnd 2.080806f
R101 95 96 2.224404
C104 97 gnd 2.080806f
R102 96 97 2.224404
C105 98 gnd 2.080806f
R103 97 98 2.224404
C106 99 gnd 2.080806f
R104 98 99 2.224404
C107 100 gnd 2.080806f
R105 99 100 2.224404
C108 101 gnd 2.080806f
R106 100 101 2.224404
C109 102 gnd 2.080806f
R107 101 102 2.224404
C110 103 gnd 2.080806f
R108 102 103 2.224404
C111 104 gnd 2.080806f
R109 103 104 2.224404
C112 105 gnd 2.080806f
R110 105 104 2.224404
C113 106 gnd 2.080806f
R111 105 106 2.224404
C114 107 gnd 2.080806f
R112 106 107 2.224404
C115 108 gnd 2.080806f
R113 107 108 2.224404
C116 109 gnd 2.080806f
R114 108 109 2.224404
R115 109 g1731_6 2.224404
.ends

.subckt netg1756 g1756_5 g1756_3 g1756_1 g1756_4 g1756_2 g1756_0 gnd
C1  g1756_5 gnd 2.080806f
C2  g1756_3 gnd 2.080806f
C3  g1756_1 gnd 2.080806f
C4  g1756_4 gnd 2.080806f
C5  g1756_2 gnd 2.080806f
C6  g1756_0 gnd 2.080806f
C7 1 gnd 2.080806f
R1 g1756_0 1 2.224404
C8 2 gnd 2.080806f
R2 1 2 2.224404
C9 3 gnd 2.080806f
R3 2 3 2.224404
C10 4 gnd 2.080806f
R4 3 4 2.224404
C11 5 gnd 2.080806f
R5 4 5 2.224404
C12 6 gnd 2.080806f
R6 5 6 2.224404
C13 7 gnd 2.080806f
R7 6 7 2.224404
C14 8 gnd 2.080806f
R8 7 8 2.224404
R9 8 g1756_5 2.224404
C15 9 gnd 2.080806f
R10 9 g1756_0 2.224404
C16 10 gnd 2.080806f
R11 9 10 2.224404
C17 11 gnd 2.080806f
R12 10 11 2.224404
C18 12 gnd 2.080806f
R13 11 12 2.224404
C19 13 gnd 2.080806f
R14 12 13 2.224404
C20 14 gnd 2.080806f
R15 14 13 2.224404
C21 15 gnd 2.080806f
R16 15 14 2.224404
C22 16 gnd 2.080806f
R17 15 16 2.224404
C23 17 gnd 2.080806f
R18 16 17 2.224404
C24 18 gnd 2.080806f
R19 17 18 2.224404
C25 19 gnd 2.080806f
R20 18 19 2.224404
C26 20 gnd 2.080806f
R21 19 20 2.224404
C27 21 gnd 2.080806f
R22 20 21 2.224404
C28 22 gnd 2.080806f
R23 22 21 2.224404
C29 23 gnd 2.080806f
R24 23 22 2.224404
C30 24 gnd 2.080806f
R25 24 23 2.224404
C31 25 gnd 2.080806f
R26 25 24 2.224404
C32 26 gnd 2.080806f
R27 26 25 2.224404
C33 27 gnd 2.080806f
R28 27 26 2.224404
C34 28 gnd 2.080806f
R29 28 27 2.224404
C35 29 gnd 2.080806f
R30 29 28 2.224404
C36 30 gnd 2.080806f
R31 30 29 2.224404
C37 31 gnd 2.080806f
R32 31 30 2.224404
C38 32 gnd 2.080806f
R33 32 31 2.224404
C39 33 gnd 2.080806f
R34 33 32 2.224404
C40 34 gnd 2.080806f
R35 34 33 2.224404
C41 35 gnd 2.080806f
R36 35 34 2.224404
C42 36 gnd 2.080806f
R37 36 35 2.224404
C43 37 gnd 2.080806f
R38 37 36 2.224404
C44 38 gnd 2.080806f
R39 38 37 2.224404
C45 39 gnd 2.080806f
R40 39 38 2.224404
C46 40 gnd 2.080806f
R41 40 39 2.224404
C47 41 gnd 2.080806f
R42 41 40 2.224404
C48 42 gnd 2.080806f
R43 42 41 2.224404
C49 43 gnd 2.080806f
R44 43 42 2.224404
C50 44 gnd 2.080806f
R45 44 43 2.224404
C51 45 gnd 2.080806f
R46 45 44 2.224404
C52 46 gnd 2.080806f
R47 46 45 2.224404
C53 47 gnd 2.080806f
R48 47 46 2.224404
C54 48 gnd 2.080806f
R49 48 47 2.224404
C55 49 gnd 2.080806f
R50 49 48 2.224404
C56 50 gnd 2.080806f
R51 50 49 2.224404
C57 51 gnd 2.080806f
R52 51 50 2.224404
C58 52 gnd 2.080806f
R53 52 51 2.224404
C59 53 gnd 2.080806f
R54 53 52 2.224404
C60 54 gnd 2.080806f
R55 54 53 2.224404
C61 55 gnd 2.080806f
R56 55 54 2.224404
C62 56 gnd 2.080806f
R57 56 55 2.224404
C63 57 gnd 2.080806f
R58 57 56 2.224404
C64 58 gnd 2.080806f
R59 58 57 2.224404
C65 59 gnd 2.080806f
R60 59 58 2.224404
C66 60 gnd 2.080806f
R61 60 59 2.224404
C67 61 gnd 2.080806f
R62 61 60 2.224404
C68 62 gnd 2.080806f
R63 62 61 2.224404
C69 63 gnd 2.080806f
R64 63 62 2.224404
C70 64 gnd 2.080806f
R65 64 63 2.224404
C71 65 gnd 2.080806f
R66 65 64 2.224404
C72 66 gnd 2.080806f
R67 66 65 2.224404
C73 67 gnd 2.080806f
R68 67 66 2.224404
C74 68 gnd 2.080806f
R69 68 67 2.224404
C75 69 gnd 2.080806f
R70 69 68 2.224404
C76 70 gnd 2.080806f
R71 70 69 2.224404
C77 71 gnd 2.080806f
R72 71 70 2.224404
C78 72 gnd 2.080806f
R73 72 71 2.224404
C79 73 gnd 2.080806f
R74 73 72 2.224404
C80 74 gnd 2.080806f
R75 74 73 2.224404
C81 75 gnd 2.080806f
R76 75 74 2.224404
C82 76 gnd 2.080806f
R77 76 75 2.224404
C83 77 gnd 2.080806f
R78 77 76 2.224404
C84 78 gnd 2.080806f
R79 78 77 2.224404
C85 79 gnd 2.080806f
R80 79 78 2.224404
C86 80 gnd 2.080806f
R81 80 79 2.224404
C87 81 gnd 2.080806f
R82 81 80 2.224404
C88 82 gnd 2.080806f
R83 82 81 2.224404
C89 83 gnd 2.080806f
R84 83 82 2.224404
C90 84 gnd 2.080806f
R85 84 83 2.224404
C91 85 gnd 2.080806f
R86 85 84 2.224404
C92 86 gnd 2.080806f
R87 86 85 2.224404
C93 87 gnd 2.080806f
R88 87 86 2.224404
C94 88 gnd 2.080806f
R89 88 87 2.224404
C95 89 gnd 2.080806f
R90 89 88 2.224404
C96 90 gnd 2.080806f
R91 90 89 2.224404
C97 91 gnd 2.080806f
R92 91 90 2.224404
C98 92 gnd 2.080806f
R93 92 91 2.224404
C99 93 gnd 2.080806f
R94 93 92 2.224404
C100 94 gnd 2.080806f
R95 94 93 2.224404
C101 95 gnd 2.080806f
R96 95 94 2.224404
C102 96 gnd 2.080806f
R97 96 95 2.224404
C103 97 gnd 2.080806f
R98 96 97 2.224404
R99 g1756_1 97 2.224404
C104 98 gnd 2.080806f
R100 g1756_1 98 2.224404
C105 99 gnd 2.080806f
R101 98 99 2.224404
C106 100 gnd 2.080806f
R102 99 100 2.224404
R103 g1756_3 100 2.224404
C107 101 gnd 2.080806f
R104 101 g1756_1 2.224404
C108 102 gnd 2.080806f
R105 102 101 2.224404
C109 103 gnd 2.080806f
R106 103 102 2.224404
C110 104 gnd 2.080806f
R107 104 103 2.224404
C111 105 gnd 2.080806f
R108 105 104 2.224404
C112 106 gnd 2.080806f
R109 106 105 2.224404
R110 g1756_4 106 2.224404
C113 107 gnd 2.080806f
R111 107 g1756_4 2.224404
C114 108 gnd 2.080806f
R112 108 107 2.224404
C115 109 gnd 2.080806f
R113 109 108 2.224404
C116 110 gnd 2.080806f
R114 110 109 2.224404
C117 111 gnd 2.080806f
R115 110 111 2.224404
C118 112 gnd 2.080806f
R116 111 112 2.224404
R117 112 g1756_2 2.224404
.ends

.subckt netg201 g201_1 g201_2 g201_0 gnd
C1  g201_1 gnd 2.080806f
C2  g201_2 gnd 2.080806f
C3  g201_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g201_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 39 40 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 41 42 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
R44 g201_1 43 2.224404
C47 44 gnd 2.080806f
R45 4 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 99 98 2.224404
R101 g201_2 99 2.224404
.ends

.subckt netg203 g203_0 g203_2 g203_1 gnd
C1  g203_0 gnd 2.080806f
C2  g203_2 gnd 2.080806f
C3  g203_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g203_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 41 42 2.224404
C46 43 gnd 2.080806f
R43 42 43 2.224404
R44 43 g203_1 2.224404
C47 44 gnd 2.080806f
R45 26 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
R92 90 g203_2 2.224404
.ends

.subckt netg204 g204_1 g204_2 g204_0 gnd
C1  g204_1 gnd 2.080806f
C2  g204_2 gnd 2.080806f
C3  g204_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g204_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 35 36 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 38 39 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 41 42 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
R45 44 g204_2 2.224404
C48 45 gnd 2.080806f
R46 5 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 85 84 2.224404
C89 86 gnd 2.080806f
R87 86 85 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
C108 105 gnd 2.080806f
R106 105 104 2.224404
R107 g204_1 105 2.224404
.ends

.subckt netg198 g198_0 g198_2 g198_1 gnd
C1  g198_0 gnd 2.080806f
C2  g198_2 gnd 2.080806f
C3  g198_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g198_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 34 35 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 39 40 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 42 43 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 44 45 2.224404
R46 45 g198_2 2.224404
C49 46 gnd 2.080806f
R47 40 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
C108 105 gnd 2.080806f
R106 104 105 2.224404
R107 105 g198_1 2.224404
.ends

.subckt netg7 g7_2 g7_0 g7_1 gnd
C1  g7_2 gnd 2.080806f
C2  g7_0 gnd 2.080806f
C3  g7_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g7_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
R3 g7_2 2 2.224404
C6 3 gnd 2.080806f
R4 3 g7_2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 81 80 2.224404
C85 82 gnd 2.080806f
R83 82 81 2.224404
C86 83 gnd 2.080806f
R84 83 82 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 85 84 2.224404
C89 86 gnd 2.080806f
R87 86 85 2.224404
C90 87 gnd 2.080806f
R88 87 86 2.224404
C91 88 gnd 2.080806f
R89 88 87 2.224404
C92 89 gnd 2.080806f
R90 89 88 2.224404
C93 90 gnd 2.080806f
R91 90 89 2.224404
C94 91 gnd 2.080806f
R92 91 90 2.224404
C95 92 gnd 2.080806f
R93 92 91 2.224404
R94 g7_1 92 2.224404
.ends

.subckt netg186 g186_1 g186_2 g186_0 gnd
C1  g186_1 gnd 2.080806f
C2  g186_2 gnd 2.080806f
C3  g186_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g186_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 35 36 2.224404
R37 36 g186_1 2.224404
C40 37 gnd 2.080806f
R38 g186_1 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
R103 101 g186_2 2.224404
.ends

.subckt netg9 g9_1 g9_2 g9_0 gnd
C1  g9_1 gnd 2.080806f
C2  g9_2 gnd 2.080806f
C3  g9_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g9_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
R4 g9_1 3 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 8 7 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 10 9 2.224404
C14 11 gnd 2.080806f
R12 11 10 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 17 16 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 51 50 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 81 80 2.224404
C85 82 gnd 2.080806f
R83 82 81 2.224404
C86 83 gnd 2.080806f
R84 83 82 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 85 84 2.224404
C89 86 gnd 2.080806f
R87 86 85 2.224404
C90 87 gnd 2.080806f
R88 87 86 2.224404
C91 88 gnd 2.080806f
R89 88 87 2.224404
C92 89 gnd 2.080806f
R90 89 88 2.224404
C93 90 gnd 2.080806f
R91 90 89 2.224404
C94 91 gnd 2.080806f
R92 91 90 2.224404
R93 g9_2 91 2.224404
.ends

.subckt netg196 g196_2 g196_1 g196_0 gnd
C1  g196_2 gnd 2.080806f
C2  g196_1 gnd 2.080806f
C3  g196_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g196_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 45 44 2.224404
C49 46 gnd 2.080806f
R46 45 46 2.224404
C50 47 gnd 2.080806f
R47 47 46 2.224404
C51 48 gnd 2.080806f
R48 48 47 2.224404
C52 49 gnd 2.080806f
R49 49 48 2.224404
C53 50 gnd 2.080806f
R50 50 49 2.224404
C54 51 gnd 2.080806f
R51 51 50 2.224404
C55 52 gnd 2.080806f
R52 52 51 2.224404
C56 53 gnd 2.080806f
R53 53 52 2.224404
C57 54 gnd 2.080806f
R54 54 53 2.224404
C58 55 gnd 2.080806f
R55 55 54 2.224404
C59 56 gnd 2.080806f
R56 56 55 2.224404
C60 57 gnd 2.080806f
R57 57 56 2.224404
C61 58 gnd 2.080806f
R58 58 57 2.224404
C62 59 gnd 2.080806f
R59 59 58 2.224404
C63 60 gnd 2.080806f
R60 60 59 2.224404
C64 61 gnd 2.080806f
R61 61 60 2.224404
C65 62 gnd 2.080806f
R62 62 61 2.224404
C66 63 gnd 2.080806f
R63 62 63 2.224404
C67 64 gnd 2.080806f
R64 64 63 2.224404
R65 64 g196_2 2.224404
C68 65 gnd 2.080806f
R66 65 61 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 81 80 2.224404
C85 82 gnd 2.080806f
R83 82 81 2.224404
C86 83 gnd 2.080806f
R84 83 82 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 86 85 2.224404
C90 87 gnd 2.080806f
R88 87 86 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 89 88 2.224404
C93 90 gnd 2.080806f
R91 90 89 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 95 94 2.224404
C99 96 gnd 2.080806f
R97 96 95 2.224404
C100 97 gnd 2.080806f
R98 97 96 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 99 98 2.224404
C103 100 gnd 2.080806f
R101 100 99 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 103 102 2.224404
C107 104 gnd 2.080806f
R105 104 103 2.224404
C108 105 gnd 2.080806f
R106 104 105 2.224404
C109 106 gnd 2.080806f
R107 106 105 2.224404
C110 107 gnd 2.080806f
R108 106 107 2.224404
C111 108 gnd 2.080806f
R109 107 108 2.224404
R110 g196_1 108 2.224404
.ends

.subckt netg206 g206_10 g206_5 g206_8 g206_7 g206_4 g206_14 g206_3 g206_1 g206_6 g206_13 g206_12 g206_2 g206_0 g206_11 g206_9 gnd
C1  g206_10 gnd 2.080806f
C2  g206_5 gnd 2.080806f
C3  g206_8 gnd 2.080806f
C4  g206_7 gnd 2.080806f
C5  g206_4 gnd 2.080806f
C6  g206_14 gnd 2.080806f
C7  g206_3 gnd 2.080806f
C8  g206_1 gnd 2.080806f
C9  g206_6 gnd 2.080806f
C10  g206_13 gnd 2.080806f
C11  g206_12 gnd 2.080806f
C12  g206_2 gnd 2.080806f
C13  g206_0 gnd 2.080806f
C14  g206_11 gnd 2.080806f
C15  g206_9 gnd 2.080806f
C16 1 gnd 2.080806f
R1 g206_0 1 2.224404
R2 1 g206_4 2.224404
R3 g206_4 g206_8 2.224404
C17 2 gnd 2.080806f
R4 g206_8 2 2.224404
C18 3 gnd 2.080806f
R5 2 3 2.224404
C19 4 gnd 2.080806f
R6 3 4 2.224404
C20 5 gnd 2.080806f
R7 4 5 2.224404
C21 6 gnd 2.080806f
R8 5 6 2.224404
C22 7 gnd 2.080806f
R9 6 7 2.224404
C23 8 gnd 2.080806f
R10 7 8 2.224404
R11 8 g206_5 2.224404
R12 g206_5 g206_12 2.224404
R13 g206_11 g206_12 2.224404
C24 9 gnd 2.080806f
R14 g206_12 9 2.224404
C25 10 gnd 2.080806f
R15 9 10 2.224404
C26 11 gnd 2.080806f
R16 10 11 2.224404
C27 12 gnd 2.080806f
R17 11 12 2.224404
C28 13 gnd 2.080806f
R18 12 13 2.224404
R19 13 g206_2 2.224404
C29 14 gnd 2.080806f
R20 14 g206_5 2.224404
C30 15 gnd 2.080806f
R21 14 15 2.224404
C31 16 gnd 2.080806f
R22 15 16 2.224404
C32 17 gnd 2.080806f
R23 17 16 2.224404
C33 18 gnd 2.080806f
R24 17 18 2.224404
C34 19 gnd 2.080806f
R25 18 19 2.224404
R26 19 g206_13 2.224404
C35 20 gnd 2.080806f
R27 20 g206_13 2.224404
C36 21 gnd 2.080806f
R28 20 21 2.224404
C37 22 gnd 2.080806f
R29 21 22 2.224404
C38 23 gnd 2.080806f
R30 22 23 2.224404
C39 24 gnd 2.080806f
R31 23 24 2.224404
R32 24 g206_1 2.224404
C40 25 gnd 2.080806f
R33 13 25 2.224404
C41 26 gnd 2.080806f
R34 25 26 2.224404
C42 27 gnd 2.080806f
R35 26 27 2.224404
C43 28 gnd 2.080806f
R36 27 28 2.224404
C44 29 gnd 2.080806f
R37 28 29 2.224404
C45 30 gnd 2.080806f
R38 29 30 2.224404
R39 30 g206_9 2.224404
C46 31 gnd 2.080806f
R40 g206_1 31 2.224404
C47 32 gnd 2.080806f
R41 31 32 2.224404
C48 33 gnd 2.080806f
R42 32 33 2.224404
C49 34 gnd 2.080806f
R43 33 34 2.224404
C50 35 gnd 2.080806f
R44 34 35 2.224404
C51 36 gnd 2.080806f
R45 35 36 2.224404
C52 37 gnd 2.080806f
R46 36 37 2.224404
C53 38 gnd 2.080806f
R47 37 38 2.224404
C54 39 gnd 2.080806f
R48 38 39 2.224404
C55 40 gnd 2.080806f
R49 39 40 2.224404
C56 41 gnd 2.080806f
R50 40 41 2.224404
C57 42 gnd 2.080806f
R51 41 42 2.224404
C58 43 gnd 2.080806f
R52 42 43 2.224404
C59 44 gnd 2.080806f
R53 43 44 2.224404
C60 45 gnd 2.080806f
R54 44 45 2.224404
C61 46 gnd 2.080806f
R55 45 46 2.224404
C62 47 gnd 2.080806f
R56 46 47 2.224404
C63 48 gnd 2.080806f
R57 47 48 2.224404
C64 49 gnd 2.080806f
R58 48 49 2.224404
C65 50 gnd 2.080806f
R59 49 50 2.224404
C66 51 gnd 2.080806f
R60 50 51 2.224404
R61 51 g206_14 2.224404
C67 52 gnd 2.080806f
R62 g206_14 52 2.224404
C68 53 gnd 2.080806f
R63 52 53 2.224404
R64 53 g206_3 2.224404
R65 g206_3 g206_10 2.224404
R66 g206_10 g206_7 2.224404
C69 54 gnd 2.080806f
R67 54 g206_14 2.224404
C70 55 gnd 2.080806f
R68 54 55 2.224404
C71 56 gnd 2.080806f
R69 55 56 2.224404
C72 57 gnd 2.080806f
R70 56 57 2.224404
C73 58 gnd 2.080806f
R71 57 58 2.224404
C74 59 gnd 2.080806f
R72 58 59 2.224404
C75 60 gnd 2.080806f
R73 59 60 2.224404
C76 61 gnd 2.080806f
R74 60 61 2.224404
C77 62 gnd 2.080806f
R75 61 62 2.224404
C78 63 gnd 2.080806f
R76 62 63 2.224404
C79 64 gnd 2.080806f
R77 63 64 2.224404
C80 65 gnd 2.080806f
R78 64 65 2.224404
C81 66 gnd 2.080806f
R79 65 66 2.224404
C82 67 gnd 2.080806f
R80 66 67 2.224404
C83 68 gnd 2.080806f
R81 67 68 2.224404
C84 69 gnd 2.080806f
R82 68 69 2.224404
C85 70 gnd 2.080806f
R83 69 70 2.224404
C86 71 gnd 2.080806f
R84 71 70 2.224404
C87 72 gnd 2.080806f
R85 72 71 2.224404
C88 73 gnd 2.080806f
R86 72 73 2.224404
C89 74 gnd 2.080806f
R87 73 74 2.224404
C90 75 gnd 2.080806f
R88 74 75 2.224404
C91 76 gnd 2.080806f
R89 75 76 2.224404
C92 77 gnd 2.080806f
R90 76 77 2.224404
C93 78 gnd 2.080806f
R91 77 78 2.224404
C94 79 gnd 2.080806f
R92 78 79 2.224404
C95 80 gnd 2.080806f
R93 79 80 2.224404
C96 81 gnd 2.080806f
R94 80 81 2.224404
C97 82 gnd 2.080806f
R95 81 82 2.224404
C98 83 gnd 2.080806f
R96 82 83 2.224404
C99 84 gnd 2.080806f
R97 83 84 2.224404
C100 85 gnd 2.080806f
R98 84 85 2.224404
C101 86 gnd 2.080806f
R99 85 86 2.224404
C102 87 gnd 2.080806f
R100 86 87 2.224404
C103 88 gnd 2.080806f
R101 87 88 2.224404
C104 89 gnd 2.080806f
R102 89 88 2.224404
C105 90 gnd 2.080806f
R103 90 89 2.224404
C106 91 gnd 2.080806f
R104 90 91 2.224404
C107 92 gnd 2.080806f
R105 91 92 2.224404
C108 93 gnd 2.080806f
R106 92 93 2.224404
C109 94 gnd 2.080806f
R107 93 94 2.224404
C110 95 gnd 2.080806f
R108 94 95 2.224404
C111 96 gnd 2.080806f
R109 95 96 2.224404
C112 97 gnd 2.080806f
R110 96 97 2.224404
C113 98 gnd 2.080806f
R111 97 98 2.224404
C114 99 gnd 2.080806f
R112 98 99 2.224404
C115 100 gnd 2.080806f
R113 99 100 2.224404
C116 101 gnd 2.080806f
R114 100 101 2.224404
C117 102 gnd 2.080806f
R115 101 102 2.224404
C118 103 gnd 2.080806f
R116 102 103 2.224404
C119 104 gnd 2.080806f
R117 103 104 2.224404
C120 105 gnd 2.080806f
R118 104 105 2.224404
C121 106 gnd 2.080806f
R119 105 106 2.224404
C122 107 gnd 2.080806f
R120 106 107 2.224404
C123 108 gnd 2.080806f
R121 108 107 2.224404
R122 g206_6 108 2.224404
.ends

.subckt netg16 g16_1 g16_2 g16_0 gnd
C1  g16_1 gnd 2.080806f
C2  g16_2 gnd 2.080806f
C3  g16_0 gnd 2.080806f
R1 g16_0 g16_2 2.224404
C4 1 gnd 2.080806f
R2 1 g16_0 2.224404
C5 2 gnd 2.080806f
R3 2 1 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 4 3 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 6 5 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 12 11 2.224404
C16 13 gnd 2.080806f
R14 13 12 2.224404
C17 14 gnd 2.080806f
R15 14 13 2.224404
C18 15 gnd 2.080806f
R16 15 14 2.224404
C19 16 gnd 2.080806f
R17 16 15 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 19 18 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 21 20 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 27 26 2.224404
C31 28 gnd 2.080806f
R29 28 27 2.224404
C32 29 gnd 2.080806f
R30 29 28 2.224404
C33 30 gnd 2.080806f
R31 30 29 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 32 31 2.224404
C36 33 gnd 2.080806f
R34 33 32 2.224404
C37 34 gnd 2.080806f
R35 34 33 2.224404
C38 35 gnd 2.080806f
R36 35 34 2.224404
C39 36 gnd 2.080806f
R37 36 35 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 38 37 2.224404
C42 39 gnd 2.080806f
R40 39 38 2.224404
C43 40 gnd 2.080806f
R41 40 39 2.224404
C44 41 gnd 2.080806f
R42 41 40 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 43 42 2.224404
C47 44 gnd 2.080806f
R45 44 43 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 49 48 2.224404
C53 50 gnd 2.080806f
R51 50 49 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 52 51 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 54 53 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 56 55 2.224404
C60 57 gnd 2.080806f
R58 57 56 2.224404
C61 58 gnd 2.080806f
R59 58 57 2.224404
C62 59 gnd 2.080806f
R60 59 58 2.224404
C63 60 gnd 2.080806f
R61 60 59 2.224404
C64 61 gnd 2.080806f
R62 61 60 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 65 64 2.224404
C69 66 gnd 2.080806f
R67 66 65 2.224404
C70 67 gnd 2.080806f
R68 67 66 2.224404
C71 68 gnd 2.080806f
R69 68 67 2.224404
C72 69 gnd 2.080806f
R70 69 68 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 73 72 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 75 74 2.224404
C79 76 gnd 2.080806f
R77 76 75 2.224404
C80 77 gnd 2.080806f
R78 77 76 2.224404
C81 78 gnd 2.080806f
R79 78 77 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 81 80 2.224404
C85 82 gnd 2.080806f
R83 82 81 2.224404
C86 83 gnd 2.080806f
R84 83 82 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 85 84 2.224404
C89 86 gnd 2.080806f
R87 86 85 2.224404
C90 87 gnd 2.080806f
R88 87 86 2.224404
C91 88 gnd 2.080806f
R89 88 87 2.224404
C92 89 gnd 2.080806f
R90 89 88 2.224404
C93 90 gnd 2.080806f
R91 90 89 2.224404
C94 91 gnd 2.080806f
R92 91 90 2.224404
C95 92 gnd 2.080806f
R93 92 91 2.224404
C96 93 gnd 2.080806f
R94 93 92 2.224404
C97 94 gnd 2.080806f
R95 94 93 2.224404
C98 95 gnd 2.080806f
R96 95 94 2.224404
C99 96 gnd 2.080806f
R97 96 95 2.224404
C100 97 gnd 2.080806f
R98 97 96 2.224404
C101 98 gnd 2.080806f
R99 98 97 2.224404
C102 99 gnd 2.080806f
R100 99 98 2.224404
C103 100 gnd 2.080806f
R101 100 99 2.224404
C104 101 gnd 2.080806f
R102 101 100 2.224404
C105 102 gnd 2.080806f
R103 102 101 2.224404
C106 103 gnd 2.080806f
R104 103 102 2.224404
C107 104 gnd 2.080806f
R105 104 103 2.224404
C108 105 gnd 2.080806f
R106 105 104 2.224404
C109 106 gnd 2.080806f
R107 106 105 2.224404
R108 g16_1 106 2.224404
.ends

.subckt netg177 g177_1 g177_0 g177_2 gnd
C1  g177_1 gnd 2.080806f
C2  g177_0 gnd 2.080806f
C3  g177_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g177_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 34 35 2.224404
C39 36 gnd 2.080806f
R36 35 36 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 38 39 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 40 41 2.224404
C45 42 gnd 2.080806f
R42 41 42 2.224404
C46 43 gnd 2.080806f
R43 42 43 2.224404
C47 44 gnd 2.080806f
R44 43 44 2.224404
C48 45 gnd 2.080806f
R45 44 45 2.224404
C49 46 gnd 2.080806f
R46 45 46 2.224404
C50 47 gnd 2.080806f
R47 47 46 2.224404
C51 48 gnd 2.080806f
R48 47 48 2.224404
R49 g177_1 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
R106 104 g177_2 2.224404
.ends

.subckt netg7483 g7483_1 g7483_0 gnd
C1  g7483_1 gnd 2.080806f
C2  g7483_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g7483_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 25 26 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 28 29 2.224404
C32 30 gnd 2.080806f
R30 29 30 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 43 44 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 46 47 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 55 56 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 59 60 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 62 63 2.224404
C66 64 gnd 2.080806f
R64 63 64 2.224404
C67 65 gnd 2.080806f
R65 64 65 2.224404
C68 66 gnd 2.080806f
R66 65 66 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 67 68 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 70 71 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 75 76 2.224404
C79 77 gnd 2.080806f
R77 77 76 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
C81 79 gnd 2.080806f
R79 79 78 2.224404
C82 80 gnd 2.080806f
R80 79 80 2.224404
C83 81 gnd 2.080806f
R81 81 80 2.224404
C84 82 gnd 2.080806f
R82 82 81 2.224404
C85 83 gnd 2.080806f
R83 82 83 2.224404
C86 84 gnd 2.080806f
R84 84 83 2.224404
C87 85 gnd 2.080806f
R85 85 84 2.224404
C88 86 gnd 2.080806f
R86 85 86 2.224404
C89 87 gnd 2.080806f
R87 87 86 2.224404
C90 88 gnd 2.080806f
R88 88 87 2.224404
C91 89 gnd 2.080806f
R89 89 88 2.224404
C92 90 gnd 2.080806f
R90 89 90 2.224404
C93 91 gnd 2.080806f
R91 90 91 2.224404
C94 92 gnd 2.080806f
R92 92 91 2.224404
C95 93 gnd 2.080806f
R93 92 93 2.224404
C96 94 gnd 2.080806f
R94 94 93 2.224404
R95 g7483_1 94 2.224404
.ends

.subckt netg200 g200_0 g200_2 g200_1 gnd
C1  g200_0 gnd 2.080806f
C2  g200_2 gnd 2.080806f
C3  g200_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g200_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 45 44 2.224404
C49 46 gnd 2.080806f
R46 46 45 2.224404
C50 47 gnd 2.080806f
R47 47 46 2.224404
C51 48 gnd 2.080806f
R48 48 47 2.224404
C52 49 gnd 2.080806f
R49 49 48 2.224404
C53 50 gnd 2.080806f
R50 50 49 2.224404
C54 51 gnd 2.080806f
R51 51 50 2.224404
C55 52 gnd 2.080806f
R52 52 51 2.224404
C56 53 gnd 2.080806f
R53 53 52 2.224404
C57 54 gnd 2.080806f
R54 54 53 2.224404
C58 55 gnd 2.080806f
R55 55 54 2.224404
C59 56 gnd 2.080806f
R56 56 55 2.224404
C60 57 gnd 2.080806f
R57 57 56 2.224404
C61 58 gnd 2.080806f
R58 58 57 2.224404
C62 59 gnd 2.080806f
R59 59 58 2.224404
C63 60 gnd 2.080806f
R60 60 59 2.224404
C64 61 gnd 2.080806f
R61 61 60 2.224404
C65 62 gnd 2.080806f
R62 62 61 2.224404
C66 63 gnd 2.080806f
R63 63 62 2.224404
C67 64 gnd 2.080806f
R64 64 63 2.224404
C68 65 gnd 2.080806f
R65 65 64 2.224404
C69 66 gnd 2.080806f
R66 66 65 2.224404
C70 67 gnd 2.080806f
R67 67 66 2.224404
C71 68 gnd 2.080806f
R68 68 67 2.224404
R69 g200_2 68 2.224404
C72 69 gnd 2.080806f
R70 69 g200_2 2.224404
C73 70 gnd 2.080806f
R71 70 69 2.224404
C74 71 gnd 2.080806f
R72 71 70 2.224404
C75 72 gnd 2.080806f
R73 72 71 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 79 78 2.224404
C83 80 gnd 2.080806f
R81 80 79 2.224404
C84 81 gnd 2.080806f
R82 81 80 2.224404
C85 82 gnd 2.080806f
R83 82 81 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 84 83 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 86 85 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 91 90 2.224404
C95 92 gnd 2.080806f
R93 92 91 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 100 99 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
C108 105 gnd 2.080806f
R106 104 105 2.224404
C109 106 gnd 2.080806f
R107 105 106 2.224404
C110 107 gnd 2.080806f
R108 107 106 2.224404
C111 108 gnd 2.080806f
R109 107 108 2.224404
C112 109 gnd 2.080806f
R110 108 109 2.224404
C113 110 gnd 2.080806f
R111 109 110 2.224404
C114 111 gnd 2.080806f
R112 110 111 2.224404
C115 112 gnd 2.080806f
R113 111 112 2.224404
C116 113 gnd 2.080806f
R114 112 113 2.224404
C117 114 gnd 2.080806f
R115 113 114 2.224404
C118 115 gnd 2.080806f
R116 114 115 2.224404
C119 116 gnd 2.080806f
R117 115 116 2.224404
C120 117 gnd 2.080806f
R118 117 116 2.224404
C121 118 gnd 2.080806f
R119 117 118 2.224404
C122 119 gnd 2.080806f
R120 118 119 2.224404
R121 119 g200_1 2.224404
.ends

.subckt netg8 g8_1 g8_2 g8_0 gnd
C1  g8_1 gnd 2.080806f
C2  g8_2 gnd 2.080806f
C3  g8_0 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g8_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 34 35 2.224404
C39 36 gnd 2.080806f
R36 35 36 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 38 39 2.224404
C43 40 gnd 2.080806f
R40 39 40 2.224404
C44 41 gnd 2.080806f
R41 40 41 2.224404
C45 42 gnd 2.080806f
R42 41 42 2.224404
C46 43 gnd 2.080806f
R43 42 43 2.224404
C47 44 gnd 2.080806f
R44 43 44 2.224404
C48 45 gnd 2.080806f
R45 44 45 2.224404
C49 46 gnd 2.080806f
R46 45 46 2.224404
C50 47 gnd 2.080806f
R47 46 47 2.224404
C51 48 gnd 2.080806f
R48 47 48 2.224404
C52 49 gnd 2.080806f
R49 48 49 2.224404
C53 50 gnd 2.080806f
R50 49 50 2.224404
C54 51 gnd 2.080806f
R51 50 51 2.224404
C55 52 gnd 2.080806f
R52 51 52 2.224404
C56 53 gnd 2.080806f
R53 52 53 2.224404
C57 54 gnd 2.080806f
R54 53 54 2.224404
C58 55 gnd 2.080806f
R55 54 55 2.224404
C59 56 gnd 2.080806f
R56 55 56 2.224404
C60 57 gnd 2.080806f
R57 56 57 2.224404
C61 58 gnd 2.080806f
R58 57 58 2.224404
C62 59 gnd 2.080806f
R59 58 59 2.224404
C63 60 gnd 2.080806f
R60 59 60 2.224404
C64 61 gnd 2.080806f
R61 60 61 2.224404
C65 62 gnd 2.080806f
R62 61 62 2.224404
C66 63 gnd 2.080806f
R63 62 63 2.224404
C67 64 gnd 2.080806f
R64 63 64 2.224404
C68 65 gnd 2.080806f
R65 64 65 2.224404
C69 66 gnd 2.080806f
R66 65 66 2.224404
C70 67 gnd 2.080806f
R67 66 67 2.224404
C71 68 gnd 2.080806f
R68 67 68 2.224404
C72 69 gnd 2.080806f
R69 68 69 2.224404
C73 70 gnd 2.080806f
R70 69 70 2.224404
C74 71 gnd 2.080806f
R71 70 71 2.224404
C75 72 gnd 2.080806f
R72 71 72 2.224404
C76 73 gnd 2.080806f
R73 72 73 2.224404
C77 74 gnd 2.080806f
R74 73 74 2.224404
C78 75 gnd 2.080806f
R75 74 75 2.224404
C79 76 gnd 2.080806f
R76 75 76 2.224404
C80 77 gnd 2.080806f
R77 76 77 2.224404
C81 78 gnd 2.080806f
R78 77 78 2.224404
C82 79 gnd 2.080806f
R79 78 79 2.224404
C83 80 gnd 2.080806f
R80 79 80 2.224404
C84 81 gnd 2.080806f
R81 80 81 2.224404
C85 82 gnd 2.080806f
R82 81 82 2.224404
C86 83 gnd 2.080806f
R83 82 83 2.224404
C87 84 gnd 2.080806f
R84 83 84 2.224404
C88 85 gnd 2.080806f
R85 84 85 2.224404
R86 85 g8_1 2.224404
C89 86 gnd 2.080806f
R87 g8_1 86 2.224404
C90 87 gnd 2.080806f
R88 87 86 2.224404
C91 88 gnd 2.080806f
R89 88 87 2.224404
C92 89 gnd 2.080806f
R90 89 88 2.224404
C93 90 gnd 2.080806f
R91 90 89 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 92 91 2.224404
C96 93 gnd 2.080806f
R94 93 92 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
C108 105 gnd 2.080806f
R106 104 105 2.224404
C109 106 gnd 2.080806f
R107 105 106 2.224404
C110 107 gnd 2.080806f
R108 106 107 2.224404
C111 108 gnd 2.080806f
R109 107 108 2.224404
C112 109 gnd 2.080806f
R110 108 109 2.224404
C113 110 gnd 2.080806f
R111 109 110 2.224404
C114 111 gnd 2.080806f
R112 110 111 2.224404
C115 112 gnd 2.080806f
R113 111 112 2.224404
C116 113 gnd 2.080806f
R114 113 112 2.224404
C117 114 gnd 2.080806f
R115 114 113 2.224404
C118 115 gnd 2.080806f
R116 115 114 2.224404
C119 116 gnd 2.080806f
R117 115 116 2.224404
C120 117 gnd 2.080806f
R118 117 116 2.224404
C121 118 gnd 2.080806f
R119 118 117 2.224404
C122 119 gnd 2.080806f
R120 119 118 2.224404
C123 120 gnd 2.080806f
R121 120 119 2.224404
C124 121 gnd 2.080806f
R122 120 121 2.224404
C125 122 gnd 2.080806f
R123 121 122 2.224404
C126 123 gnd 2.080806f
R124 122 123 2.224404
C127 124 gnd 2.080806f
R125 123 124 2.224404
C128 125 gnd 2.080806f
R126 125 124 2.224404
C129 126 gnd 2.080806f
R127 126 125 2.224404
C130 127 gnd 2.080806f
R128 127 126 2.224404
R129 127 g8_2 2.224404
.ends

.subckt netg207 g207_3 g207_2 g207_0 g207_4 g207_1 gnd
C1  g207_3 gnd 2.080806f
C2  g207_2 gnd 2.080806f
C3  g207_0 gnd 2.080806f
C4  g207_4 gnd 2.080806f
C5  g207_1 gnd 2.080806f
R1 g207_2 g207_0 2.224404
C6 1 gnd 2.080806f
R2 1 g207_2 2.224404
C7 2 gnd 2.080806f
R3 2 1 2.224404
C8 3 gnd 2.080806f
R4 3 2 2.224404
C9 4 gnd 2.080806f
R5 4 3 2.224404
C10 5 gnd 2.080806f
R6 5 4 2.224404
C11 6 gnd 2.080806f
R7 6 5 2.224404
C12 7 gnd 2.080806f
R8 7 6 2.224404
C13 8 gnd 2.080806f
R9 8 7 2.224404
C14 9 gnd 2.080806f
R10 9 8 2.224404
C15 10 gnd 2.080806f
R11 10 9 2.224404
C16 11 gnd 2.080806f
R12 11 10 2.224404
C17 12 gnd 2.080806f
R13 12 11 2.224404
C18 13 gnd 2.080806f
R14 13 12 2.224404
C19 14 gnd 2.080806f
R15 14 13 2.224404
C20 15 gnd 2.080806f
R16 15 14 2.224404
C21 16 gnd 2.080806f
R17 16 15 2.224404
C22 17 gnd 2.080806f
R18 17 16 2.224404
C23 18 gnd 2.080806f
R19 18 17 2.224404
C24 19 gnd 2.080806f
R20 19 18 2.224404
C25 20 gnd 2.080806f
R21 20 19 2.224404
C26 21 gnd 2.080806f
R22 21 20 2.224404
C27 22 gnd 2.080806f
R23 22 21 2.224404
C28 23 gnd 2.080806f
R24 23 22 2.224404
C29 24 gnd 2.080806f
R25 24 23 2.224404
C30 25 gnd 2.080806f
R26 25 24 2.224404
C31 26 gnd 2.080806f
R27 26 25 2.224404
C32 27 gnd 2.080806f
R28 27 26 2.224404
C33 28 gnd 2.080806f
R29 28 27 2.224404
C34 29 gnd 2.080806f
R30 29 28 2.224404
C35 30 gnd 2.080806f
R31 30 29 2.224404
C36 31 gnd 2.080806f
R32 31 30 2.224404
C37 32 gnd 2.080806f
R33 32 31 2.224404
C38 33 gnd 2.080806f
R34 33 32 2.224404
C39 34 gnd 2.080806f
R35 34 33 2.224404
C40 35 gnd 2.080806f
R36 35 34 2.224404
C41 36 gnd 2.080806f
R37 36 35 2.224404
C42 37 gnd 2.080806f
R38 37 36 2.224404
C43 38 gnd 2.080806f
R39 38 37 2.224404
C44 39 gnd 2.080806f
R40 39 38 2.224404
C45 40 gnd 2.080806f
R41 40 39 2.224404
C46 41 gnd 2.080806f
R42 41 40 2.224404
C47 42 gnd 2.080806f
R43 42 41 2.224404
C48 43 gnd 2.080806f
R44 43 42 2.224404
C49 44 gnd 2.080806f
R45 44 43 2.224404
C50 45 gnd 2.080806f
R46 45 44 2.224404
C51 46 gnd 2.080806f
R47 46 45 2.224404
C52 47 gnd 2.080806f
R48 47 46 2.224404
C53 48 gnd 2.080806f
R49 48 47 2.224404
C54 49 gnd 2.080806f
R50 49 48 2.224404
C55 50 gnd 2.080806f
R51 50 49 2.224404
R52 g207_4 50 2.224404
R53 g207_3 g207_4 2.224404
C56 51 gnd 2.080806f
R54 2 51 2.224404
C57 52 gnd 2.080806f
R55 51 52 2.224404
C58 53 gnd 2.080806f
R56 53 52 2.224404
C59 54 gnd 2.080806f
R57 54 53 2.224404
C60 55 gnd 2.080806f
R58 54 55 2.224404
C61 56 gnd 2.080806f
R59 55 56 2.224404
C62 57 gnd 2.080806f
R60 57 56 2.224404
C63 58 gnd 2.080806f
R61 58 57 2.224404
C64 59 gnd 2.080806f
R62 59 58 2.224404
C65 60 gnd 2.080806f
R63 59 60 2.224404
C66 61 gnd 2.080806f
R64 61 60 2.224404
C67 62 gnd 2.080806f
R65 62 61 2.224404
C68 63 gnd 2.080806f
R66 63 62 2.224404
C69 64 gnd 2.080806f
R67 64 63 2.224404
C70 65 gnd 2.080806f
R68 64 65 2.224404
C71 66 gnd 2.080806f
R69 65 66 2.224404
C72 67 gnd 2.080806f
R70 66 67 2.224404
C73 68 gnd 2.080806f
R71 67 68 2.224404
C74 69 gnd 2.080806f
R72 68 69 2.224404
C75 70 gnd 2.080806f
R73 69 70 2.224404
C76 71 gnd 2.080806f
R74 70 71 2.224404
C77 72 gnd 2.080806f
R75 71 72 2.224404
C78 73 gnd 2.080806f
R76 72 73 2.224404
C79 74 gnd 2.080806f
R77 73 74 2.224404
C80 75 gnd 2.080806f
R78 74 75 2.224404
C81 76 gnd 2.080806f
R79 75 76 2.224404
C82 77 gnd 2.080806f
R80 76 77 2.224404
C83 78 gnd 2.080806f
R81 77 78 2.224404
C84 79 gnd 2.080806f
R82 78 79 2.224404
C85 80 gnd 2.080806f
R83 79 80 2.224404
C86 81 gnd 2.080806f
R84 81 80 2.224404
C87 82 gnd 2.080806f
R85 81 82 2.224404
C88 83 gnd 2.080806f
R86 83 82 2.224404
C89 84 gnd 2.080806f
R87 83 84 2.224404
C90 85 gnd 2.080806f
R88 85 84 2.224404
C91 86 gnd 2.080806f
R89 86 85 2.224404
C92 87 gnd 2.080806f
R90 87 86 2.224404
C93 88 gnd 2.080806f
R91 87 88 2.224404
C94 89 gnd 2.080806f
R92 89 88 2.224404
C95 90 gnd 2.080806f
R93 89 90 2.224404
C96 91 gnd 2.080806f
R94 90 91 2.224404
C97 92 gnd 2.080806f
R95 92 91 2.224404
C98 93 gnd 2.080806f
R96 92 93 2.224404
C99 94 gnd 2.080806f
R97 93 94 2.224404
C100 95 gnd 2.080806f
R98 94 95 2.224404
C101 96 gnd 2.080806f
R99 95 96 2.224404
C102 97 gnd 2.080806f
R100 96 97 2.224404
C103 98 gnd 2.080806f
R101 97 98 2.224404
C104 99 gnd 2.080806f
R102 98 99 2.224404
C105 100 gnd 2.080806f
R103 99 100 2.224404
C106 101 gnd 2.080806f
R104 100 101 2.224404
C107 102 gnd 2.080806f
R105 101 102 2.224404
C108 103 gnd 2.080806f
R106 102 103 2.224404
C109 104 gnd 2.080806f
R107 104 103 2.224404
C110 105 gnd 2.080806f
R108 105 104 2.224404
C111 106 gnd 2.080806f
R109 106 105 2.224404
C112 107 gnd 2.080806f
R110 106 107 2.224404
C113 108 gnd 2.080806f
R111 107 108 2.224404
C114 109 gnd 2.080806f
R112 108 109 2.224404
C115 110 gnd 2.080806f
R113 109 110 2.224404
C116 111 gnd 2.080806f
R114 110 111 2.224404
C117 112 gnd 2.080806f
R115 111 112 2.224404
C118 113 gnd 2.080806f
R116 113 112 2.224404
C119 114 gnd 2.080806f
R117 114 113 2.224404
C120 115 gnd 2.080806f
R118 114 115 2.224404
C121 116 gnd 2.080806f
R119 116 115 2.224404
R120 g207_1 116 2.224404
.ends

.subckt netg11 g11_2 g11_1 gnd
C1  g11_2 gnd 2.080806f
C2  g11_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g11_2 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
C79 77 gnd 2.080806f
R77 77 76 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
C81 79 gnd 2.080806f
R79 79 78 2.224404
C82 80 gnd 2.080806f
R80 80 79 2.224404
C83 81 gnd 2.080806f
R81 81 80 2.224404
C84 82 gnd 2.080806f
R82 82 81 2.224404
C85 83 gnd 2.080806f
R83 83 82 2.224404
C86 84 gnd 2.080806f
R84 84 83 2.224404
C87 85 gnd 2.080806f
R85 85 84 2.224404
C88 86 gnd 2.080806f
R86 86 85 2.224404
C89 87 gnd 2.080806f
R87 87 86 2.224404
C90 88 gnd 2.080806f
R88 88 87 2.224404
C91 89 gnd 2.080806f
R89 89 88 2.224404
C92 90 gnd 2.080806f
R90 90 89 2.224404
C93 91 gnd 2.080806f
R91 91 90 2.224404
C94 92 gnd 2.080806f
R92 92 91 2.224404
C95 93 gnd 2.080806f
R93 93 92 2.224404
C96 94 gnd 2.080806f
R94 94 93 2.224404
C97 95 gnd 2.080806f
R95 95 94 2.224404
C98 96 gnd 2.080806f
R96 96 95 2.224404
C99 97 gnd 2.080806f
R97 97 96 2.224404
C100 98 gnd 2.080806f
R98 98 97 2.224404
C101 99 gnd 2.080806f
R99 99 98 2.224404
C102 100 gnd 2.080806f
R100 100 99 2.224404
R101 g11_1 100 2.224404
.ends

.subckt netg6 g6_0 g6_2 g6_1 g6_4 g6_3 gnd
C1  g6_0 gnd 2.080806f
C2  g6_2 gnd 2.080806f
C3  g6_1 gnd 2.080806f
C4  g6_4 gnd 2.080806f
C5  g6_3 gnd 2.080806f
C6 1 gnd 2.080806f
R1 g6_0 1 2.224404
C7 2 gnd 2.080806f
R2 1 2 2.224404
C8 3 gnd 2.080806f
R3 2 3 2.224404
R4 3 g6_1 2.224404
C9 4 gnd 2.080806f
R5 4 3 2.224404
C10 5 gnd 2.080806f
R6 5 4 2.224404
C11 6 gnd 2.080806f
R7 6 5 2.224404
C12 7 gnd 2.080806f
R8 6 7 2.224404
C13 8 gnd 2.080806f
R9 7 8 2.224404
C14 9 gnd 2.080806f
R10 9 8 2.224404
C15 10 gnd 2.080806f
R11 9 10 2.224404
C16 11 gnd 2.080806f
R12 10 11 2.224404
C17 12 gnd 2.080806f
R13 11 12 2.224404
C18 13 gnd 2.080806f
R14 13 12 2.224404
C19 14 gnd 2.080806f
R15 13 14 2.224404
C20 15 gnd 2.080806f
R16 14 15 2.224404
C21 16 gnd 2.080806f
R17 15 16 2.224404
C22 17 gnd 2.080806f
R18 16 17 2.224404
C23 18 gnd 2.080806f
R19 17 18 2.224404
C24 19 gnd 2.080806f
R20 18 19 2.224404
C25 20 gnd 2.080806f
R21 20 19 2.224404
C26 21 gnd 2.080806f
R22 21 20 2.224404
C27 22 gnd 2.080806f
R23 22 21 2.224404
C28 23 gnd 2.080806f
R24 23 22 2.224404
C29 24 gnd 2.080806f
R25 24 23 2.224404
C30 25 gnd 2.080806f
R26 24 25 2.224404
C31 26 gnd 2.080806f
R27 26 25 2.224404
C32 27 gnd 2.080806f
R28 27 26 2.224404
C33 28 gnd 2.080806f
R29 28 27 2.224404
C34 29 gnd 2.080806f
R30 29 28 2.224404
C35 30 gnd 2.080806f
R31 30 29 2.224404
R32 g6_2 30 2.224404
C36 31 gnd 2.080806f
R33 31 g6_2 2.224404
C37 32 gnd 2.080806f
R34 32 31 2.224404
C38 33 gnd 2.080806f
R35 33 32 2.224404
C39 34 gnd 2.080806f
R36 33 34 2.224404
C40 35 gnd 2.080806f
R37 35 34 2.224404
C41 36 gnd 2.080806f
R38 36 35 2.224404
C42 37 gnd 2.080806f
R39 37 36 2.224404
C43 38 gnd 2.080806f
R40 38 37 2.224404
C44 39 gnd 2.080806f
R41 39 38 2.224404
C45 40 gnd 2.080806f
R42 40 39 2.224404
C46 41 gnd 2.080806f
R43 41 40 2.224404
C47 42 gnd 2.080806f
R44 42 41 2.224404
C48 43 gnd 2.080806f
R45 43 42 2.224404
C49 44 gnd 2.080806f
R46 44 43 2.224404
C50 45 gnd 2.080806f
R47 45 44 2.224404
C51 46 gnd 2.080806f
R48 46 45 2.224404
C52 47 gnd 2.080806f
R49 47 46 2.224404
C53 48 gnd 2.080806f
R50 48 47 2.224404
C54 49 gnd 2.080806f
R51 49 48 2.224404
C55 50 gnd 2.080806f
R52 50 49 2.224404
C56 51 gnd 2.080806f
R53 51 50 2.224404
C57 52 gnd 2.080806f
R54 52 51 2.224404
C58 53 gnd 2.080806f
R55 53 52 2.224404
C59 54 gnd 2.080806f
R56 54 53 2.224404
C60 55 gnd 2.080806f
R57 55 54 2.224404
C61 56 gnd 2.080806f
R58 56 55 2.224404
C62 57 gnd 2.080806f
R59 57 56 2.224404
C63 58 gnd 2.080806f
R60 58 57 2.224404
R61 g6_3 58 2.224404
C64 59 gnd 2.080806f
R62 59 g6_3 2.224404
C65 60 gnd 2.080806f
R63 60 59 2.224404
C66 61 gnd 2.080806f
R64 61 60 2.224404
C67 62 gnd 2.080806f
R65 62 61 2.224404
C68 63 gnd 2.080806f
R66 63 62 2.224404
C69 64 gnd 2.080806f
R67 64 63 2.224404
C70 65 gnd 2.080806f
R68 65 64 2.224404
C71 66 gnd 2.080806f
R69 66 65 2.224404
C72 67 gnd 2.080806f
R70 67 66 2.224404
C73 68 gnd 2.080806f
R71 68 67 2.224404
C74 69 gnd 2.080806f
R72 69 68 2.224404
C75 70 gnd 2.080806f
R73 70 69 2.224404
C76 71 gnd 2.080806f
R74 71 70 2.224404
C77 72 gnd 2.080806f
R75 72 71 2.224404
C78 73 gnd 2.080806f
R76 73 72 2.224404
C79 74 gnd 2.080806f
R77 74 73 2.224404
C80 75 gnd 2.080806f
R78 75 74 2.224404
C81 76 gnd 2.080806f
R79 76 75 2.224404
C82 77 gnd 2.080806f
R80 77 76 2.224404
C83 78 gnd 2.080806f
R81 78 77 2.224404
C84 79 gnd 2.080806f
R82 79 78 2.224404
C85 80 gnd 2.080806f
R83 80 79 2.224404
C86 81 gnd 2.080806f
R84 81 80 2.224404
C87 82 gnd 2.080806f
R85 82 81 2.224404
C88 83 gnd 2.080806f
R86 83 82 2.224404
C89 84 gnd 2.080806f
R87 84 83 2.224404
C90 85 gnd 2.080806f
R88 85 84 2.224404
C91 86 gnd 2.080806f
R89 86 85 2.224404
C92 87 gnd 2.080806f
R90 87 86 2.224404
C93 88 gnd 2.080806f
R91 88 87 2.224404
C94 89 gnd 2.080806f
R92 89 88 2.224404
C95 90 gnd 2.080806f
R93 90 89 2.224404
C96 91 gnd 2.080806f
R94 91 90 2.224404
C97 92 gnd 2.080806f
R95 92 91 2.224404
C98 93 gnd 2.080806f
R96 93 92 2.224404
C99 94 gnd 2.080806f
R97 94 93 2.224404
C100 95 gnd 2.080806f
R98 95 94 2.224404
C101 96 gnd 2.080806f
R99 96 95 2.224404
C102 97 gnd 2.080806f
R100 97 96 2.224404
C103 98 gnd 2.080806f
R101 98 97 2.224404
C104 99 gnd 2.080806f
R102 99 98 2.224404
C105 100 gnd 2.080806f
R103 100 99 2.224404
C106 101 gnd 2.080806f
R104 101 100 2.224404
C107 102 gnd 2.080806f
R105 102 101 2.224404
C108 103 gnd 2.080806f
R106 103 102 2.224404
C109 104 gnd 2.080806f
R107 104 103 2.224404
C110 105 gnd 2.080806f
R108 105 104 2.224404
C111 106 gnd 2.080806f
R109 106 105 2.224404
C112 107 gnd 2.080806f
R110 107 106 2.224404
C113 108 gnd 2.080806f
R111 108 107 2.224404
C114 109 gnd 2.080806f
R112 109 108 2.224404
C115 110 gnd 2.080806f
R113 110 109 2.224404
C116 111 gnd 2.080806f
R114 111 110 2.224404
C117 112 gnd 2.080806f
R115 112 111 2.224404
C118 113 gnd 2.080806f
R116 113 112 2.224404
C119 114 gnd 2.080806f
R117 114 113 2.224404
C120 115 gnd 2.080806f
R118 115 114 2.224404
R119 g6_4 115 2.224404
.ends

.subckt netg15 g15_0 g15_2 g15_1 gnd
C1  g15_0 gnd 2.080806f
C2  g15_2 gnd 2.080806f
C3  g15_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 g15_0 1 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 10 11 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 13 14 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 31 32 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 34 35 2.224404
C39 36 gnd 2.080806f
R36 35 36 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 37 38 2.224404
C42 39 gnd 2.080806f
R39 38 39 2.224404
C43 40 gnd 2.080806f
R40 39 40 2.224404
C44 41 gnd 2.080806f
R41 40 41 2.224404
C45 42 gnd 2.080806f
R42 41 42 2.224404
C46 43 gnd 2.080806f
R43 42 43 2.224404
C47 44 gnd 2.080806f
R44 43 44 2.224404
C48 45 gnd 2.080806f
R45 44 45 2.224404
C49 46 gnd 2.080806f
R46 45 46 2.224404
C50 47 gnd 2.080806f
R47 46 47 2.224404
C51 48 gnd 2.080806f
R48 47 48 2.224404
C52 49 gnd 2.080806f
R49 48 49 2.224404
C53 50 gnd 2.080806f
R50 50 49 2.224404
C54 51 gnd 2.080806f
R51 50 51 2.224404
C55 52 gnd 2.080806f
R52 52 51 2.224404
C56 53 gnd 2.080806f
R53 52 53 2.224404
C57 54 gnd 2.080806f
R54 53 54 2.224404
C58 55 gnd 2.080806f
R55 54 55 2.224404
C59 56 gnd 2.080806f
R56 55 56 2.224404
C60 57 gnd 2.080806f
R57 56 57 2.224404
C61 58 gnd 2.080806f
R58 57 58 2.224404
C62 59 gnd 2.080806f
R59 58 59 2.224404
C63 60 gnd 2.080806f
R60 59 60 2.224404
C64 61 gnd 2.080806f
R61 60 61 2.224404
C65 62 gnd 2.080806f
R62 61 62 2.224404
C66 63 gnd 2.080806f
R63 62 63 2.224404
C67 64 gnd 2.080806f
R64 63 64 2.224404
C68 65 gnd 2.080806f
R65 64 65 2.224404
C69 66 gnd 2.080806f
R66 65 66 2.224404
C70 67 gnd 2.080806f
R67 66 67 2.224404
C71 68 gnd 2.080806f
R68 67 68 2.224404
C72 69 gnd 2.080806f
R69 68 69 2.224404
C73 70 gnd 2.080806f
R70 69 70 2.224404
C74 71 gnd 2.080806f
R71 70 71 2.224404
C75 72 gnd 2.080806f
R72 71 72 2.224404
C76 73 gnd 2.080806f
R73 72 73 2.224404
C77 74 gnd 2.080806f
R74 73 74 2.224404
C78 75 gnd 2.080806f
R75 74 75 2.224404
C79 76 gnd 2.080806f
R76 75 76 2.224404
C80 77 gnd 2.080806f
R77 76 77 2.224404
C81 78 gnd 2.080806f
R78 77 78 2.224404
C82 79 gnd 2.080806f
R79 78 79 2.224404
C83 80 gnd 2.080806f
R80 79 80 2.224404
C84 81 gnd 2.080806f
R81 80 81 2.224404
C85 82 gnd 2.080806f
R82 81 82 2.224404
C86 83 gnd 2.080806f
R83 82 83 2.224404
C87 84 gnd 2.080806f
R84 83 84 2.224404
C88 85 gnd 2.080806f
R85 84 85 2.224404
C89 86 gnd 2.080806f
R86 85 86 2.224404
C90 87 gnd 2.080806f
R87 86 87 2.224404
C91 88 gnd 2.080806f
R88 87 88 2.224404
C92 89 gnd 2.080806f
R89 89 88 2.224404
C93 90 gnd 2.080806f
R90 90 89 2.224404
C94 91 gnd 2.080806f
R91 90 91 2.224404
C95 92 gnd 2.080806f
R92 92 91 2.224404
C96 93 gnd 2.080806f
R93 92 93 2.224404
C97 94 gnd 2.080806f
R94 93 94 2.224404
C98 95 gnd 2.080806f
R95 94 95 2.224404
C99 96 gnd 2.080806f
R96 95 96 2.224404
C100 97 gnd 2.080806f
R97 97 96 2.224404
C101 98 gnd 2.080806f
R98 98 97 2.224404
C102 99 gnd 2.080806f
R99 99 98 2.224404
C103 100 gnd 2.080806f
R100 100 99 2.224404
C104 101 gnd 2.080806f
R101 101 100 2.224404
C105 102 gnd 2.080806f
R102 101 102 2.224404
C106 103 gnd 2.080806f
R103 102 103 2.224404
C107 104 gnd 2.080806f
R104 104 103 2.224404
C108 105 gnd 2.080806f
R105 104 105 2.224404
C109 106 gnd 2.080806f
R106 105 106 2.224404
C110 107 gnd 2.080806f
R107 106 107 2.224404
C111 108 gnd 2.080806f
R108 108 107 2.224404
C112 109 gnd 2.080806f
R109 109 108 2.224404
C113 110 gnd 2.080806f
R110 109 110 2.224404
C114 111 gnd 2.080806f
R111 110 111 2.224404
C115 112 gnd 2.080806f
R112 111 112 2.224404
C116 113 gnd 2.080806f
R113 112 113 2.224404
C117 114 gnd 2.080806f
R114 113 114 2.224404
C118 115 gnd 2.080806f
R115 114 115 2.224404
C119 116 gnd 2.080806f
R116 115 116 2.224404
C120 117 gnd 2.080806f
R117 116 117 2.224404
R118 117 g15_2 2.224404
C121 118 gnd 2.080806f
R119 98 118 2.224404
C122 119 gnd 2.080806f
R120 118 119 2.224404
C123 120 gnd 2.080806f
R121 119 120 2.224404
C124 121 gnd 2.080806f
R122 120 121 2.224404
C125 122 gnd 2.080806f
R123 121 122 2.224404
C126 123 gnd 2.080806f
R124 122 123 2.224404
C127 124 gnd 2.080806f
R125 123 124 2.224404
C128 125 gnd 2.080806f
R126 124 125 2.224404
C129 126 gnd 2.080806f
R127 125 126 2.224404
C130 127 gnd 2.080806f
R128 126 127 2.224404
C131 128 gnd 2.080806f
R129 127 128 2.224404
C132 129 gnd 2.080806f
R130 128 129 2.224404
C133 130 gnd 2.080806f
R131 130 129 2.224404
C134 131 gnd 2.080806f
R132 130 131 2.224404
C135 132 gnd 2.080806f
R133 131 132 2.224404
C136 133 gnd 2.080806f
R134 132 133 2.224404
C137 134 gnd 2.080806f
R135 133 134 2.224404
C138 135 gnd 2.080806f
R136 134 135 2.224404
C139 136 gnd 2.080806f
R137 135 136 2.224404
C140 137 gnd 2.080806f
R138 136 137 2.224404
C141 138 gnd 2.080806f
R139 137 138 2.224404
C142 139 gnd 2.080806f
R140 139 138 2.224404
C143 140 gnd 2.080806f
R141 140 139 2.224404
C144 141 gnd 2.080806f
R142 141 140 2.224404
C145 142 gnd 2.080806f
R143 141 142 2.224404
C146 143 gnd 2.080806f
R144 143 142 2.224404
C147 144 gnd 2.080806f
R145 144 143 2.224404
R146 g15_1 144 2.224404
.ends

.subckt netg187 g187_2 g187_0 g187_1 gnd
C1  g187_2 gnd 2.080806f
C2  g187_0 gnd 2.080806f
C3  g187_1 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g187_0 2.224404
C5 2 gnd 2.080806f
R2 1 2 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 3 4 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 12 13 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 14 15 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 16 17 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 18 19 2.224404
C23 20 gnd 2.080806f
R20 19 20 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 21 22 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 23 24 2.224404
C28 25 gnd 2.080806f
R25 24 25 2.224404
C29 26 gnd 2.080806f
R26 25 26 2.224404
C30 27 gnd 2.080806f
R27 26 27 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 28 29 2.224404
C33 30 gnd 2.080806f
R30 29 30 2.224404
C34 31 gnd 2.080806f
R31 30 31 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 32 33 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 34 35 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 42 43 2.224404
C47 44 gnd 2.080806f
R44 43 44 2.224404
R45 44 g187_2 2.224404
C48 45 gnd 2.080806f
R46 g187_2 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
C108 105 gnd 2.080806f
R106 104 105 2.224404
C109 106 gnd 2.080806f
R107 105 106 2.224404
C110 107 gnd 2.080806f
R108 106 107 2.224404
C111 108 gnd 2.080806f
R109 107 108 2.224404
R110 108 g187_1 2.224404
.ends

.subckt netg10 g10_1 g10_0 g10_2 gnd
C1  g10_1 gnd 2.080806f
C2  g10_0 gnd 2.080806f
C3  g10_2 gnd 2.080806f
.ends

.subckt netg182 g182_1 g182_0 g182_2 gnd
C1  g182_1 gnd 2.080806f
C2  g182_0 gnd 2.080806f
C3  g182_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g182_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 2 3 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 4 5 2.224404
C9 6 gnd 2.080806f
R6 5 6 2.224404
C10 7 gnd 2.080806f
R7 6 7 2.224404
C11 8 gnd 2.080806f
R8 7 8 2.224404
C12 9 gnd 2.080806f
R9 8 9 2.224404
C13 10 gnd 2.080806f
R10 9 10 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 11 12 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 15 16 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 17 18 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 20 21 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 22 23 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 27 28 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 33 34 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 36 37 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 39 40 2.224404
C44 41 gnd 2.080806f
R41 40 41 2.224404
C45 42 gnd 2.080806f
R42 41 42 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 44 45 2.224404
C49 46 gnd 2.080806f
R46 45 46 2.224404
C50 47 gnd 2.080806f
R47 47 46 2.224404
C51 48 gnd 2.080806f
R48 47 48 2.224404
C52 49 gnd 2.080806f
R49 49 48 2.224404
C53 50 gnd 2.080806f
R50 49 50 2.224404
C54 51 gnd 2.080806f
R51 50 51 2.224404
R52 g182_2 51 2.224404
C55 52 gnd 2.080806f
R53 g182_0 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
C108 105 gnd 2.080806f
R106 104 105 2.224404
C109 106 gnd 2.080806f
R107 105 106 2.224404
C110 107 gnd 2.080806f
R108 106 107 2.224404
C111 108 gnd 2.080806f
R109 107 108 2.224404
C112 109 gnd 2.080806f
R110 108 109 2.224404
C113 110 gnd 2.080806f
R111 109 110 2.224404
C114 111 gnd 2.080806f
R112 110 111 2.224404
C115 112 gnd 2.080806f
R113 111 112 2.224404
C116 113 gnd 2.080806f
R114 112 113 2.224404
C117 114 gnd 2.080806f
R115 113 114 2.224404
C118 115 gnd 2.080806f
R116 114 115 2.224404
C119 116 gnd 2.080806f
R117 115 116 2.224404
C120 117 gnd 2.080806f
R118 116 117 2.224404
C121 118 gnd 2.080806f
R119 117 118 2.224404
C122 119 gnd 2.080806f
R120 118 119 2.224404
C123 120 gnd 2.080806f
R121 119 120 2.224404
C124 121 gnd 2.080806f
R122 120 121 2.224404
C125 122 gnd 2.080806f
R123 121 122 2.224404
C126 123 gnd 2.080806f
R124 122 123 2.224404
C127 124 gnd 2.080806f
R125 123 124 2.224404
R126 124 g182_1 2.224404
.ends

.subckt netg173 g173_2 g173_0 g173_3 g173_1 gnd
C1  g173_2 gnd 2.080806f
C2  g173_0 gnd 2.080806f
C3  g173_3 gnd 2.080806f
C4  g173_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g173_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
C14 10 gnd 2.080806f
R10 10 9 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
C16 12 gnd 2.080806f
R12 12 11 2.224404
C17 13 gnd 2.080806f
R13 13 12 2.224404
C18 14 gnd 2.080806f
R14 14 13 2.224404
C19 15 gnd 2.080806f
R15 15 14 2.224404
C20 16 gnd 2.080806f
R16 16 15 2.224404
C21 17 gnd 2.080806f
R17 17 16 2.224404
C22 18 gnd 2.080806f
R18 18 17 2.224404
C23 19 gnd 2.080806f
R19 19 18 2.224404
C24 20 gnd 2.080806f
R20 20 19 2.224404
C25 21 gnd 2.080806f
R21 21 20 2.224404
C26 22 gnd 2.080806f
R22 22 21 2.224404
C27 23 gnd 2.080806f
R23 23 22 2.224404
C28 24 gnd 2.080806f
R24 24 23 2.224404
C29 25 gnd 2.080806f
R25 25 24 2.224404
C30 26 gnd 2.080806f
R26 26 25 2.224404
C31 27 gnd 2.080806f
R27 27 26 2.224404
C32 28 gnd 2.080806f
R28 28 27 2.224404
C33 29 gnd 2.080806f
R29 29 28 2.224404
C34 30 gnd 2.080806f
R30 30 29 2.224404
C35 31 gnd 2.080806f
R31 31 30 2.224404
C36 32 gnd 2.080806f
R32 32 31 2.224404
C37 33 gnd 2.080806f
R33 33 32 2.224404
C38 34 gnd 2.080806f
R34 34 33 2.224404
C39 35 gnd 2.080806f
R35 35 34 2.224404
C40 36 gnd 2.080806f
R36 36 35 2.224404
C41 37 gnd 2.080806f
R37 37 36 2.224404
C42 38 gnd 2.080806f
R38 38 37 2.224404
C43 39 gnd 2.080806f
R39 39 38 2.224404
C44 40 gnd 2.080806f
R40 40 39 2.224404
C45 41 gnd 2.080806f
R41 41 40 2.224404
C46 42 gnd 2.080806f
R42 42 41 2.224404
C47 43 gnd 2.080806f
R43 43 42 2.224404
C48 44 gnd 2.080806f
R44 44 43 2.224404
C49 45 gnd 2.080806f
R45 45 44 2.224404
C50 46 gnd 2.080806f
R46 46 45 2.224404
C51 47 gnd 2.080806f
R47 47 46 2.224404
C52 48 gnd 2.080806f
R48 48 47 2.224404
C53 49 gnd 2.080806f
R49 49 48 2.224404
C54 50 gnd 2.080806f
R50 50 49 2.224404
C55 51 gnd 2.080806f
R51 51 50 2.224404
C56 52 gnd 2.080806f
R52 52 51 2.224404
C57 53 gnd 2.080806f
R53 53 52 2.224404
C58 54 gnd 2.080806f
R54 54 53 2.224404
C59 55 gnd 2.080806f
R55 55 54 2.224404
C60 56 gnd 2.080806f
R56 56 55 2.224404
C61 57 gnd 2.080806f
R57 57 56 2.224404
C62 58 gnd 2.080806f
R58 58 57 2.224404
C63 59 gnd 2.080806f
R59 59 58 2.224404
C64 60 gnd 2.080806f
R60 60 59 2.224404
C65 61 gnd 2.080806f
R61 61 60 2.224404
C66 62 gnd 2.080806f
R62 62 61 2.224404
C67 63 gnd 2.080806f
R63 63 62 2.224404
C68 64 gnd 2.080806f
R64 64 63 2.224404
C69 65 gnd 2.080806f
R65 65 64 2.224404
C70 66 gnd 2.080806f
R66 66 65 2.224404
C71 67 gnd 2.080806f
R67 67 66 2.224404
C72 68 gnd 2.080806f
R68 68 67 2.224404
C73 69 gnd 2.080806f
R69 69 68 2.224404
C74 70 gnd 2.080806f
R70 70 69 2.224404
C75 71 gnd 2.080806f
R71 71 70 2.224404
C76 72 gnd 2.080806f
R72 72 71 2.224404
C77 73 gnd 2.080806f
R73 73 72 2.224404
C78 74 gnd 2.080806f
R74 74 73 2.224404
C79 75 gnd 2.080806f
R75 75 74 2.224404
C80 76 gnd 2.080806f
R76 76 75 2.224404
C81 77 gnd 2.080806f
R77 77 76 2.224404
C82 78 gnd 2.080806f
R78 78 77 2.224404
R79 g173_1 78 2.224404
C83 79 gnd 2.080806f
R80 79 g173_1 2.224404
C84 80 gnd 2.080806f
R81 80 79 2.224404
C85 81 gnd 2.080806f
R82 81 80 2.224404
C86 82 gnd 2.080806f
R83 82 81 2.224404
C87 83 gnd 2.080806f
R84 82 83 2.224404
C88 84 gnd 2.080806f
R85 84 83 2.224404
C89 85 gnd 2.080806f
R86 85 84 2.224404
C90 86 gnd 2.080806f
R87 86 85 2.224404
C91 87 gnd 2.080806f
R88 87 86 2.224404
C92 88 gnd 2.080806f
R89 88 87 2.224404
C93 89 gnd 2.080806f
R90 89 88 2.224404
C94 90 gnd 2.080806f
R91 90 89 2.224404
C95 91 gnd 2.080806f
R92 91 90 2.224404
C96 92 gnd 2.080806f
R93 92 91 2.224404
C97 93 gnd 2.080806f
R94 93 92 2.224404
C98 94 gnd 2.080806f
R95 94 93 2.224404
C99 95 gnd 2.080806f
R96 95 94 2.224404
C100 96 gnd 2.080806f
R97 96 95 2.224404
C101 97 gnd 2.080806f
R98 97 96 2.224404
C102 98 gnd 2.080806f
R99 98 97 2.224404
C103 99 gnd 2.080806f
R100 99 98 2.224404
C104 100 gnd 2.080806f
R101 100 99 2.224404
C105 101 gnd 2.080806f
R102 100 101 2.224404
C106 102 gnd 2.080806f
R103 102 101 2.224404
C107 103 gnd 2.080806f
R104 103 102 2.224404
C108 104 gnd 2.080806f
R105 104 103 2.224404
C109 105 gnd 2.080806f
R106 105 104 2.224404
C110 106 gnd 2.080806f
R107 106 105 2.224404
C111 107 gnd 2.080806f
R108 107 106 2.224404
C112 108 gnd 2.080806f
R109 108 107 2.224404
C113 109 gnd 2.080806f
R110 109 108 2.224404
C114 110 gnd 2.080806f
R111 109 110 2.224404
R112 g173_3 110 2.224404
C115 111 gnd 2.080806f
R113 103 111 2.224404
C116 112 gnd 2.080806f
R114 111 112 2.224404
C117 113 gnd 2.080806f
R115 112 113 2.224404
C118 114 gnd 2.080806f
R116 113 114 2.224404
C119 115 gnd 2.080806f
R117 114 115 2.224404
C120 116 gnd 2.080806f
R118 115 116 2.224404
C121 117 gnd 2.080806f
R119 116 117 2.224404
C122 118 gnd 2.080806f
R120 117 118 2.224404
C123 119 gnd 2.080806f
R121 118 119 2.224404
C124 120 gnd 2.080806f
R122 119 120 2.224404
C125 121 gnd 2.080806f
R123 120 121 2.224404
C126 122 gnd 2.080806f
R124 121 122 2.224404
C127 123 gnd 2.080806f
R125 122 123 2.224404
C128 124 gnd 2.080806f
R126 123 124 2.224404
C129 125 gnd 2.080806f
R127 124 125 2.224404
C130 126 gnd 2.080806f
R128 125 126 2.224404
C131 127 gnd 2.080806f
R129 126 127 2.224404
C132 128 gnd 2.080806f
R130 127 128 2.224404
R131 128 g173_2 2.224404
.ends

.subckt netg174 g174_2 g174_3 g174_1 g174_0 gnd
C1  g174_2 gnd 2.080806f
C2  g174_3 gnd 2.080806f
C3  g174_1 gnd 2.080806f
C4  g174_0 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g174_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
C14 10 gnd 2.080806f
R10 10 9 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
C16 12 gnd 2.080806f
R12 12 11 2.224404
C17 13 gnd 2.080806f
R13 13 12 2.224404
C18 14 gnd 2.080806f
R14 14 13 2.224404
C19 15 gnd 2.080806f
R15 15 14 2.224404
C20 16 gnd 2.080806f
R16 16 15 2.224404
C21 17 gnd 2.080806f
R17 17 16 2.224404
C22 18 gnd 2.080806f
R18 18 17 2.224404
C23 19 gnd 2.080806f
R19 19 18 2.224404
C24 20 gnd 2.080806f
R20 20 19 2.224404
C25 21 gnd 2.080806f
R21 21 20 2.224404
C26 22 gnd 2.080806f
R22 22 21 2.224404
C27 23 gnd 2.080806f
R23 23 22 2.224404
C28 24 gnd 2.080806f
R24 24 23 2.224404
C29 25 gnd 2.080806f
R25 25 24 2.224404
C30 26 gnd 2.080806f
R26 26 25 2.224404
C31 27 gnd 2.080806f
R27 27 26 2.224404
C32 28 gnd 2.080806f
R28 28 27 2.224404
C33 29 gnd 2.080806f
R29 29 28 2.224404
C34 30 gnd 2.080806f
R30 30 29 2.224404
C35 31 gnd 2.080806f
R31 31 30 2.224404
C36 32 gnd 2.080806f
R32 32 31 2.224404
C37 33 gnd 2.080806f
R33 33 32 2.224404
C38 34 gnd 2.080806f
R34 34 33 2.224404
C39 35 gnd 2.080806f
R35 35 34 2.224404
C40 36 gnd 2.080806f
R36 36 35 2.224404
C41 37 gnd 2.080806f
R37 37 36 2.224404
C42 38 gnd 2.080806f
R38 38 37 2.224404
C43 39 gnd 2.080806f
R39 39 38 2.224404
C44 40 gnd 2.080806f
R40 40 39 2.224404
C45 41 gnd 2.080806f
R41 41 40 2.224404
C46 42 gnd 2.080806f
R42 42 41 2.224404
C47 43 gnd 2.080806f
R43 43 42 2.224404
C48 44 gnd 2.080806f
R44 44 43 2.224404
C49 45 gnd 2.080806f
R45 45 44 2.224404
C50 46 gnd 2.080806f
R46 46 45 2.224404
C51 47 gnd 2.080806f
R47 47 46 2.224404
C52 48 gnd 2.080806f
R48 48 47 2.224404
C53 49 gnd 2.080806f
R49 49 48 2.224404
C54 50 gnd 2.080806f
R50 50 49 2.224404
C55 51 gnd 2.080806f
R51 51 50 2.224404
C56 52 gnd 2.080806f
R52 52 51 2.224404
C57 53 gnd 2.080806f
R53 53 52 2.224404
C58 54 gnd 2.080806f
R54 54 53 2.224404
C59 55 gnd 2.080806f
R55 55 54 2.224404
C60 56 gnd 2.080806f
R56 56 55 2.224404
C61 57 gnd 2.080806f
R57 57 56 2.224404
C62 58 gnd 2.080806f
R58 58 57 2.224404
C63 59 gnd 2.080806f
R59 59 58 2.224404
C64 60 gnd 2.080806f
R60 60 59 2.224404
C65 61 gnd 2.080806f
R61 61 60 2.224404
C66 62 gnd 2.080806f
R62 62 61 2.224404
C67 63 gnd 2.080806f
R63 63 62 2.224404
C68 64 gnd 2.080806f
R64 64 63 2.224404
C69 65 gnd 2.080806f
R65 65 64 2.224404
C70 66 gnd 2.080806f
R66 66 65 2.224404
C71 67 gnd 2.080806f
R67 67 66 2.224404
C72 68 gnd 2.080806f
R68 68 67 2.224404
C73 69 gnd 2.080806f
R69 69 68 2.224404
C74 70 gnd 2.080806f
R70 70 69 2.224404
C75 71 gnd 2.080806f
R71 71 70 2.224404
C76 72 gnd 2.080806f
R72 72 71 2.224404
C77 73 gnd 2.080806f
R73 73 72 2.224404
R74 g174_3 73 2.224404
C78 74 gnd 2.080806f
R75 74 73 2.224404
C79 75 gnd 2.080806f
R76 75 74 2.224404
C80 76 gnd 2.080806f
R77 76 75 2.224404
C81 77 gnd 2.080806f
R78 77 76 2.224404
C82 78 gnd 2.080806f
R79 78 77 2.224404
C83 79 gnd 2.080806f
R80 79 78 2.224404
C84 80 gnd 2.080806f
R81 80 79 2.224404
C85 81 gnd 2.080806f
R82 81 80 2.224404
C86 82 gnd 2.080806f
R83 82 81 2.224404
C87 83 gnd 2.080806f
R84 83 82 2.224404
C88 84 gnd 2.080806f
R85 84 83 2.224404
C89 85 gnd 2.080806f
R86 85 84 2.224404
C90 86 gnd 2.080806f
R87 86 85 2.224404
C91 87 gnd 2.080806f
R88 87 86 2.224404
C92 88 gnd 2.080806f
R89 88 87 2.224404
C93 89 gnd 2.080806f
R90 89 88 2.224404
C94 90 gnd 2.080806f
R91 90 89 2.224404
C95 91 gnd 2.080806f
R92 91 90 2.224404
C96 92 gnd 2.080806f
R93 92 91 2.224404
C97 93 gnd 2.080806f
R94 93 92 2.224404
C98 94 gnd 2.080806f
R95 94 93 2.224404
C99 95 gnd 2.080806f
R96 95 94 2.224404
C100 96 gnd 2.080806f
R97 96 95 2.224404
C101 97 gnd 2.080806f
R98 97 96 2.224404
C102 98 gnd 2.080806f
R99 98 97 2.224404
C103 99 gnd 2.080806f
R100 99 98 2.224404
C104 100 gnd 2.080806f
R101 100 99 2.224404
C105 101 gnd 2.080806f
R102 101 100 2.224404
C106 102 gnd 2.080806f
R103 102 101 2.224404
C107 103 gnd 2.080806f
R104 103 102 2.224404
C108 104 gnd 2.080806f
R105 104 103 2.224404
C109 105 gnd 2.080806f
R106 105 104 2.224404
R107 g174_2 105 2.224404
C110 106 gnd 2.080806f
R108 102 106 2.224404
C111 107 gnd 2.080806f
R109 106 107 2.224404
C112 108 gnd 2.080806f
R110 107 108 2.224404
C113 109 gnd 2.080806f
R111 108 109 2.224404
C114 110 gnd 2.080806f
R112 109 110 2.224404
C115 111 gnd 2.080806f
R113 110 111 2.224404
C116 112 gnd 2.080806f
R114 111 112 2.224404
C117 113 gnd 2.080806f
R115 112 113 2.224404
C118 114 gnd 2.080806f
R116 113 114 2.224404
C119 115 gnd 2.080806f
R117 114 115 2.224404
C120 116 gnd 2.080806f
R118 115 116 2.224404
C121 117 gnd 2.080806f
R119 116 117 2.224404
C122 118 gnd 2.080806f
R120 117 118 2.224404
C123 119 gnd 2.080806f
R121 118 119 2.224404
C124 120 gnd 2.080806f
R122 119 120 2.224404
C125 121 gnd 2.080806f
R123 120 121 2.224404
C126 122 gnd 2.080806f
R124 121 122 2.224404
C127 123 gnd 2.080806f
R125 122 123 2.224404
C128 124 gnd 2.080806f
R126 123 124 2.224404
C129 125 gnd 2.080806f
R127 124 125 2.224404
R128 125 g174_1 2.224404
.ends

.subckt netg388 g388_2 g388_1 g388_0 gnd
C1  g388_2 gnd 2.080806f
C2  g388_1 gnd 2.080806f
C3  g388_0 gnd 2.080806f
R1 g388_2 g388_0 2.224404
C4 1 gnd 2.080806f
R2 g388_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 3 2 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 5 4 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 7 6 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 9 8 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 18 17 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 20 19 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 22 21 2.224404
C26 23 gnd 2.080806f
R24 23 22 2.224404
C27 24 gnd 2.080806f
R25 24 23 2.224404
C28 25 gnd 2.080806f
R26 25 24 2.224404
C29 26 gnd 2.080806f
R27 26 25 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 31 30 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 37 36 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 42 41 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 45 44 2.224404
C49 46 gnd 2.080806f
R47 46 45 2.224404
C50 47 gnd 2.080806f
R48 47 46 2.224404
C51 48 gnd 2.080806f
R49 48 47 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 53 52 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 55 54 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 62 61 2.224404
C66 63 gnd 2.080806f
R64 63 62 2.224404
C67 64 gnd 2.080806f
R65 64 63 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 74 73 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 83 82 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 87 86 2.224404
C91 88 gnd 2.080806f
R89 88 87 2.224404
C92 89 gnd 2.080806f
R90 89 88 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 93 92 2.224404
C97 94 gnd 2.080806f
R95 94 93 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 96 95 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 101 100 2.224404
C105 102 gnd 2.080806f
R103 102 101 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
C108 105 gnd 2.080806f
R106 105 104 2.224404
C109 106 gnd 2.080806f
R107 106 105 2.224404
C110 107 gnd 2.080806f
R108 107 106 2.224404
C111 108 gnd 2.080806f
R109 108 107 2.224404
C112 109 gnd 2.080806f
R110 109 108 2.224404
C113 110 gnd 2.080806f
R111 109 110 2.224404
C114 111 gnd 2.080806f
R112 110 111 2.224404
C115 112 gnd 2.080806f
R113 111 112 2.224404
C116 113 gnd 2.080806f
R114 112 113 2.224404
C117 114 gnd 2.080806f
R115 113 114 2.224404
C118 115 gnd 2.080806f
R116 114 115 2.224404
R117 115 g388_1 2.224404
.ends

.subckt netg181 g181_0 g181_2 g181_1 g181_3 gnd
C1  g181_0 gnd 2.080806f
C2  g181_2 gnd 2.080806f
C3  g181_1 gnd 2.080806f
C4  g181_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 g181_0 1 2.224404
C6 2 gnd 2.080806f
R2 1 2 2.224404
C7 3 gnd 2.080806f
R3 2 3 2.224404
C8 4 gnd 2.080806f
R4 3 4 2.224404
C9 5 gnd 2.080806f
R5 4 5 2.224404
C10 6 gnd 2.080806f
R6 5 6 2.224404
C11 7 gnd 2.080806f
R7 6 7 2.224404
C12 8 gnd 2.080806f
R8 7 8 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
C14 10 gnd 2.080806f
R10 10 9 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
C16 12 gnd 2.080806f
R12 12 11 2.224404
C17 13 gnd 2.080806f
R13 13 12 2.224404
C18 14 gnd 2.080806f
R14 14 13 2.224404
C19 15 gnd 2.080806f
R15 15 14 2.224404
C20 16 gnd 2.080806f
R16 16 15 2.224404
C21 17 gnd 2.080806f
R17 17 16 2.224404
C22 18 gnd 2.080806f
R18 18 17 2.224404
C23 19 gnd 2.080806f
R19 19 18 2.224404
C24 20 gnd 2.080806f
R20 19 20 2.224404
C25 21 gnd 2.080806f
R21 21 20 2.224404
C26 22 gnd 2.080806f
R22 22 21 2.224404
C27 23 gnd 2.080806f
R23 23 22 2.224404
C28 24 gnd 2.080806f
R24 24 23 2.224404
C29 25 gnd 2.080806f
R25 25 24 2.224404
C30 26 gnd 2.080806f
R26 26 25 2.224404
C31 27 gnd 2.080806f
R27 27 26 2.224404
C32 28 gnd 2.080806f
R28 28 27 2.224404
C33 29 gnd 2.080806f
R29 29 28 2.224404
C34 30 gnd 2.080806f
R30 30 29 2.224404
C35 31 gnd 2.080806f
R31 31 30 2.224404
C36 32 gnd 2.080806f
R32 32 31 2.224404
C37 33 gnd 2.080806f
R33 33 32 2.224404
C38 34 gnd 2.080806f
R34 34 33 2.224404
C39 35 gnd 2.080806f
R35 35 34 2.224404
C40 36 gnd 2.080806f
R36 36 35 2.224404
C41 37 gnd 2.080806f
R37 37 36 2.224404
C42 38 gnd 2.080806f
R38 38 37 2.224404
C43 39 gnd 2.080806f
R39 39 38 2.224404
C44 40 gnd 2.080806f
R40 40 39 2.224404
C45 41 gnd 2.080806f
R41 41 40 2.224404
C46 42 gnd 2.080806f
R42 42 41 2.224404
C47 43 gnd 2.080806f
R43 43 42 2.224404
C48 44 gnd 2.080806f
R44 44 43 2.224404
C49 45 gnd 2.080806f
R45 45 44 2.224404
C50 46 gnd 2.080806f
R46 46 45 2.224404
C51 47 gnd 2.080806f
R47 47 46 2.224404
C52 48 gnd 2.080806f
R48 48 47 2.224404
C53 49 gnd 2.080806f
R49 48 49 2.224404
C54 50 gnd 2.080806f
R50 50 49 2.224404
C55 51 gnd 2.080806f
R51 51 50 2.224404
R52 g181_1 51 2.224404
C56 52 gnd 2.080806f
R53 g181_1 52 2.224404
C57 53 gnd 2.080806f
R54 52 53 2.224404
C58 54 gnd 2.080806f
R55 53 54 2.224404
C59 55 gnd 2.080806f
R56 54 55 2.224404
C60 56 gnd 2.080806f
R57 55 56 2.224404
C61 57 gnd 2.080806f
R58 56 57 2.224404
C62 58 gnd 2.080806f
R59 57 58 2.224404
C63 59 gnd 2.080806f
R60 59 58 2.224404
C64 60 gnd 2.080806f
R61 59 60 2.224404
C65 61 gnd 2.080806f
R62 60 61 2.224404
C66 62 gnd 2.080806f
R63 61 62 2.224404
C67 63 gnd 2.080806f
R64 62 63 2.224404
C68 64 gnd 2.080806f
R65 63 64 2.224404
C69 65 gnd 2.080806f
R66 64 65 2.224404
C70 66 gnd 2.080806f
R67 65 66 2.224404
C71 67 gnd 2.080806f
R68 66 67 2.224404
C72 68 gnd 2.080806f
R69 67 68 2.224404
C73 69 gnd 2.080806f
R70 68 69 2.224404
C74 70 gnd 2.080806f
R71 69 70 2.224404
C75 71 gnd 2.080806f
R72 70 71 2.224404
C76 72 gnd 2.080806f
R73 72 71 2.224404
C77 73 gnd 2.080806f
R74 72 73 2.224404
C78 74 gnd 2.080806f
R75 73 74 2.224404
C79 75 gnd 2.080806f
R76 74 75 2.224404
C80 76 gnd 2.080806f
R77 75 76 2.224404
C81 77 gnd 2.080806f
R78 76 77 2.224404
C82 78 gnd 2.080806f
R79 77 78 2.224404
C83 79 gnd 2.080806f
R80 78 79 2.224404
C84 80 gnd 2.080806f
R81 80 79 2.224404
C85 81 gnd 2.080806f
R82 80 81 2.224404
C86 82 gnd 2.080806f
R83 81 82 2.224404
C87 83 gnd 2.080806f
R84 82 83 2.224404
C88 84 gnd 2.080806f
R85 84 83 2.224404
C89 85 gnd 2.080806f
R86 84 85 2.224404
C90 86 gnd 2.080806f
R87 85 86 2.224404
C91 87 gnd 2.080806f
R88 86 87 2.224404
R89 87 g181_2 2.224404
C92 88 gnd 2.080806f
R90 g181_2 88 2.224404
C93 89 gnd 2.080806f
R91 88 89 2.224404
C94 90 gnd 2.080806f
R92 89 90 2.224404
C95 91 gnd 2.080806f
R93 90 91 2.224404
C96 92 gnd 2.080806f
R94 91 92 2.224404
C97 93 gnd 2.080806f
R95 92 93 2.224404
C98 94 gnd 2.080806f
R96 93 94 2.224404
C99 95 gnd 2.080806f
R97 94 95 2.224404
C100 96 gnd 2.080806f
R98 95 96 2.224404
C101 97 gnd 2.080806f
R99 96 97 2.224404
C102 98 gnd 2.080806f
R100 97 98 2.224404
C103 99 gnd 2.080806f
R101 98 99 2.224404
C104 100 gnd 2.080806f
R102 99 100 2.224404
C105 101 gnd 2.080806f
R103 100 101 2.224404
C106 102 gnd 2.080806f
R104 101 102 2.224404
C107 103 gnd 2.080806f
R105 102 103 2.224404
C108 104 gnd 2.080806f
R106 103 104 2.224404
C109 105 gnd 2.080806f
R107 104 105 2.224404
C110 106 gnd 2.080806f
R108 105 106 2.224404
C111 107 gnd 2.080806f
R109 106 107 2.224404
C112 108 gnd 2.080806f
R110 107 108 2.224404
C113 109 gnd 2.080806f
R111 108 109 2.224404
C114 110 gnd 2.080806f
R112 109 110 2.224404
C115 111 gnd 2.080806f
R113 110 111 2.224404
C116 112 gnd 2.080806f
R114 111 112 2.224404
C117 113 gnd 2.080806f
R115 112 113 2.224404
C118 114 gnd 2.080806f
R116 113 114 2.224404
C119 115 gnd 2.080806f
R117 114 115 2.224404
C120 116 gnd 2.080806f
R118 115 116 2.224404
C121 117 gnd 2.080806f
R119 116 117 2.224404
C122 118 gnd 2.080806f
R120 117 118 2.224404
C123 119 gnd 2.080806f
R121 118 119 2.224404
C124 120 gnd 2.080806f
R122 119 120 2.224404
C125 121 gnd 2.080806f
R123 120 121 2.224404
C126 122 gnd 2.080806f
R124 121 122 2.224404
C127 123 gnd 2.080806f
R125 122 123 2.224404
C128 124 gnd 2.080806f
R126 123 124 2.224404
C129 125 gnd 2.080806f
R127 124 125 2.224404
C130 126 gnd 2.080806f
R128 125 126 2.224404
C131 127 gnd 2.080806f
R129 126 127 2.224404
C132 128 gnd 2.080806f
R130 127 128 2.224404
C133 129 gnd 2.080806f
R131 128 129 2.224404
C134 130 gnd 2.080806f
R132 129 130 2.224404
C135 131 gnd 2.080806f
R133 130 131 2.224404
C136 132 gnd 2.080806f
R134 131 132 2.224404
C137 133 gnd 2.080806f
R135 132 133 2.224404
C138 134 gnd 2.080806f
R136 133 134 2.224404
C139 135 gnd 2.080806f
R137 134 135 2.224404
C140 136 gnd 2.080806f
R138 135 136 2.224404
C141 137 gnd 2.080806f
R139 136 137 2.224404
C142 138 gnd 2.080806f
R140 137 138 2.224404
C143 139 gnd 2.080806f
R141 138 139 2.224404
C144 140 gnd 2.080806f
R142 139 140 2.224404
C145 141 gnd 2.080806f
R143 140 141 2.224404
C146 142 gnd 2.080806f
R144 141 142 2.224404
C147 143 gnd 2.080806f
R145 142 143 2.224404
C148 144 gnd 2.080806f
R146 143 144 2.224404
C149 145 gnd 2.080806f
R147 144 145 2.224404
C150 146 gnd 2.080806f
R148 145 146 2.224404
C151 147 gnd 2.080806f
R149 146 147 2.224404
C152 148 gnd 2.080806f
R150 147 148 2.224404
C153 149 gnd 2.080806f
R151 148 149 2.224404
C154 150 gnd 2.080806f
R152 149 150 2.224404
C155 151 gnd 2.080806f
R153 150 151 2.224404
C156 152 gnd 2.080806f
R154 151 152 2.224404
C157 153 gnd 2.080806f
R155 152 153 2.224404
C158 154 gnd 2.080806f
R156 153 154 2.224404
C159 155 gnd 2.080806f
R157 154 155 2.224404
C160 156 gnd 2.080806f
R158 155 156 2.224404
C161 157 gnd 2.080806f
R159 156 157 2.224404
C162 158 gnd 2.080806f
R160 157 158 2.224404
R161 158 g181_3 2.224404
.ends

.subckt netg87 g87_0 g87_1 gnd
C1  g87_0 gnd 2.080806f
C2  g87_1 gnd 2.080806f
C3 1 gnd 2.080806f
R1 g87_0 1 2.224404
C4 2 gnd 2.080806f
R2 1 2 2.224404
C5 3 gnd 2.080806f
R3 2 3 2.224404
C6 4 gnd 2.080806f
R4 3 4 2.224404
C7 5 gnd 2.080806f
R5 4 5 2.224404
C8 6 gnd 2.080806f
R6 5 6 2.224404
C9 7 gnd 2.080806f
R7 6 7 2.224404
C10 8 gnd 2.080806f
R8 7 8 2.224404
C11 9 gnd 2.080806f
R9 8 9 2.224404
C12 10 gnd 2.080806f
R10 9 10 2.224404
C13 11 gnd 2.080806f
R11 10 11 2.224404
C14 12 gnd 2.080806f
R12 11 12 2.224404
C15 13 gnd 2.080806f
R13 12 13 2.224404
C16 14 gnd 2.080806f
R14 13 14 2.224404
C17 15 gnd 2.080806f
R15 14 15 2.224404
C18 16 gnd 2.080806f
R16 15 16 2.224404
C19 17 gnd 2.080806f
R17 16 17 2.224404
C20 18 gnd 2.080806f
R18 17 18 2.224404
C21 19 gnd 2.080806f
R19 18 19 2.224404
C22 20 gnd 2.080806f
R20 19 20 2.224404
C23 21 gnd 2.080806f
R21 20 21 2.224404
C24 22 gnd 2.080806f
R22 21 22 2.224404
C25 23 gnd 2.080806f
R23 22 23 2.224404
C26 24 gnd 2.080806f
R24 23 24 2.224404
C27 25 gnd 2.080806f
R25 24 25 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 30 31 2.224404
C34 32 gnd 2.080806f
R32 31 32 2.224404
C35 33 gnd 2.080806f
R33 32 33 2.224404
C36 34 gnd 2.080806f
R34 33 34 2.224404
C37 35 gnd 2.080806f
R35 34 35 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 37 38 2.224404
C41 39 gnd 2.080806f
R39 38 39 2.224404
C42 40 gnd 2.080806f
R40 39 40 2.224404
C43 41 gnd 2.080806f
R41 40 41 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 42 43 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
C79 77 gnd 2.080806f
R77 77 76 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
C81 79 gnd 2.080806f
R79 79 78 2.224404
C82 80 gnd 2.080806f
R80 80 79 2.224404
C83 81 gnd 2.080806f
R81 81 80 2.224404
C84 82 gnd 2.080806f
R82 82 81 2.224404
C85 83 gnd 2.080806f
R83 83 82 2.224404
C86 84 gnd 2.080806f
R84 84 83 2.224404
C87 85 gnd 2.080806f
R85 85 84 2.224404
C88 86 gnd 2.080806f
R86 86 85 2.224404
C89 87 gnd 2.080806f
R87 87 86 2.224404
C90 88 gnd 2.080806f
R88 88 87 2.224404
C91 89 gnd 2.080806f
R89 89 88 2.224404
C92 90 gnd 2.080806f
R90 90 89 2.224404
C93 91 gnd 2.080806f
R91 91 90 2.224404
C94 92 gnd 2.080806f
R92 92 91 2.224404
C95 93 gnd 2.080806f
R93 93 92 2.224404
C96 94 gnd 2.080806f
R94 94 93 2.224404
C97 95 gnd 2.080806f
R95 95 94 2.224404
C98 96 gnd 2.080806f
R96 96 95 2.224404
C99 97 gnd 2.080806f
R97 97 96 2.224404
C100 98 gnd 2.080806f
R98 98 97 2.224404
C101 99 gnd 2.080806f
R99 99 98 2.224404
C102 100 gnd 2.080806f
R100 100 99 2.224404
C103 101 gnd 2.080806f
R101 101 100 2.224404
C104 102 gnd 2.080806f
R102 102 101 2.224404
C105 103 gnd 2.080806f
R103 103 102 2.224404
C106 104 gnd 2.080806f
R104 104 103 2.224404
C107 105 gnd 2.080806f
R105 105 104 2.224404
C108 106 gnd 2.080806f
R106 106 105 2.224404
C109 107 gnd 2.080806f
R107 107 106 2.224404
C110 108 gnd 2.080806f
R108 108 107 2.224404
C111 109 gnd 2.080806f
R109 109 108 2.224404
C112 110 gnd 2.080806f
R110 109 110 2.224404
C113 111 gnd 2.080806f
R111 111 110 2.224404
C114 112 gnd 2.080806f
R112 112 111 2.224404
C115 113 gnd 2.080806f
R113 113 112 2.224404
C116 114 gnd 2.080806f
R114 114 113 2.224404
C117 115 gnd 2.080806f
R115 114 115 2.224404
C118 116 gnd 2.080806f
R116 116 115 2.224404
C119 117 gnd 2.080806f
R117 117 116 2.224404
C120 118 gnd 2.080806f
R118 118 117 2.224404
C121 119 gnd 2.080806f
R119 119 118 2.224404
C122 120 gnd 2.080806f
R120 120 119 2.224404
C123 121 gnd 2.080806f
R121 121 120 2.224404
C124 122 gnd 2.080806f
R122 122 121 2.224404
C125 123 gnd 2.080806f
R123 123 122 2.224404
C126 124 gnd 2.080806f
R124 123 124 2.224404
R125 g87_1 124 2.224404
.ends

.subckt netg166 g166_0 g166_2 g166_1 gnd
C1  g166_0 gnd 2.080806f
C2  g166_2 gnd 2.080806f
C3  g166_1 gnd 2.080806f
R1 g166_1 g166_0 2.224404
C4 1 gnd 2.080806f
R2 g166_0 1 2.224404
C5 2 gnd 2.080806f
R3 1 2 2.224404
C6 3 gnd 2.080806f
R4 2 3 2.224404
C7 4 gnd 2.080806f
R5 3 4 2.224404
C8 5 gnd 2.080806f
R6 4 5 2.224404
C9 6 gnd 2.080806f
R7 5 6 2.224404
C10 7 gnd 2.080806f
R8 6 7 2.224404
C11 8 gnd 2.080806f
R9 7 8 2.224404
C12 9 gnd 2.080806f
R10 8 9 2.224404
C13 10 gnd 2.080806f
R11 9 10 2.224404
C14 11 gnd 2.080806f
R12 10 11 2.224404
C15 12 gnd 2.080806f
R13 11 12 2.224404
C16 13 gnd 2.080806f
R14 12 13 2.224404
C17 14 gnd 2.080806f
R15 13 14 2.224404
C18 15 gnd 2.080806f
R16 14 15 2.224404
C19 16 gnd 2.080806f
R17 15 16 2.224404
C20 17 gnd 2.080806f
R18 16 17 2.224404
C21 18 gnd 2.080806f
R19 17 18 2.224404
C22 19 gnd 2.080806f
R20 18 19 2.224404
C23 20 gnd 2.080806f
R21 19 20 2.224404
C24 21 gnd 2.080806f
R22 20 21 2.224404
C25 22 gnd 2.080806f
R23 21 22 2.224404
C26 23 gnd 2.080806f
R24 22 23 2.224404
C27 24 gnd 2.080806f
R25 23 24 2.224404
C28 25 gnd 2.080806f
R26 24 25 2.224404
C29 26 gnd 2.080806f
R27 25 26 2.224404
C30 27 gnd 2.080806f
R28 26 27 2.224404
C31 28 gnd 2.080806f
R29 27 28 2.224404
C32 29 gnd 2.080806f
R30 28 29 2.224404
C33 30 gnd 2.080806f
R31 29 30 2.224404
C34 31 gnd 2.080806f
R32 30 31 2.224404
C35 32 gnd 2.080806f
R33 31 32 2.224404
C36 33 gnd 2.080806f
R34 32 33 2.224404
C37 34 gnd 2.080806f
R35 33 34 2.224404
C38 35 gnd 2.080806f
R36 34 35 2.224404
C39 36 gnd 2.080806f
R37 35 36 2.224404
C40 37 gnd 2.080806f
R38 36 37 2.224404
C41 38 gnd 2.080806f
R39 37 38 2.224404
C42 39 gnd 2.080806f
R40 38 39 2.224404
C43 40 gnd 2.080806f
R41 39 40 2.224404
C44 41 gnd 2.080806f
R42 40 41 2.224404
C45 42 gnd 2.080806f
R43 41 42 2.224404
C46 43 gnd 2.080806f
R44 42 43 2.224404
C47 44 gnd 2.080806f
R45 43 44 2.224404
C48 45 gnd 2.080806f
R46 44 45 2.224404
C49 46 gnd 2.080806f
R47 45 46 2.224404
C50 47 gnd 2.080806f
R48 46 47 2.224404
C51 48 gnd 2.080806f
R49 47 48 2.224404
C52 49 gnd 2.080806f
R50 48 49 2.224404
C53 50 gnd 2.080806f
R51 49 50 2.224404
C54 51 gnd 2.080806f
R52 50 51 2.224404
C55 52 gnd 2.080806f
R53 51 52 2.224404
C56 53 gnd 2.080806f
R54 52 53 2.224404
C57 54 gnd 2.080806f
R55 53 54 2.224404
C58 55 gnd 2.080806f
R56 54 55 2.224404
C59 56 gnd 2.080806f
R57 55 56 2.224404
C60 57 gnd 2.080806f
R58 56 57 2.224404
C61 58 gnd 2.080806f
R59 57 58 2.224404
C62 59 gnd 2.080806f
R60 58 59 2.224404
C63 60 gnd 2.080806f
R61 59 60 2.224404
C64 61 gnd 2.080806f
R62 60 61 2.224404
C65 62 gnd 2.080806f
R63 61 62 2.224404
C66 63 gnd 2.080806f
R64 62 63 2.224404
C67 64 gnd 2.080806f
R65 63 64 2.224404
C68 65 gnd 2.080806f
R66 64 65 2.224404
C69 66 gnd 2.080806f
R67 65 66 2.224404
C70 67 gnd 2.080806f
R68 66 67 2.224404
C71 68 gnd 2.080806f
R69 67 68 2.224404
C72 69 gnd 2.080806f
R70 68 69 2.224404
C73 70 gnd 2.080806f
R71 69 70 2.224404
C74 71 gnd 2.080806f
R72 70 71 2.224404
C75 72 gnd 2.080806f
R73 71 72 2.224404
C76 73 gnd 2.080806f
R74 72 73 2.224404
C77 74 gnd 2.080806f
R75 73 74 2.224404
C78 75 gnd 2.080806f
R76 74 75 2.224404
C79 76 gnd 2.080806f
R77 75 76 2.224404
C80 77 gnd 2.080806f
R78 76 77 2.224404
C81 78 gnd 2.080806f
R79 77 78 2.224404
C82 79 gnd 2.080806f
R80 78 79 2.224404
C83 80 gnd 2.080806f
R81 79 80 2.224404
C84 81 gnd 2.080806f
R82 80 81 2.224404
C85 82 gnd 2.080806f
R83 81 82 2.224404
C86 83 gnd 2.080806f
R84 82 83 2.224404
C87 84 gnd 2.080806f
R85 83 84 2.224404
C88 85 gnd 2.080806f
R86 84 85 2.224404
C89 86 gnd 2.080806f
R87 85 86 2.224404
C90 87 gnd 2.080806f
R88 86 87 2.224404
C91 88 gnd 2.080806f
R89 87 88 2.224404
C92 89 gnd 2.080806f
R90 88 89 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 90 91 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 92 93 2.224404
C97 94 gnd 2.080806f
R95 93 94 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 95 96 2.224404
C100 97 gnd 2.080806f
R98 96 97 2.224404
C101 98 gnd 2.080806f
R99 97 98 2.224404
C102 99 gnd 2.080806f
R100 98 99 2.224404
C103 100 gnd 2.080806f
R101 99 100 2.224404
C104 101 gnd 2.080806f
R102 100 101 2.224404
C105 102 gnd 2.080806f
R103 101 102 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 103 104 2.224404
C108 105 gnd 2.080806f
R106 104 105 2.224404
C109 106 gnd 2.080806f
R107 105 106 2.224404
C110 107 gnd 2.080806f
R108 106 107 2.224404
C111 108 gnd 2.080806f
R109 107 108 2.224404
C112 109 gnd 2.080806f
R110 108 109 2.224404
C113 110 gnd 2.080806f
R111 109 110 2.224404
C114 111 gnd 2.080806f
R112 110 111 2.224404
C115 112 gnd 2.080806f
R113 111 112 2.224404
C116 113 gnd 2.080806f
R114 112 113 2.224404
C117 114 gnd 2.080806f
R115 113 114 2.224404
C118 115 gnd 2.080806f
R116 114 115 2.224404
C119 116 gnd 2.080806f
R117 115 116 2.224404
C120 117 gnd 2.080806f
R118 116 117 2.224404
R119 117 g166_2 2.224404
.ends

.subckt netg180 g180_0 g180_1 g180_2 gnd
C1  g180_0 gnd 2.080806f
C2  g180_1 gnd 2.080806f
C3  g180_2 gnd 2.080806f
C4 1 gnd 2.080806f
R1 1 g180_0 2.224404
C5 2 gnd 2.080806f
R2 2 1 2.224404
C6 3 gnd 2.080806f
R3 3 2 2.224404
C7 4 gnd 2.080806f
R4 4 3 2.224404
C8 5 gnd 2.080806f
R5 5 4 2.224404
C9 6 gnd 2.080806f
R6 6 5 2.224404
C10 7 gnd 2.080806f
R7 7 6 2.224404
C11 8 gnd 2.080806f
R8 8 7 2.224404
C12 9 gnd 2.080806f
R9 9 8 2.224404
C13 10 gnd 2.080806f
R10 10 9 2.224404
C14 11 gnd 2.080806f
R11 11 10 2.224404
C15 12 gnd 2.080806f
R12 12 11 2.224404
C16 13 gnd 2.080806f
R13 13 12 2.224404
C17 14 gnd 2.080806f
R14 14 13 2.224404
C18 15 gnd 2.080806f
R15 15 14 2.224404
C19 16 gnd 2.080806f
R16 16 15 2.224404
C20 17 gnd 2.080806f
R17 17 16 2.224404
C21 18 gnd 2.080806f
R18 18 17 2.224404
C22 19 gnd 2.080806f
R19 19 18 2.224404
C23 20 gnd 2.080806f
R20 20 19 2.224404
C24 21 gnd 2.080806f
R21 21 20 2.224404
C25 22 gnd 2.080806f
R22 22 21 2.224404
C26 23 gnd 2.080806f
R23 23 22 2.224404
C27 24 gnd 2.080806f
R24 24 23 2.224404
C28 25 gnd 2.080806f
R25 25 24 2.224404
C29 26 gnd 2.080806f
R26 26 25 2.224404
C30 27 gnd 2.080806f
R27 27 26 2.224404
C31 28 gnd 2.080806f
R28 28 27 2.224404
C32 29 gnd 2.080806f
R29 29 28 2.224404
C33 30 gnd 2.080806f
R30 30 29 2.224404
C34 31 gnd 2.080806f
R31 31 30 2.224404
C35 32 gnd 2.080806f
R32 32 31 2.224404
C36 33 gnd 2.080806f
R33 33 32 2.224404
C37 34 gnd 2.080806f
R34 34 33 2.224404
C38 35 gnd 2.080806f
R35 35 34 2.224404
C39 36 gnd 2.080806f
R36 36 35 2.224404
C40 37 gnd 2.080806f
R37 37 36 2.224404
C41 38 gnd 2.080806f
R38 38 37 2.224404
C42 39 gnd 2.080806f
R39 39 38 2.224404
C43 40 gnd 2.080806f
R40 40 39 2.224404
C44 41 gnd 2.080806f
R41 41 40 2.224404
C45 42 gnd 2.080806f
R42 42 41 2.224404
C46 43 gnd 2.080806f
R43 43 42 2.224404
C47 44 gnd 2.080806f
R44 44 43 2.224404
C48 45 gnd 2.080806f
R45 45 44 2.224404
C49 46 gnd 2.080806f
R46 46 45 2.224404
C50 47 gnd 2.080806f
R47 47 46 2.224404
C51 48 gnd 2.080806f
R48 48 47 2.224404
C52 49 gnd 2.080806f
R49 49 48 2.224404
C53 50 gnd 2.080806f
R50 50 49 2.224404
C54 51 gnd 2.080806f
R51 51 50 2.224404
C55 52 gnd 2.080806f
R52 52 51 2.224404
C56 53 gnd 2.080806f
R53 53 52 2.224404
C57 54 gnd 2.080806f
R54 54 53 2.224404
C58 55 gnd 2.080806f
R55 55 54 2.224404
C59 56 gnd 2.080806f
R56 56 55 2.224404
C60 57 gnd 2.080806f
R57 57 56 2.224404
C61 58 gnd 2.080806f
R58 58 57 2.224404
C62 59 gnd 2.080806f
R59 59 58 2.224404
C63 60 gnd 2.080806f
R60 60 59 2.224404
C64 61 gnd 2.080806f
R61 61 60 2.224404
C65 62 gnd 2.080806f
R62 62 61 2.224404
C66 63 gnd 2.080806f
R63 63 62 2.224404
C67 64 gnd 2.080806f
R64 64 63 2.224404
C68 65 gnd 2.080806f
R65 65 64 2.224404
C69 66 gnd 2.080806f
R66 66 65 2.224404
C70 67 gnd 2.080806f
R67 67 66 2.224404
C71 68 gnd 2.080806f
R68 68 67 2.224404
C72 69 gnd 2.080806f
R69 68 69 2.224404
C73 70 gnd 2.080806f
R70 70 69 2.224404
C74 71 gnd 2.080806f
R71 71 70 2.224404
C75 72 gnd 2.080806f
R72 71 72 2.224404
C76 73 gnd 2.080806f
R73 72 73 2.224404
C77 74 gnd 2.080806f
R74 74 73 2.224404
C78 75 gnd 2.080806f
R75 75 74 2.224404
C79 76 gnd 2.080806f
R76 76 75 2.224404
C80 77 gnd 2.080806f
R77 77 76 2.224404
C81 78 gnd 2.080806f
R78 78 77 2.224404
C82 79 gnd 2.080806f
R79 79 78 2.224404
C83 80 gnd 2.080806f
R80 80 79 2.224404
C84 81 gnd 2.080806f
R81 81 80 2.224404
C85 82 gnd 2.080806f
R82 82 81 2.224404
C86 83 gnd 2.080806f
R83 83 82 2.224404
C87 84 gnd 2.080806f
R84 84 83 2.224404
C88 85 gnd 2.080806f
R85 85 84 2.224404
R86 g180_1 85 2.224404
C89 86 gnd 2.080806f
R87 86 85 2.224404
C90 87 gnd 2.080806f
R88 87 86 2.224404
C91 88 gnd 2.080806f
R89 88 87 2.224404
C92 89 gnd 2.080806f
R90 89 88 2.224404
C93 90 gnd 2.080806f
R91 89 90 2.224404
C94 91 gnd 2.080806f
R92 91 90 2.224404
C95 92 gnd 2.080806f
R93 91 92 2.224404
C96 93 gnd 2.080806f
R94 93 92 2.224404
C97 94 gnd 2.080806f
R95 94 93 2.224404
C98 95 gnd 2.080806f
R96 94 95 2.224404
C99 96 gnd 2.080806f
R97 96 95 2.224404
C100 97 gnd 2.080806f
R98 97 96 2.224404
C101 98 gnd 2.080806f
R99 98 97 2.224404
C102 99 gnd 2.080806f
R100 99 98 2.224404
C103 100 gnd 2.080806f
R101 100 99 2.224404
C104 101 gnd 2.080806f
R102 101 100 2.224404
C105 102 gnd 2.080806f
R103 102 101 2.224404
C106 103 gnd 2.080806f
R104 102 103 2.224404
C107 104 gnd 2.080806f
R105 104 103 2.224404
C108 105 gnd 2.080806f
R106 105 104 2.224404
C109 106 gnd 2.080806f
R107 105 106 2.224404
C110 107 gnd 2.080806f
R108 107 106 2.224404
C111 108 gnd 2.080806f
R109 108 107 2.224404
C112 109 gnd 2.080806f
R110 108 109 2.224404
C113 110 gnd 2.080806f
R111 109 110 2.224404
C114 111 gnd 2.080806f
R112 110 111 2.224404
C115 112 gnd 2.080806f
R113 111 112 2.224404
C116 113 gnd 2.080806f
R114 112 113 2.224404
C117 114 gnd 2.080806f
R115 113 114 2.224404
C118 115 gnd 2.080806f
R116 114 115 2.224404
C119 116 gnd 2.080806f
R117 115 116 2.224404
C120 117 gnd 2.080806f
R118 116 117 2.224404
C121 118 gnd 2.080806f
R119 118 117 2.224404
C122 119 gnd 2.080806f
R120 118 119 2.224404
C123 120 gnd 2.080806f
R121 120 119 2.224404
C124 121 gnd 2.080806f
R122 121 120 2.224404
C125 122 gnd 2.080806f
R123 121 122 2.224404
C126 123 gnd 2.080806f
R124 123 122 2.224404
C127 124 gnd 2.080806f
R125 124 123 2.224404
C128 125 gnd 2.080806f
R126 125 124 2.224404
C129 126 gnd 2.080806f
R127 126 125 2.224404
C130 127 gnd 2.080806f
R128 126 127 2.224404
C131 128 gnd 2.080806f
R129 128 127 2.224404
C132 129 gnd 2.080806f
R130 128 129 2.224404
C133 130 gnd 2.080806f
R131 130 129 2.224404
C134 131 gnd 2.080806f
R132 131 130 2.224404
C135 132 gnd 2.080806f
R133 132 131 2.224404
C136 133 gnd 2.080806f
R134 133 132 2.224404
C137 134 gnd 2.080806f
R135 134 133 2.224404
C138 135 gnd 2.080806f
R136 134 135 2.224404
C139 136 gnd 2.080806f
R137 135 136 2.224404
C140 137 gnd 2.080806f
R138 137 136 2.224404
C141 138 gnd 2.080806f
R139 138 137 2.224404
C142 139 gnd 2.080806f
R140 138 139 2.224404
C143 140 gnd 2.080806f
R141 139 140 2.224404
C144 141 gnd 2.080806f
R142 140 141 2.224404
C145 142 gnd 2.080806f
R143 142 141 2.224404
C146 143 gnd 2.080806f
R144 142 143 2.224404
C147 144 gnd 2.080806f
R145 143 144 2.224404
C148 145 gnd 2.080806f
R146 144 145 2.224404
C149 146 gnd 2.080806f
R147 145 146 2.224404
C150 147 gnd 2.080806f
R148 146 147 2.224404
C151 148 gnd 2.080806f
R149 147 148 2.224404
C152 149 gnd 2.080806f
R150 148 149 2.224404
C153 150 gnd 2.080806f
R151 150 149 2.224404
C154 151 gnd 2.080806f
R152 150 151 2.224404
C155 152 gnd 2.080806f
R153 151 152 2.224404
C156 153 gnd 2.080806f
R154 153 152 2.224404
C157 154 gnd 2.080806f
R155 153 154 2.224404
C158 155 gnd 2.080806f
R156 155 154 2.224404
C159 156 gnd 2.080806f
R157 156 155 2.224404
C160 157 gnd 2.080806f
R158 156 157 2.224404
C161 158 gnd 2.080806f
R159 158 157 2.224404
C162 159 gnd 2.080806f
R160 159 158 2.224404
C163 160 gnd 2.080806f
R161 160 159 2.224404
C164 161 gnd 2.080806f
R162 160 161 2.224404
C165 162 gnd 2.080806f
R163 161 162 2.224404
C166 163 gnd 2.080806f
R164 162 163 2.224404
R165 g180_2 163 2.224404
.ends

.subckt netg185 g185_0 g185_2 g185_1 g185_3 gnd
C1  g185_0 gnd 2.080806f
C2  g185_2 gnd 2.080806f
C3  g185_1 gnd 2.080806f
C4  g185_3 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g185_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
C14 10 gnd 2.080806f
R10 10 9 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
C16 12 gnd 2.080806f
R12 12 11 2.224404
C17 13 gnd 2.080806f
R13 13 12 2.224404
C18 14 gnd 2.080806f
R14 14 13 2.224404
C19 15 gnd 2.080806f
R15 15 14 2.224404
C20 16 gnd 2.080806f
R16 16 15 2.224404
C21 17 gnd 2.080806f
R17 17 16 2.224404
C22 18 gnd 2.080806f
R18 18 17 2.224404
C23 19 gnd 2.080806f
R19 19 18 2.224404
C24 20 gnd 2.080806f
R20 20 19 2.224404
C25 21 gnd 2.080806f
R21 21 20 2.224404
C26 22 gnd 2.080806f
R22 22 21 2.224404
C27 23 gnd 2.080806f
R23 23 22 2.224404
C28 24 gnd 2.080806f
R24 24 23 2.224404
C29 25 gnd 2.080806f
R25 25 24 2.224404
C30 26 gnd 2.080806f
R26 26 25 2.224404
C31 27 gnd 2.080806f
R27 27 26 2.224404
C32 28 gnd 2.080806f
R28 28 27 2.224404
C33 29 gnd 2.080806f
R29 29 28 2.224404
C34 30 gnd 2.080806f
R30 30 29 2.224404
C35 31 gnd 2.080806f
R31 31 30 2.224404
C36 32 gnd 2.080806f
R32 32 31 2.224404
C37 33 gnd 2.080806f
R33 33 32 2.224404
C38 34 gnd 2.080806f
R34 34 33 2.224404
C39 35 gnd 2.080806f
R35 35 34 2.224404
C40 36 gnd 2.080806f
R36 36 35 2.224404
C41 37 gnd 2.080806f
R37 37 36 2.224404
C42 38 gnd 2.080806f
R38 38 37 2.224404
C43 39 gnd 2.080806f
R39 39 38 2.224404
C44 40 gnd 2.080806f
R40 40 39 2.224404
C45 41 gnd 2.080806f
R41 41 40 2.224404
C46 42 gnd 2.080806f
R42 42 41 2.224404
C47 43 gnd 2.080806f
R43 43 42 2.224404
C48 44 gnd 2.080806f
R44 44 43 2.224404
C49 45 gnd 2.080806f
R45 45 44 2.224404
C50 46 gnd 2.080806f
R46 46 45 2.224404
C51 47 gnd 2.080806f
R47 47 46 2.224404
C52 48 gnd 2.080806f
R48 48 47 2.224404
C53 49 gnd 2.080806f
R49 49 48 2.224404
C54 50 gnd 2.080806f
R50 50 49 2.224404
C55 51 gnd 2.080806f
R51 51 50 2.224404
C56 52 gnd 2.080806f
R52 52 51 2.224404
C57 53 gnd 2.080806f
R53 53 52 2.224404
C58 54 gnd 2.080806f
R54 54 53 2.224404
C59 55 gnd 2.080806f
R55 55 54 2.224404
C60 56 gnd 2.080806f
R56 56 55 2.224404
C61 57 gnd 2.080806f
R57 57 56 2.224404
C62 58 gnd 2.080806f
R58 58 57 2.224404
C63 59 gnd 2.080806f
R59 59 58 2.224404
C64 60 gnd 2.080806f
R60 60 59 2.224404
C65 61 gnd 2.080806f
R61 61 60 2.224404
C66 62 gnd 2.080806f
R62 62 61 2.224404
C67 63 gnd 2.080806f
R63 63 62 2.224404
C68 64 gnd 2.080806f
R64 64 63 2.224404
C69 65 gnd 2.080806f
R65 65 64 2.224404
C70 66 gnd 2.080806f
R66 66 65 2.224404
C71 67 gnd 2.080806f
R67 67 66 2.224404
C72 68 gnd 2.080806f
R68 68 67 2.224404
C73 69 gnd 2.080806f
R69 69 68 2.224404
C74 70 gnd 2.080806f
R70 70 69 2.224404
C75 71 gnd 2.080806f
R71 71 70 2.224404
C76 72 gnd 2.080806f
R72 72 71 2.224404
C77 73 gnd 2.080806f
R73 73 72 2.224404
C78 74 gnd 2.080806f
R74 74 73 2.224404
C79 75 gnd 2.080806f
R75 75 74 2.224404
C80 76 gnd 2.080806f
R76 76 75 2.224404
R77 g185_1 76 2.224404
C81 77 gnd 2.080806f
R78 77 g185_1 2.224404
C82 78 gnd 2.080806f
R79 78 77 2.224404
C83 79 gnd 2.080806f
R80 79 78 2.224404
C84 80 gnd 2.080806f
R81 80 79 2.224404
C85 81 gnd 2.080806f
R82 81 80 2.224404
C86 82 gnd 2.080806f
R83 82 81 2.224404
C87 83 gnd 2.080806f
R84 83 82 2.224404
C88 84 gnd 2.080806f
R85 84 83 2.224404
C89 85 gnd 2.080806f
R86 85 84 2.224404
C90 86 gnd 2.080806f
R87 86 85 2.224404
C91 87 gnd 2.080806f
R88 87 86 2.224404
C92 88 gnd 2.080806f
R89 88 87 2.224404
C93 89 gnd 2.080806f
R90 89 88 2.224404
C94 90 gnd 2.080806f
R91 90 89 2.224404
C95 91 gnd 2.080806f
R92 91 90 2.224404
C96 92 gnd 2.080806f
R93 92 91 2.224404
C97 93 gnd 2.080806f
R94 93 92 2.224404
C98 94 gnd 2.080806f
R95 94 93 2.224404
C99 95 gnd 2.080806f
R96 95 94 2.224404
C100 96 gnd 2.080806f
R97 96 95 2.224404
C101 97 gnd 2.080806f
R98 97 96 2.224404
C102 98 gnd 2.080806f
R99 98 97 2.224404
C103 99 gnd 2.080806f
R100 99 98 2.224404
C104 100 gnd 2.080806f
R101 100 99 2.224404
C105 101 gnd 2.080806f
R102 101 100 2.224404
C106 102 gnd 2.080806f
R103 102 101 2.224404
C107 103 gnd 2.080806f
R104 103 102 2.224404
C108 104 gnd 2.080806f
R105 104 103 2.224404
C109 105 gnd 2.080806f
R106 105 104 2.224404
C110 106 gnd 2.080806f
R107 106 105 2.224404
C111 107 gnd 2.080806f
R108 107 106 2.224404
C112 108 gnd 2.080806f
R109 108 107 2.224404
C113 109 gnd 2.080806f
R110 109 108 2.224404
R111 g185_3 109 2.224404
C114 110 gnd 2.080806f
R112 110 g185_3 2.224404
C115 111 gnd 2.080806f
R113 111 110 2.224404
C116 112 gnd 2.080806f
R114 112 111 2.224404
C117 113 gnd 2.080806f
R115 112 113 2.224404
C118 114 gnd 2.080806f
R116 113 114 2.224404
C119 115 gnd 2.080806f
R117 114 115 2.224404
C120 116 gnd 2.080806f
R118 115 116 2.224404
C121 117 gnd 2.080806f
R119 116 117 2.224404
C122 118 gnd 2.080806f
R120 117 118 2.224404
C123 119 gnd 2.080806f
R121 118 119 2.224404
C124 120 gnd 2.080806f
R122 119 120 2.224404
C125 121 gnd 2.080806f
R123 120 121 2.224404
C126 122 gnd 2.080806f
R124 121 122 2.224404
C127 123 gnd 2.080806f
R125 122 123 2.224404
C128 124 gnd 2.080806f
R126 123 124 2.224404
C129 125 gnd 2.080806f
R127 124 125 2.224404
C130 126 gnd 2.080806f
R128 125 126 2.224404
C131 127 gnd 2.080806f
R129 126 127 2.224404
C132 128 gnd 2.080806f
R130 127 128 2.224404
C133 129 gnd 2.080806f
R131 128 129 2.224404
C134 130 gnd 2.080806f
R132 129 130 2.224404
C135 131 gnd 2.080806f
R133 130 131 2.224404
C136 132 gnd 2.080806f
R134 131 132 2.224404
C137 133 gnd 2.080806f
R135 132 133 2.224404
C138 134 gnd 2.080806f
R136 133 134 2.224404
C139 135 gnd 2.080806f
R137 134 135 2.224404
C140 136 gnd 2.080806f
R138 135 136 2.224404
C141 137 gnd 2.080806f
R139 136 137 2.224404
C142 138 gnd 2.080806f
R140 137 138 2.224404
C143 139 gnd 2.080806f
R141 138 139 2.224404
C144 140 gnd 2.080806f
R142 139 140 2.224404
C145 141 gnd 2.080806f
R143 140 141 2.224404
C146 142 gnd 2.080806f
R144 141 142 2.224404
C147 143 gnd 2.080806f
R145 142 143 2.224404
C148 144 gnd 2.080806f
R146 143 144 2.224404
C149 145 gnd 2.080806f
R147 144 145 2.224404
C150 146 gnd 2.080806f
R148 145 146 2.224404
C151 147 gnd 2.080806f
R149 146 147 2.224404
C152 148 gnd 2.080806f
R150 147 148 2.224404
C153 149 gnd 2.080806f
R151 148 149 2.224404
C154 150 gnd 2.080806f
R152 149 150 2.224404
C155 151 gnd 2.080806f
R153 150 151 2.224404
C156 152 gnd 2.080806f
R154 151 152 2.224404
C157 153 gnd 2.080806f
R155 153 152 2.224404
C158 154 gnd 2.080806f
R156 154 153 2.224404
C159 155 gnd 2.080806f
R157 155 154 2.224404
C160 156 gnd 2.080806f
R158 156 155 2.224404
C161 157 gnd 2.080806f
R159 157 156 2.224404
C162 158 gnd 2.080806f
R160 158 157 2.224404
C163 159 gnd 2.080806f
R161 158 159 2.224404
C164 160 gnd 2.080806f
R162 159 160 2.224404
C165 161 gnd 2.080806f
R163 160 161 2.224404
C166 162 gnd 2.080806f
R164 161 162 2.224404
C167 163 gnd 2.080806f
R165 162 163 2.224404
C168 164 gnd 2.080806f
R166 163 164 2.224404
C169 165 gnd 2.080806f
R167 164 165 2.224404
C170 166 gnd 2.080806f
R168 165 166 2.224404
C171 167 gnd 2.080806f
R169 166 167 2.224404
C172 168 gnd 2.080806f
R170 167 168 2.224404
C173 169 gnd 2.080806f
R171 168 169 2.224404
C174 170 gnd 2.080806f
R172 169 170 2.224404
C175 171 gnd 2.080806f
R173 170 171 2.224404
C176 172 gnd 2.080806f
R174 171 172 2.224404
C177 173 gnd 2.080806f
R175 172 173 2.224404
C178 174 gnd 2.080806f
R176 173 174 2.224404
C179 175 gnd 2.080806f
R177 174 175 2.224404
C180 176 gnd 2.080806f
R178 175 176 2.224404
C181 177 gnd 2.080806f
R179 176 177 2.224404
R180 177 g185_2 2.224404
.ends

.subckt netg184 g184_0 g184_3 g184_2 g184_1 gnd
C1  g184_0 gnd 2.080806f
C2  g184_3 gnd 2.080806f
C3  g184_2 gnd 2.080806f
C4  g184_1 gnd 2.080806f
C5 1 gnd 2.080806f
R1 1 g184_0 2.224404
C6 2 gnd 2.080806f
R2 2 1 2.224404
C7 3 gnd 2.080806f
R3 3 2 2.224404
C8 4 gnd 2.080806f
R4 4 3 2.224404
C9 5 gnd 2.080806f
R5 5 4 2.224404
C10 6 gnd 2.080806f
R6 6 5 2.224404
C11 7 gnd 2.080806f
R7 7 6 2.224404
C12 8 gnd 2.080806f
R8 8 7 2.224404
C13 9 gnd 2.080806f
R9 9 8 2.224404
C14 10 gnd 2.080806f
R10 10 9 2.224404
C15 11 gnd 2.080806f
R11 11 10 2.224404
C16 12 gnd 2.080806f
R12 12 11 2.224404
C17 13 gnd 2.080806f
R13 13 12 2.224404
C18 14 gnd 2.080806f
R14 14 13 2.224404
C19 15 gnd 2.080806f
R15 15 14 2.224404
C20 16 gnd 2.080806f
R16 16 15 2.224404
C21 17 gnd 2.080806f
R17 16 17 2.224404
C22 18 gnd 2.080806f
R18 17 18 2.224404
C23 19 gnd 2.080806f
R19 18 19 2.224404
C24 20 gnd 2.080806f
R20 20 19 2.224404
C25 21 gnd 2.080806f
R21 20 21 2.224404
C26 22 gnd 2.080806f
R22 21 22 2.224404
C27 23 gnd 2.080806f
R23 22 23 2.224404
C28 24 gnd 2.080806f
R24 24 23 2.224404
C29 25 gnd 2.080806f
R25 24 25 2.224404
C30 26 gnd 2.080806f
R26 26 25 2.224404
C31 27 gnd 2.080806f
R27 26 27 2.224404
C32 28 gnd 2.080806f
R28 28 27 2.224404
C33 29 gnd 2.080806f
R29 29 28 2.224404
C34 30 gnd 2.080806f
R30 30 29 2.224404
C35 31 gnd 2.080806f
R31 30 31 2.224404
C36 32 gnd 2.080806f
R32 32 31 2.224404
C37 33 gnd 2.080806f
R33 33 32 2.224404
C38 34 gnd 2.080806f
R34 34 33 2.224404
C39 35 gnd 2.080806f
R35 35 34 2.224404
C40 36 gnd 2.080806f
R36 36 35 2.224404
C41 37 gnd 2.080806f
R37 37 36 2.224404
C42 38 gnd 2.080806f
R38 38 37 2.224404
C43 39 gnd 2.080806f
R39 39 38 2.224404
C44 40 gnd 2.080806f
R40 40 39 2.224404
C45 41 gnd 2.080806f
R41 41 40 2.224404
C46 42 gnd 2.080806f
R42 42 41 2.224404
C47 43 gnd 2.080806f
R43 43 42 2.224404
C48 44 gnd 2.080806f
R44 44 43 2.224404
C49 45 gnd 2.080806f
R45 45 44 2.224404
C50 46 gnd 2.080806f
R46 46 45 2.224404
C51 47 gnd 2.080806f
R47 47 46 2.224404
C52 48 gnd 2.080806f
R48 48 47 2.224404
C53 49 gnd 2.080806f
R49 49 48 2.224404
C54 50 gnd 2.080806f
R50 50 49 2.224404
C55 51 gnd 2.080806f
R51 51 50 2.224404
C56 52 gnd 2.080806f
R52 52 51 2.224404
C57 53 gnd 2.080806f
R53 53 52 2.224404
C58 54 gnd 2.080806f
R54 54 53 2.224404
C59 55 gnd 2.080806f
R55 55 54 2.224404
C60 56 gnd 2.080806f
R56 56 55 2.224404
C61 57 gnd 2.080806f
R57 57 56 2.224404
C62 58 gnd 2.080806f
R58 57 58 2.224404
C63 59 gnd 2.080806f
R59 59 58 2.224404
C64 60 gnd 2.080806f
R60 60 59 2.224404
C65 61 gnd 2.080806f
R61 61 60 2.224404
C66 62 gnd 2.080806f
R62 62 61 2.224404
C67 63 gnd 2.080806f
R63 63 62 2.224404
C68 64 gnd 2.080806f
R64 64 63 2.224404
C69 65 gnd 2.080806f
R65 65 64 2.224404
C70 66 gnd 2.080806f
R66 66 65 2.224404
C71 67 gnd 2.080806f
R67 67 66 2.224404
C72 68 gnd 2.080806f
R68 68 67 2.224404
C73 69 gnd 2.080806f
R69 69 68 2.224404
C74 70 gnd 2.080806f
R70 70 69 2.224404
C75 71 gnd 2.080806f
R71 71 70 2.224404
R72 g184_2 71 2.224404
C76 72 gnd 2.080806f
R73 g184_2 72 2.224404
C77 73 gnd 2.080806f
R74 72 73 2.224404
C78 74 gnd 2.080806f
R75 73 74 2.224404
C79 75 gnd 2.080806f
R76 74 75 2.224404
C80 76 gnd 2.080806f
R77 75 76 2.224404
C81 77 gnd 2.080806f
R78 76 77 2.224404
C82 78 gnd 2.080806f
R79 77 78 2.224404
C83 79 gnd 2.080806f
R80 78 79 2.224404
C84 80 gnd 2.080806f
R81 79 80 2.224404
C85 81 gnd 2.080806f
R82 80 81 2.224404
C86 82 gnd 2.080806f
R83 81 82 2.224404
C87 83 gnd 2.080806f
R84 82 83 2.224404
C88 84 gnd 2.080806f
R85 83 84 2.224404
C89 85 gnd 2.080806f
R86 84 85 2.224404
C90 86 gnd 2.080806f
R87 85 86 2.224404
C91 87 gnd 2.080806f
R88 86 87 2.224404
C92 88 gnd 2.080806f
R89 87 88 2.224404
C93 89 gnd 2.080806f
R90 88 89 2.224404
C94 90 gnd 2.080806f
R91 89 90 2.224404
C95 91 gnd 2.080806f
R92 90 91 2.224404
C96 92 gnd 2.080806f
R93 91 92 2.224404
C97 93 gnd 2.080806f
R94 92 93 2.224404
C98 94 gnd 2.080806f
R95 93 94 2.224404
C99 95 gnd 2.080806f
R96 94 95 2.224404
C100 96 gnd 2.080806f
R97 95 96 2.224404
C101 97 gnd 2.080806f
R98 96 97 2.224404
C102 98 gnd 2.080806f
R99 97 98 2.224404
C103 99 gnd 2.080806f
R100 98 99 2.224404
C104 100 gnd 2.080806f
R101 99 100 2.224404
C105 101 gnd 2.080806f
R102 100 101 2.224404
C106 102 gnd 2.080806f
R103 101 102 2.224404
C107 103 gnd 2.080806f
R104 102 103 2.224404
R105 103 g184_1 2.224404
C108 104 gnd 2.080806f
R106 g184_1 104 2.224404
C109 105 gnd 2.080806f
R107 104 105 2.224404
C110 106 gnd 2.080806f
R108 105 106 2.224404
C111 107 gnd 2.080806f
R109 106 107 2.224404
C112 108 gnd 2.080806f
R110 107 108 2.224404
C113 109 gnd 2.080806f
R111 108 109 2.224404
C114 110 gnd 2.080806f
R112 109 110 2.224404
C115 111 gnd 2.080806f
R113 110 111 2.224404
C116 112 gnd 2.080806f
R114 111 112 2.224404
C117 113 gnd 2.080806f
R115 112 113 2.224404
C118 114 gnd 2.080806f
R116 113 114 2.224404
C119 115 gnd 2.080806f
R117 114 115 2.224404
C120 116 gnd 2.080806f
R118 115 116 2.224404
C121 117 gnd 2.080806f
R119 116 117 2.224404
C122 118 gnd 2.080806f
R120 117 118 2.224404
C123 119 gnd 2.080806f
R121 118 119 2.224404
C124 120 gnd 2.080806f
R122 119 120 2.224404
C125 121 gnd 2.080806f
R123 120 121 2.224404
C126 122 gnd 2.080806f
R124 121 122 2.224404
C127 123 gnd 2.080806f
R125 122 123 2.224404
C128 124 gnd 2.080806f
R126 123 124 2.224404
C129 125 gnd 2.080806f
R127 124 125 2.224404
C130 126 gnd 2.080806f
R128 125 126 2.224404
C131 127 gnd 2.080806f
R129 126 127 2.224404
C132 128 gnd 2.080806f
R130 127 128 2.224404
C133 129 gnd 2.080806f
R131 128 129 2.224404
C134 130 gnd 2.080806f
R132 129 130 2.224404
C135 131 gnd 2.080806f
R133 130 131 2.224404
C136 132 gnd 2.080806f
R134 131 132 2.224404
C137 133 gnd 2.080806f
R135 132 133 2.224404
C138 134 gnd 2.080806f
R136 133 134 2.224404
C139 135 gnd 2.080806f
R137 134 135 2.224404
C140 136 gnd 2.080806f
R138 135 136 2.224404
C141 137 gnd 2.080806f
R139 136 137 2.224404
C142 138 gnd 2.080806f
R140 137 138 2.224404
C143 139 gnd 2.080806f
R141 138 139 2.224404
C144 140 gnd 2.080806f
R142 139 140 2.224404
C145 141 gnd 2.080806f
R143 140 141 2.224404
C146 142 gnd 2.080806f
R144 141 142 2.224404
C147 143 gnd 2.080806f
R145 142 143 2.224404
C148 144 gnd 2.080806f
R146 143 144 2.224404
C149 145 gnd 2.080806f
R147 144 145 2.224404
C150 146 gnd 2.080806f
R148 145 146 2.224404
C151 147 gnd 2.080806f
R149 146 147 2.224404
C152 148 gnd 2.080806f
R150 147 148 2.224404
C153 149 gnd 2.080806f
R151 148 149 2.224404
C154 150 gnd 2.080806f
R152 149 150 2.224404
C155 151 gnd 2.080806f
R153 150 151 2.224404
C156 152 gnd 2.080806f
R154 151 152 2.224404
C157 153 gnd 2.080806f
R155 152 153 2.224404
C158 154 gnd 2.080806f
R156 153 154 2.224404
C159 155 gnd 2.080806f
R157 154 155 2.224404
C160 156 gnd 2.080806f
R158 155 156 2.224404
C161 157 gnd 2.080806f
R159 156 157 2.224404
C162 158 gnd 2.080806f
R160 157 158 2.224404
C163 159 gnd 2.080806f
R161 158 159 2.224404
C164 160 gnd 2.080806f
R162 159 160 2.224404
C165 161 gnd 2.080806f
R163 160 161 2.224404
C166 162 gnd 2.080806f
R164 161 162 2.224404
C167 163 gnd 2.080806f
R165 162 163 2.224404
C168 164 gnd 2.080806f
R166 163 164 2.224404
C169 165 gnd 2.080806f
R167 164 165 2.224404
C170 166 gnd 2.080806f
R168 165 166 2.224404
C171 167 gnd 2.080806f
R169 166 167 2.224404
C172 168 gnd 2.080806f
R170 167 168 2.224404
C173 169 gnd 2.080806f
R171 168 169 2.224404
C174 170 gnd 2.080806f
R172 169 170 2.224404
C175 171 gnd 2.080806f
R173 170 171 2.224404
C176 172 gnd 2.080806f
R174 171 172 2.224404
C177 173 gnd 2.080806f
R175 172 173 2.224404
C178 174 gnd 2.080806f
R176 173 174 2.224404
C179 175 gnd 2.080806f
R177 174 175 2.224404
C180 176 gnd 2.080806f
R178 175 176 2.224404
C181 177 gnd 2.080806f
R179 176 177 2.224404
C182 178 gnd 2.080806f
R180 177 178 2.224404
C183 179 gnd 2.080806f
R181 178 179 2.224404
C184 180 gnd 2.080806f
R182 179 180 2.224404
C185 181 gnd 2.080806f
R183 180 181 2.224404
C186 182 gnd 2.080806f
R184 181 182 2.224404
R185 182 g184_3 2.224404
.ends

.subckt netg165 g165_1 g165_0 gnd
C1  g165_1 gnd 2.080806f
C2  g165_0 gnd 2.080806f
C3 1 gnd 2.080806f
R1 1 g165_0 2.224404
C4 2 gnd 2.080806f
R2 2 1 2.224404
C5 3 gnd 2.080806f
R3 3 2 2.224404
C6 4 gnd 2.080806f
R4 4 3 2.224404
C7 5 gnd 2.080806f
R5 5 4 2.224404
C8 6 gnd 2.080806f
R6 6 5 2.224404
C9 7 gnd 2.080806f
R7 7 6 2.224404
C10 8 gnd 2.080806f
R8 8 7 2.224404
C11 9 gnd 2.080806f
R9 9 8 2.224404
C12 10 gnd 2.080806f
R10 10 9 2.224404
C13 11 gnd 2.080806f
R11 11 10 2.224404
C14 12 gnd 2.080806f
R12 12 11 2.224404
C15 13 gnd 2.080806f
R13 13 12 2.224404
C16 14 gnd 2.080806f
R14 14 13 2.224404
C17 15 gnd 2.080806f
R15 15 14 2.224404
C18 16 gnd 2.080806f
R16 16 15 2.224404
C19 17 gnd 2.080806f
R17 17 16 2.224404
C20 18 gnd 2.080806f
R18 18 17 2.224404
C21 19 gnd 2.080806f
R19 19 18 2.224404
C22 20 gnd 2.080806f
R20 20 19 2.224404
C23 21 gnd 2.080806f
R21 21 20 2.224404
C24 22 gnd 2.080806f
R22 22 21 2.224404
C25 23 gnd 2.080806f
R23 23 22 2.224404
C26 24 gnd 2.080806f
R24 24 23 2.224404
C27 25 gnd 2.080806f
R25 25 24 2.224404
C28 26 gnd 2.080806f
R26 26 25 2.224404
C29 27 gnd 2.080806f
R27 27 26 2.224404
C30 28 gnd 2.080806f
R28 28 27 2.224404
C31 29 gnd 2.080806f
R29 29 28 2.224404
C32 30 gnd 2.080806f
R30 30 29 2.224404
C33 31 gnd 2.080806f
R31 31 30 2.224404
C34 32 gnd 2.080806f
R32 32 31 2.224404
C35 33 gnd 2.080806f
R33 33 32 2.224404
C36 34 gnd 2.080806f
R34 34 33 2.224404
C37 35 gnd 2.080806f
R35 35 34 2.224404
C38 36 gnd 2.080806f
R36 36 35 2.224404
C39 37 gnd 2.080806f
R37 37 36 2.224404
C40 38 gnd 2.080806f
R38 38 37 2.224404
C41 39 gnd 2.080806f
R39 39 38 2.224404
C42 40 gnd 2.080806f
R40 40 39 2.224404
C43 41 gnd 2.080806f
R41 41 40 2.224404
C44 42 gnd 2.080806f
R42 42 41 2.224404
C45 43 gnd 2.080806f
R43 43 42 2.224404
C46 44 gnd 2.080806f
R44 44 43 2.224404
C47 45 gnd 2.080806f
R45 45 44 2.224404
C48 46 gnd 2.080806f
R46 46 45 2.224404
C49 47 gnd 2.080806f
R47 47 46 2.224404
C50 48 gnd 2.080806f
R48 48 47 2.224404
C51 49 gnd 2.080806f
R49 49 48 2.224404
C52 50 gnd 2.080806f
R50 50 49 2.224404
C53 51 gnd 2.080806f
R51 51 50 2.224404
C54 52 gnd 2.080806f
R52 52 51 2.224404
C55 53 gnd 2.080806f
R53 53 52 2.224404
C56 54 gnd 2.080806f
R54 54 53 2.224404
C57 55 gnd 2.080806f
R55 55 54 2.224404
C58 56 gnd 2.080806f
R56 56 55 2.224404
C59 57 gnd 2.080806f
R57 57 56 2.224404
C60 58 gnd 2.080806f
R58 58 57 2.224404
C61 59 gnd 2.080806f
R59 59 58 2.224404
C62 60 gnd 2.080806f
R60 60 59 2.224404
C63 61 gnd 2.080806f
R61 61 60 2.224404
C64 62 gnd 2.080806f
R62 62 61 2.224404
C65 63 gnd 2.080806f
R63 63 62 2.224404
C66 64 gnd 2.080806f
R64 64 63 2.224404
C67 65 gnd 2.080806f
R65 65 64 2.224404
C68 66 gnd 2.080806f
R66 66 65 2.224404
C69 67 gnd 2.080806f
R67 67 66 2.224404
C70 68 gnd 2.080806f
R68 68 67 2.224404
C71 69 gnd 2.080806f
R69 69 68 2.224404
C72 70 gnd 2.080806f
R70 70 69 2.224404
C73 71 gnd 2.080806f
R71 71 70 2.224404
C74 72 gnd 2.080806f
R72 72 71 2.224404
C75 73 gnd 2.080806f
R73 73 72 2.224404
C76 74 gnd 2.080806f
R74 74 73 2.224404
C77 75 gnd 2.080806f
R75 75 74 2.224404
C78 76 gnd 2.080806f
R76 76 75 2.224404
C79 77 gnd 2.080806f
R77 77 76 2.224404
C80 78 gnd 2.080806f
R78 78 77 2.224404
C81 79 gnd 2.080806f
R79 79 78 2.224404
C82 80 gnd 2.080806f
R80 80 79 2.224404
C83 81 gnd 2.080806f
R81 81 80 2.224404
C84 82 gnd 2.080806f
R82 82 81 2.224404
C85 83 gnd 2.080806f
R83 83 82 2.224404
C86 84 gnd 2.080806f
R84 84 83 2.224404
C87 85 gnd 2.080806f
R85 85 84 2.224404
C88 86 gnd 2.080806f
R86 86 85 2.224404
C89 87 gnd 2.080806f
R87 87 86 2.224404
C90 88 gnd 2.080806f
R88 88 87 2.224404
C91 89 gnd 2.080806f
R89 89 88 2.224404
C92 90 gnd 2.080806f
R90 90 89 2.224404
C93 91 gnd 2.080806f
R91 91 90 2.224404
C94 92 gnd 2.080806f
R92 92 91 2.224404
C95 93 gnd 2.080806f
R93 93 92 2.224404
C96 94 gnd 2.080806f
R94 94 93 2.224404
C97 95 gnd 2.080806f
R95 95 94 2.224404
C98 96 gnd 2.080806f
R96 96 95 2.224404
C99 97 gnd 2.080806f
R97 97 96 2.224404
C100 98 gnd 2.080806f
R98 98 97 2.224404
C101 99 gnd 2.080806f
R99 99 98 2.224404
C102 100 gnd 2.080806f
R100 100 99 2.224404
C103 101 gnd 2.080806f
R101 101 100 2.224404
C104 102 gnd 2.080806f
R102 102 101 2.224404
C105 103 gnd 2.080806f
R103 103 102 2.224404
C106 104 gnd 2.080806f
R104 104 103 2.224404
C107 105 gnd 2.080806f
R105 105 104 2.224404
C108 106 gnd 2.080806f
R106 106 105 2.224404
C109 107 gnd 2.080806f
R107 107 106 2.224404
C110 108 gnd 2.080806f
R108 108 107 2.224404
C111 109 gnd 2.080806f
R109 109 108 2.224404
C112 110 gnd 2.080806f
R110 110 109 2.224404
C113 111 gnd 2.080806f
R111 111 110 2.224404
C114 112 gnd 2.080806f
R112 112 111 2.224404
C115 113 gnd 2.080806f
R113 113 112 2.224404
C116 114 gnd 2.080806f
R114 114 113 2.224404
C117 115 gnd 2.080806f
R115 115 114 2.224404
C118 116 gnd 2.080806f
R116 116 115 2.224404
C119 117 gnd 2.080806f
R117 117 116 2.224404
C120 118 gnd 2.080806f
R118 118 117 2.224404
C121 119 gnd 2.080806f
R119 119 118 2.224404
C122 120 gnd 2.080806f
R120 120 119 2.224404
C123 121 gnd 2.080806f
R121 121 120 2.224404
C124 122 gnd 2.080806f
R122 122 121 2.224404
C125 123 gnd 2.080806f
R123 123 122 2.224404
C126 124 gnd 2.080806f
R124 124 123 2.224404
C127 125 gnd 2.080806f
R125 125 124 2.224404
C128 126 gnd 2.080806f
R126 126 125 2.224404
C129 127 gnd 2.080806f
R127 127 126 2.224404
C130 128 gnd 2.080806f
R128 128 127 2.224404
C131 129 gnd 2.080806f
R129 129 128 2.224404
C132 130 gnd 2.080806f
R130 130 129 2.224404
C133 131 gnd 2.080806f
R131 131 130 2.224404
C134 132 gnd 2.080806f
R132 132 131 2.224404
C135 133 gnd 2.080806f
R133 133 132 2.224404
C136 134 gnd 2.080806f
R134 134 133 2.224404
C137 135 gnd 2.080806f
R135 135 134 2.224404
C138 136 gnd 2.080806f
R136 136 135 2.224404
C139 137 gnd 2.080806f
R137 137 136 2.224404
C140 138 gnd 2.080806f
R138 138 137 2.224404
C141 139 gnd 2.080806f
R139 139 138 2.224404
C142 140 gnd 2.080806f
R140 140 139 2.224404
C143 141 gnd 2.080806f
R141 141 140 2.224404
C144 142 gnd 2.080806f
R142 142 141 2.224404
C145 143 gnd 2.080806f
R143 143 142 2.224404
C146 144 gnd 2.080806f
R144 144 143 2.224404
C147 145 gnd 2.080806f
R145 145 144 2.224404
C148 146 gnd 2.080806f
R146 146 145 2.224404
C149 147 gnd 2.080806f
R147 147 146 2.224404
C150 148 gnd 2.080806f
R148 148 147 2.224404
C151 149 gnd 2.080806f
R149 149 148 2.224404
C152 150 gnd 2.080806f
R150 150 149 2.224404
C153 151 gnd 2.080806f
R151 151 150 2.224404
C154 152 gnd 2.080806f
R152 152 151 2.224404
C155 153 gnd 2.080806f
R153 153 152 2.224404
C156 154 gnd 2.080806f
R154 154 153 2.224404
C157 155 gnd 2.080806f
R155 155 154 2.224404
C158 156 gnd 2.080806f
R156 156 155 2.224404
C159 157 gnd 2.080806f
R157 157 156 2.224404
C160 158 gnd 2.080806f
R158 158 157 2.224404
C161 159 gnd 2.080806f
R159 159 158 2.224404
C162 160 gnd 2.080806f
R160 160 159 2.224404
C163 161 gnd 2.080806f
R161 161 160 2.224404
R162 g165_1 161 2.224404
.ends

* the call of the nets sub circuits:

X1 x81_1 x81_0 0 netx81
X2 g4055_1 g4055_0 0 netg4055
X3 g6531_1 g6531_0 0 netg6531
X4 g1255_0 g1255_1 0 netg1255
X5 g5391_0 g5391_1 0 netg5391
X6 g4749_0 g4749_1 0 netg4749
X7 g7003_0 g7003_1 0 netg7003
X8 x242_1 x242_0 0 netx242
X9 g6733_0 g6733_1 0 netg6733
X10 g404_2 g404_0 0 netg404
X11 g2934_1 g2934_0 0 netg2934
X12 g6397_0 g6397_1 0 netg6397
X13 g7266_1 g7266_0 0 netg7266
X14 g5784_0 g5784_1 0 netg5784
X15 g6546_1 g6546_2 0 netg6546
X16 g6937_1 g6937_0 0 netg6937
X17 g2929_1 g2929_0 0 netg2929
X18 g4099_1 g4099_0 0 netg4099
X19 g3537_0 g3537_1 0 netg3537
X20 g4245_0 g4245_1 0 netg4245
X21 g5584_1 g5584_0 0 netg5584
X22 g4531_1 g4531_0 0 netg4531
X23 g3903_1 g3903_0 0 netg3903
X24 g7164_1 g7164_0 0 netg7164
X25 g1998_0 g1998_1 0 netg1998
X26 x461_0 x461_1 0 netx461
X27 g4257_0 g4257_1 0 netg4257
X28 g961_2 g961_1 0 netg961
X29 g2816_0 g2816_1 0 netg2816
X30 g6439_1 g6439_0 0 netg6439
X31 g6979_1 g6979_0 0 netg6979
X32 g6213_0 g6213_1 0 netg6213
X33 g7268_1 g7268_0 0 netg7268
X34 g1933_1 g1933_0 0 netg1933
X35 g3986_0 g3986_1 0 netg3986
X36 g2916_1 g2916_0 0 netg2916
X37 g6553_0 g6553_1 0 netg6553
X38 g2788_0 g2788_1 0 netg2788
X39 g5960_0 g5960_1 0 netg5960
X40 g3549_0 g3549_1 0 netg3549
X41 g6206_0 g6206_1 0 netg6206
X42 g1874_2 g1874_1 0 netg1874
X43 g6916_1 g6916_0 0 netg6916
X44 g5365_0 g5365_1 0 netg5365
X45 g1131_1 g1131_0 0 netg1131
X46 g7189_1 g7189_0 0 netg7189
X47 g4313_1 g4313_0 0 netg4313
X48 g2426_0 g2426_2 0 netg2426
X49 g7001_1 g7001_0 0 netg7001
X50 g2952_1 g2952_0 0 netg2952
X51 g5880_1 g5880_0 0 netg5880
X52 g3513_1 g3513_0 0 netg3513
X53 g2939_0 g2939_1 0 netg2939
X54 g3524_0 g3524_1 0 netg3524
X55 g6729_1 g6729_0 0 netg6729
X56 g7354_1 g7354_0 0 netg7354
X57 g2818_0 g2818_1 0 netg2818
X58 g6447_1 g6447_0 0 netg6447
X59 g6132_0 g6132_1 0 netg6132
X60 g3510_0 g3510_1 0 netg3510
X61 g3486_1 g3486_0 0 netg3486
X62 g6042_0 g6042_1 0 netg6042
X63 g1591_1 g1591_0 0 netg1591
X64 g4096_1 g4096_0 0 netg4096
X65 g4048_1 g4048_0 0 netg4048
X66 g2813_1 g2813_0 0 netg2813
X67 g1928_0 g1928_1 0 netg1928
X68 g5233_0 g5233_1 0 netg5233
X69 g5369_1 g5369_0 0 netg5369
X70 g4451_1 g4451_0 0 netg4451
X71 g3480_1 g3480_0 0 netg3480
X72 g7359_0 g7359_1 0 netg7359
X73 g4302_0 g4302_1 0 netg4302
X74 g6047_1 g6047_0 0 netg6047
X75 g7358_0 g7358_1 0 netg7358
X76 g4280_1 g4280_0 0 netg4280
X77 g5411_1 g5411_0 0 netg5411
X78 x22_0 x22_1 0 netx22
X79 g1128_0 g1128_1 0 netg1128
X80 g3691_2 g3691_0 0 netg3691
X81 g7213_1 g7213_0 0 netg7213
X82 g2764_0 g2764_1 0 netg2764
X83 g6382_1 g6382_0 0 netg6382
X84 g3894_1 g3894_0 0 netg3894
X85 g6815_1 g6815_0 0 netg6815
X86 g2773_0 g2773_1 0 netg2773
X87 g2228_1 g2228_0 0 netg2228
X88 g5246_1 g5246_0 0 netg5246
X89 g2821_0 g2821_1 0 netg2821
X90 x312_0 x312_1 0 netx312
X91 g3983_1 g3983_0 0 netg3983
X92 g4329_1 g4329_0 0 netg4329
X93 g7374_0 g7374_1 0 netg7374
X94 g2501_2 g2501_0 0 netg2501
X95 g4100_1 g4100_0 0 netg4100
X96 g6013_0 g6013_1 0 netg6013
X97 g2760_1 g2760_0 0 netg2760
X98 g7212_0 g7212_1 0 netg7212
X99 g3923_1 g3923_0 0 netg3923
X100 g3414_2 g3414_1 0 netg3414
X101 g5597_0 g5597_1 0 netg5597
X102 g4298_0 g4298_1 0 netg4298
X103 g7046_0 g7046_1 0 netg7046
X104 g6452_1 g6452_0 0 netg6452
X105 g6081_1 g6081_0 0 netg6081
X106 g5448_2 g5448_1 0 netg5448
X107 g3367_1 g3367_0 0 netg3367
X108 g5353_0 g5353_1 0 netg5353
X109 g7191_0 g7191_1 0 netg7191
X110 g4013_0 g4013_1 0 netg4013
X111 g6580_0 g6580_1 0 netg6580
X112 g2350_2 g2350_0 0 netg2350
X113 g3519_1 g3519_0 0 netg3519
X114 g387_0 g387_1 0 netg387
X115 g6199_2 g6199_0 0 netg6199
X116 g7293_1 g7293_0 0 netg7293
X117 g1432_0 g1432_1 0 netg1432
X118 g1378_1 g1378_0 0 netg1378
X119 x332_0 x332_1 0 netx332
X120 g6611_1 g6611_0 0 netg6611
X121 g3564_0 g3564_1 0 netg3564
X122 g2774_1 g2774_0 0 netg2774
X123 g1313_0 g1313_1 0 netg1313
X124 g6741_1 g6741_0 0 netg6741
X125 g4290_0 g4290_1 0 netg4290
X126 g6931_1 g6931_0 0 netg6931
X127 g5859_1 g5859_0 0 netg5859
X128 g5827_0 g5827_1 0 netg5827
X129 g4428_0 g4428_1 0 netg4428
X130 g4220_0 g4220_1 0 netg4220
X131 g1174_0 g1174_1 0 netg1174
X132 g5857_0 g5857_1 0 netg5857
X133 g4103_1 g4103_0 0 netg4103
X134 g6102_0 g6102_1 0 netg6102
X135 g3070_0 g3070_1 0 netg3070
X136 g6474_1 g6474_0 0 netg6474
X137 g2781_1 g2781_0 0 netg2781
X138 g7397_1 g7397_0 0 netg7397
X139 g1284_0 g1284_1 0 netg1284
X140 g410_2 g410_0 0 netg410
X141 g2778_0 g2778_1 0 netg2778
X142 g4283_0 g4283_1 0 netg4283
X143 g6345_0 g6345_1 0 netg6345
X144 g5766_0 g5766_1 0 netg5766
X145 g6254_0 g6254_1 0 netg6254
X146 g3069_1 g3069_0 0 netg3069
X147 g6640_1 g6640_0 0 netg6640
X148 g6014_1 g6014_0 0 netg6014
X149 g4216_1 g4216_0 0 netg4216
X150 g1945_2 g1945_1 0 netg1945
X151 g5527_0 g5527_1 0 netg5527
X152 g2371_1 g2371_2 0 netg2371
X153 x82_1 x82_0 0 netx82
X154 g2751_0 g2751_1 0 netg2751
X155 g4219_1 g4219_0 0 netg4219
X156 g5998_0 g5998_1 0 netg5998
X157 g5065_2 g5065_1 0 netg5065
X158 g6103_0 g6103_1 0 netg6103
X159 g7047_0 g7047_1 0 netg7047
X160 g5316_0 g5316_1 0 netg5316
X161 g7405_1 g7405_0 0 netg7405
X162 g1518_1 g1518_0 0 netg1518
X163 g5191_0 g5191_2 0 netg5191
X164 g5996_0 g5996_1 0 netg5996
X165 g1125_1 g1125_0 0 netg1125
X166 g5792_1 g5792_0 0 netg5792
X167 g2380_2 g2380_1 0 netg2380
X168 g6084_0 g6084_1 0 netg6084
X169 g6052_0 g6052_1 0 netg6052
X170 g5297_1 g5297_0 0 netg5297
X171 g4323_1 g4323_0 0 netg4323
X172 g4628_0 g4628_1 0 netg4628
X173 g3540_1 g3540_0 0 netg3540
X174 g4065_1 g4065_0 0 netg4065
X175 g4239_1 g4239_0 0 netg4239
X176 g5350_0 g5350_1 0 netg5350
X177 g1234_0 g1234_1 0 netg1234
X178 g4318_1 g4318_0 0 netg4318
X179 g6667_1 g6667_0 0 netg6667
X180 g5737_2 g5737_1 0 netg5737
X181 g7004_1 g7004_2 0 netg7004
X182 g5244_1 g5244_0 0 netg5244
X183 g6184_1 g6184_0 0 netg6184
X184 g6862_0 g6862_1 0 netg6862
X185 g1264_0 g1264_1 0 netg1264
X186 g2879_1 g2879_0 0 netg2879
X187 g3509_0 g3509_1 0 netg3509
X188 g3411_0 g3411_1 0 netg3411
X189 g2719_1 g2719_2 0 netg2719
X190 g6642_1 g6642_2 0 netg6642
X191 g5601_1 g5601_0 0 netg5601
X192 g6287_0 g6287_1 0 netg6287
X193 g5182_0 g5182_1 0 netg5182
X194 g4344_1 g4344_0 0 netg4344
X195 g7399_1 g7399_0 0 netg7399
X196 g1461_1 g1461_0 0 netg1461
X197 g1123_1 g1123_0 0 netg1123
X198 g5322_1 g5322_0 0 netg5322
X199 g4010_1 g4010_0 0 netg4010
X200 x21_0 x21_1 0 netx21
X201 g2847_1 g2847_0 0 netg2847
X202 g1222_0 g1222_1 0 netg1222
X203 g1916_1 g1916_0 0 netg1916
X204 g5425_1 g5425_0 0 netg5425
X205 g6385_0 g6385_1 0 netg6385
X206 g2240_1 g2240_0 0 netg2240
X207 g5603_1 g5603_0 0 netg5603
X208 g4043_0 g4043_1 0 netg4043
X209 g4404_1 g4404_0 0 netg4404
X210 g1491_0 g1491_1 0 netg1491
X211 g5965_0 g5965_1 0 netg5965
X212 g6137_0 g6137_1 0 netg6137
X213 g2945_1 g2945_0 0 netg2945
X214 x61_0 x61_1 0 netx61
X215 g7093_1 g7093_2 0 netg7093
X216 g6420_0 g6420_1 0 netg6420
X217 g874_0 g874_2 0 netg874
X218 g7344_1 g7344_0 0 netg7344
X219 g6243_1 g6243_0 0 netg6243
X220 g1069_0 g1069_1 0 netg1069
X221 g6846_1 g6846_0 0 netg6846
X222 g4353_1 g4353_0 0 netg4353
X223 g1250_1 g1250_0 0 netg1250
X224 g5270_0 g5270_1 0 netg5270
X225 g2918_0 g2918_1 0 netg2918
X226 g5980_0 g5980_1 0 netg5980
X227 g1307_1 g1307_0 0 netg1307
X228 g7273_1 g7273_0 0 netg7273
X229 g2743_2 g2743_1 0 netg2743
X230 g3207_1 g3207_2 0 netg3207
X231 x471_0 x471_1 0 netx471
X232 g7275_0 g7275_1 0 netg7275
X233 g5266_1 g5266_0 0 netg5266
X234 g4265_0 g4265_1 0 netg4265
X235 g4022_1 g4022_0 0 netg4022
X236 g1360_0 g1360_1 0 netg1360
X237 g6399_0 g6399_1 0 netg6399
X238 g6182_0 g6182_1 0 netg6182
X239 g6673_0 g6673_1 0 netg6673
X240 g3082_1 g3082_0 0 netg3082
X241 g2930_1 g2930_0 0 netg2930
X242 g1494_0 g1494_1 0 netg1494
X243 g5368_0 g5368_1 0 netg5368
X244 g1422_0 g1422_1 0 netg1422
X245 g2937_1 g2937_0 0 netg2937
X246 g2555_1 g2555_2 0 netg2555
X247 g3061_0 g3061_1 0 netg3061
X248 g5394_0 g5394_1 0 netg5394
X249 g2845_1 g2845_0 0 netg2845
X250 g1534_1 g1534_0 0 netg1534
X251 g3045_1 g3045_0 0 netg3045
X252 g6887_1 g6887_0 0 netg6887
X253 g6278_0 g6278_2 0 netg6278
X254 g6977_0 g6977_1 0 netg6977
X255 g3551_1 g3551_0 0 netg3551
X256 g6751_2 g6751_0 0 netg6751
X257 x72_1 x72_0 0 netx72
X258 g5421_1 g5421_0 0 netg5421
X259 x122_1 x122_0 0 netx122
X260 g5251_1 g5251_0 0 netg5251
X261 g2784_1 g2784_0 0 netg2784
X262 x131_1 x131_0 0 netx131
X263 g6814_1 g6814_0 0 netg6814
X264 g6205_1 g6205_0 0 netg6205
X265 g6693_1 g6693_0 0 netg6693
X266 g6465_0 g6465_1 0 netg6465
X267 g2995_1 g2995_0 0 netg2995
X268 g3261_2 g3261_0 0 netg3261
X269 g1236_0 g1236_1 0 netg1236
X270 g5333_0 g5333_1 0 netg5333
X271 g4098_1 g4098_0 0 netg4098
X272 g5144_1 g5144_2 0 netg5144
X273 g1375_0 g1375_1 0 netg1375
X274 g5366_0 g5366_1 0 netg5366
X275 g4131_0 g4131_1 0 netg4131
X276 g4240_1 g4240_0 0 netg4240
X277 g3563_0 g3563_1 0 netg3563
X278 g1158_0 g1158_1 0 netg1158
X279 g7002_0 g7002_1 0 netg7002
X280 g5870_1 g5870_0 0 netg5870
X281 g4106_0 g4106_1 0 netg4106
X282 g4352_1 g4352_0 0 netg4352
X283 x91_1 x91_0 0 netx91
X284 g5932_1 g5932_0 0 netg5932
X285 g7306_2 g7306_1 0 netg7306
X286 g2579_1 g2579_2 0 netg2579
X287 g2919_0 g2919_1 0 netg2919
X288 g3429_2 g3429_0 0 netg3429
X289 g4082_1 g4082_0 0 netg4082
X290 g3901_0 g3901_1 0 netg3901
X291 g5999_1 g5999_0 0 netg5999
X292 g4309_0 g4309_1 0 netg4309
X293 g5705_1 g5705_0 0 netg5705
X294 g6450_1 g6450_0 0 netg6450
X295 g7240_1 g7240_0 0 netg7240
X296 g6392_0 g6392_1 0 netg6392
X297 g1169_1 g1169_0 0 netg1169
X298 g6871_1 g6871_0 0 netg6871
X299 g4138_0 g4138_1 0 netg4138
X300 g6363_1 g6363_0 0 netg6363
X301 g5278_0 g5278_1 0 netg5278
X302 g1479_1 g1479_0 0 netg1479
X303 g6167_0 g6167_1 0 netg6167
X304 g6131_0 g6131_1 0 netg6131
X305 g2933_0 g2933_1 0 netg2933
X306 g6744_1 g6744_0 0 netg6744
X307 g7400_1 g7400_0 0 netg7400
X308 g1852_1 g1852_0 0 netg1852
X309 g2731_1 g2731_2 0 netg2731
X310 g3453_2 g3453_0 0 netg3453
X311 g1151_0 g1151_1 0 netg1151
X312 g1421_1 g1421_0 0 netg1421
X313 g3113_1 g3113_0 0 netg3113
X314 g3089_1 g3089_0 0 netg3089
X315 x192_0 x192_1 0 netx192
X316 g6000_1 g6000_0 0 netg6000
X317 g1573_0 g1573_1 0 netg1573
X318 g6373_1 g6373_0 0 netg6373
X319 g456_0 g456_1 0 netg456
X320 g3180_2 g3180_1 0 netg3180
X321 g5313_1 g5313_0 0 netg5313
X322 g6413_1 g6413_0 0 netg6413
X323 g4149_0 g4149_1 0 netg4149
X324 g6105_1 g6105_0 0 netg6105
X325 g6448_0 g6448_1 0 netg6448
X326 g4247_1 g4247_0 0 netg4247
X327 g7269_0 g7269_1 0 netg7269
X328 g4436_0 g4436_1 0 netg4436
X329 g7346_1 g7346_0 0 netg7346
X330 g5134_0 g5134_1 0 netg5134
X331 g2822_1 g2822_0 0 netg2822
X332 g4403_0 g4403_1 0 netg4403
X333 g3968_0 g3968_1 0 netg3968
X334 g1308_0 g1308_1 0 netg1308
X335 g1165_1 g1165_0 0 netg1165
X336 g6976_0 g6976_1 0 netg6976
X337 g3315_0 g3315_2 0 netg3315
X338 g2749_0 g2749_1 0 netg2749
X339 g6732_1 g6732_0 0 netg6732
X340 g5634_2 g5634_1 0 netg5634
X341 g1380_1 g1380_0 0 netg1380
X342 g6326_0 g6326_1 0 netg6326
X343 g3225_0 g3225_2 0 netg3225
X344 g7437_1 g7437_0 0 netg7437
X345 x162_0 x162_1 0 netx162
X346 g6139_1 g6139_0 0 netg6139
X347 g6106_1 g6106_0 0 netg6106
X348 g1510_1 g1510_0 0 netg1510
X349 g1585_0 g1585_1 0 netg1585
X350 g4047_0 g4047_1 0 netg4047
X351 g5415_1 g5415_0 0 netg5415
X352 g3897_1 g3897_0 0 netg3897
X353 g6584_1 g6584_0 0 netg6584
X354 g1815_1 g1815_0 0 netg1815
X355 g6962_1 g6962_0 0 netg6962
X356 g5879_0 g5879_1 0 netg5879
X357 g2486_1 g2486_2 0 netg2486
X358 g4206_0 g4206_1 0 netg4206
X359 g4070_1 g4070_0 0 netg4070
X360 g7156_1 g7156_0 0 netg7156
X361 g1519_0 g1519_1 0 netg1519
X362 g6669_0 g6669_1 0 netg6669
X363 g1492_1 g1492_0 0 netg1492
X364 g6272_0 g6272_1 0 netg6272
X365 g1122_0 g1122_1 0 netg1122
X366 g5526_1 g5526_0 0 netg5526
X367 g3557_1 g3557_0 0 netg3557
X368 g3568_1 g3568_0 0 netg3568
X369 g6464_0 g6464_1 0 netg6464
X370 g7129_0 g7129_1 0 netg7129
X371 g4982_1 g4982_2 0 netg4982
X372 g1134_1 g1134_0 0 netg1134
X373 g7099_0 g7099_1 0 netg7099
X374 g6920_1 g6920_0 0 netg6920
X375 g6011_1 g6011_0 0 netg6011
X376 g1252_0 g1252_1 0 netg1252
X377 g6894_0 g6894_1 0 netg6894
X378 g4067_1 g4067_0 0 netg4067
X379 g1265_0 g1265_1 0 netg1265
X380 g5249_1 g5249_0 0 netg5249
X381 g4230_0 g4230_1 0 netg4230
X382 g4414_0 g4414_1 0 netg4414
X383 x221_0 x221_1 0 netx221
X384 g3487_1 g3487_0 0 netg3487
X385 g6720_0 g6720_1 0 netg6720
X386 g1452_0 g1452_1 0 netg1452
X387 g6134_0 g6134_1 0 netg6134
X388 g3500_1 g3500_0 0 netg3500
X389 g4237_1 g4237_0 0 netg4237
X390 g4530_1 g4530_0 0 netg4530
X391 g6554_1 g6554_0 0 netg6554
X392 g7131_2 g7131_1 0 netg7131
X393 g6207_1 g6207_0 0 netg6207
X394 g4997_1 g4997_2 0 netg4997
X395 g5458_0 g5458_1 0 netg5458
X396 g7381_1 g7381_0 0 netg7381
X397 g2404_1 g2404_0 0 netg2404
X398 g3468_1 g3468_0 0 netg3468
X399 g4256_1 g4256_0 0 netg4256
X400 g5298_1 g5298_0 0 netg5298
X401 g6141_1 g6141_0 0 netg6141
X402 g6175_0 g6175_1 0 netg6175
X403 g1948_2 g1948_0 0 netg1948
X404 g5330_1 g5330_0 0 netg5330
X405 g2786_0 g2786_1 0 netg2786
X406 g4226_0 g4226_1 0 netg4226
X407 g5143_0 g5143_1 0 netg5143
X408 g2792_0 g2792_1 0 netg2792
X409 g6507_0 g6507_1 0 netg6507
X410 g3570_1 g3570_0 0 netg3570
X411 g6259_2 g6259_1 0 netg6259
X412 g5606_1 g5606_0 0 netg5606
X413 g2835_0 g2835_1 0 netg2835
X414 g1533_1 g1533_0 0 netg1533
X415 g6820_1 g6820_0 0 netg6820
X416 g3547_0 g3547_1 0 netg3547
X417 g7347_0 g7347_1 0 netg7347
X418 g3717_1 g3717_0 0 netg3717
X419 g5592_1 g5592_0 0 netg5592
X420 g6073_0 g6073_1 0 netg6073
X421 g4424_0 g4424_1 0 netg4424
X422 g1582_0 g1582_1 0 netg1582
X423 g6902_0 g6902_1 0 netg6902
X424 g5706_1 g5706_0 0 netg5706
X425 g1227_1 g1227_0 0 netg1227
X426 g2846_0 g2846_1 0 netg2846
X427 g1173_0 g1173_1 0 netg1173
X428 g5769_1 g5769_0 0 netg5769
X429 g2785_0 g2785_1 0 netg2785
X430 g7332_1 g7332_0 0 netg7332
X431 g1481_1 g1481_0 0 netg1481
X432 g3541_1 g3541_0 0 netg3541
X433 g3096_2 g3096_1 0 netg3096
X434 g4452_1 g4452_0 0 netg4452
X435 g7183_0 g7183_1 0 netg7183
X436 g1457_1 g1457_0 0 netg1457
X437 g6737_1 g6737_0 0 netg6737
X438 g7013_1 g7013_0 0 netg7013
X439 g6697_0 g6697_1 0 netg6697
X440 g3915_1 g3915_0 0 netg3915
X441 g6460_1 g6460_0 0 netg6460
X442 g5476_1 g5476_0 0 netg5476
X443 g5114_1 g5114_0 0 netg5114
X444 g7092_1 g7092_0 0 netg7092
X445 g7249_0 g7249_1 0 netg7249
X446 g6244_0 g6244_1 0 netg6244
X447 g3578_1 g3578_0 0 netg3578
X448 x231_0 x231_1 0 netx231
X449 g7279_0 g7279_1 0 netg7279
X450 g6088_1 g6088_0 0 netg6088
X451 g5546_0 g5546_2 0 netg5546
X452 g6696_0 g6696_1 0 netg6696
X453 g4340_1 g4340_0 0 netg4340
X454 g6008_0 g6008_1 0 netg6008
X455 g7076_1 g7076_0 0 netg7076
X456 g5776_0 g5776_1 0 netg5776
X457 g6229_1 g6229_0 0 netg6229
X458 g1051_2 g1051_0 0 netg1051
X459 g2435_0 g2435_2 0 netg2435
X460 g3900_1 g3900_0 0 netg3900
X461 g455_0 g455_1 0 netg455
X462 g6684_0 g6684_1 0 netg6684
X463 g6006_1 g6006_0 0 netg6006
X464 g1314_1 g1314_0 0 netg1314
X465 g5238_1 g5238_0 0 netg5238
X466 g5538_1 g5538_0 0 netg5538
X467 g3573_1 g3573_0 0 netg3573
X468 g5362_1 g5362_0 0 netg5362
X469 g5252_1 g5252_0 0 netg5252
X470 g6135_0 g6135_1 0 netg6135
X471 g4023_0 g4023_1 0 netg4023
X472 g7442_1 g7442_0 0 netg7442
X473 g910_1 g910_2 0 netg910
X474 g5671_1 g5671_2 0 netg5671
X475 g1929_0 g1929_1 0 netg1929
X476 g4137_0 g4137_1 0 netg4137
X477 g1359_0 g1359_1 0 netg1359
X478 g6648_1 g6648_0 0 netg6648
X479 g6940_0 g6940_1 0 netg6940
X480 g6099_0 g6099_1 0 netg6099
X481 g6362_1 g6362_0 0 netg6362
X482 g4321_0 g4321_1 0 netg4321
X483 g3920_1 g3920_0 0 netg3920
X484 g5540_1 g5540_2 0 netg5540
X485 g4160_0 g4160_1 0 netg4160
X486 g6936_1 g6936_0 0 netg6936
X487 g7185_1 g7185_0 0 netg7185
X488 g6665_0 g6665_1 0 netg6665
X489 g1939_0 g1939_1 0 netg1939
X490 g6996_1 g6996_0 0 netg6996
X491 g6529_1 g6529_0 0 netg6529
X492 g1232_0 g1232_1 0 netg1232
X493 g3529_1 g3529_0 0 netg3529
X494 g6191_1 g6191_0 0 netg6191
X495 g3198_1 g3198_2 0 netg3198
X496 g4328_0 g4328_1 0 netg4328
X497 g3514_1 g3514_0 0 netg3514
X498 g7022_1 g7022_0 0 netg7022
X499 g7198_0 g7198_1 0 netg7198
X500 g1431_0 g1431_1 0 netg1431
X501 g2701_1 g2701_2 0 netg2701
X502 g7353_1 g7353_0 0 netg7353
X503 g4053_0 g4053_1 0 netg4053
X504 g5410_0 g5410_1 0 netg5410
X505 g6525_1 g6525_0 0 netg6525
X506 x281_1 x281_0 0 netx281
X507 g4332_1 g4332_0 0 netg4332
X508 g2558_2 g2558_1 0 netg2558
X509 g2914_1 g2914_0 0 netg2914
X510 g7107_0 g7107_1 0 netg7107
X511 g6186_1 g6186_0 0 netg6186
X512 g7228_1 g7228_2 0 netg7228
X513 g4173_1 g4173_0 0 netg4173
X514 g6356_1 g6356_0 0 netg6356
X515 g6317_0 g6317_1 0 netg6317
X516 g5443_1 g5443_0 0 netg5443
X517 g1999_0 g1999_1 0 netg1999
X518 g6163_1 g6163_0 0 netg6163
X519 g6731_0 g6731_1 0 netg6731
X520 g4134_1 g4134_0 0 netg4134
X521 g1162_1 g1162_0 0 netg1162
X522 g6298_0 g6298_1 0 netg6298
X523 g4286_0 g4286_1 0 netg4286
X524 g6694_1 g6694_0 0 netg6694
X525 g1408_0 g1408_1 0 netg1408
X526 g6087_0 g6087_1 0 netg6087
X527 g1231_0 g1231_1 0 netg1231
X528 x402_1 x402_0 0 netx402
X529 g5423_0 g5423_1 0 netg5423
X530 g5992_0 g5992_1 0 netg5992
X531 g3508_1 g3508_0 0 netg3508
X532 g2823_0 g2823_1 0 netg2823
X533 g6169_0 g6169_1 0 netg6169
X534 g4062_1 g4062_0 0 netg4062
X535 g4129_0 g4129_1 0 netg4129
X536 g2795_0 g2795_1 0 netg2795
X537 g2923_1 g2923_0 0 netg2923
X538 g4203_0 g4203_1 0 netg4203
X539 g4057_1 g4057_0 0 netg4057
X540 g1886_1 g1886_0 0 netg1886
X541 x121_1 x121_0 0 netx121
X542 g5994_1 g5994_0 0 netg5994
X543 g6395_0 g6395_1 0 netg6395
X544 g6166_1 g6166_0 0 netg6166
X545 g1921_1 g1921_0 0 netg1921
X546 x291_1 x291_0 0 netx291
X547 g5982_1 g5982_0 0 netg5982
X548 g5408_0 g5408_1 0 netg5408
X549 g6333_1 g6333_0 0 netg6333
X550 g1168_1 g1168_0 0 netg1168
X551 g1394_1 g1394_0 0 netg1394
X552 g6440_0 g6440_1 0 netg6440
X553 g5354_1 g5354_0 0 netg5354
X554 g6437_0 g6437_1 0 netg6437
X555 g865_1 g865_2 0 netg865
X556 g2931_0 g2931_1 0 netg2931
X557 g5135_0 g5135_1 0 netg5135
X558 g6994_1 g6994_0 0 netg6994
X559 g6194_1 g6194_0 0 netg6194
X560 g752_1 g752_0 0 netg752
X561 g7270_1 g7270_0 0 netg7270
X562 x11_1 x11_0 0 netx11
X563 g4108_0 g4108_1 0 netg4108
X564 g6502_2 g6502_0 0 netg6502
X565 g3904_1 g3904_0 0 netg3904
X566 g1382_1 g1382_0 0 netg1382
X567 g3497_1 g3497_0 0 netg3497
X568 g6587_1 g6587_0 0 netg6587
X569 g4242_1 g4242_0 0 netg4242
X570 g4121_0 g4121_2 0 netg4121
X571 g3081_0 g3081_1 0 netg3081
X572 g6549_1 g6549_0 0 netg6549
X573 g3129_2 g3129_1 0 netg3129
X574 g1934_0 g1934_1 0 netg1934
X575 g3577_1 g3577_0 0 netg3577
X576 g2793_1 g2793_0 0 netg2793
X577 g5604_1 g5604_0 0 netg5604
X578 g1925_0 g1925_1 0 netg1925
X579 g4264_0 g4264_1 0 netg4264
X580 g6586_0 g6586_1 0 netg6586
X581 g4223_0 g4223_1 0 netg4223
X582 g3565_0 g3565_1 0 netg3565
X583 g6390_0 g6390_1 0 netg6390
X584 g7025_1 g7025_0 0 netg7025
X585 g3049_1 g3049_0 0 netg3049
X586 g6743_1 g6743_0 0 netg6743
X587 g6101_1 g6101_0 0 netg6101
X588 g1228_1 g1228_0 0 netg1228
X589 g6451_1 g6451_0 0 netg6451
X590 g2790_1 g2790_0 0 netg2790
X591 g3067_0 g3067_1 0 netg3067
X592 g6138_0 g6138_1 0 netg6138
X593 x371_1 x371_0 0 netx371
X594 g1172_0 g1172_1 0 netg1172
X595 g2762_1 g2762_0 0 netg2762
X596 g5599_1 g5599_0 0 netg5599
X597 g5364_0 g5364_1 0 netg5364
X598 g5318_0 g5318_1 0 netg5318
X599 g6539_0 g6539_1 0 netg6539
X600 g6742_0 g6742_1 0 netg6742
X601 g7082_0 g7082_1 0 netg7082
X602 g1930_0 g1930_1 0 netg1930
X603 g4336_1 g4336_0 0 netg4336
X604 g4529_1 g4529_0 0 netg4529
X605 g5596_1 g5596_0 0 netg5596
X606 g1369_2 g1369_0 0 netg1369
X607 x512_1 x512_0 0 netx512
X608 g4058_0 g4058_1 0 netg4058
X609 g1906_1 g1906_0 0 netg1906
X610 g4402_0 g4402_1 0 netg4402
X611 g2833_1 g2833_0 0 netg2833
X612 g5775_1 g5775_0 0 netg5775
X613 g2998_1 g2998_0 0 netg2998
X614 g3556_0 g3556_1 0 netg3556
X615 g3365_0 g3365_1 0 netg3365
X616 g5511_0 g5511_1 0 netg5511
X617 g1251_0 g1251_1 0 netg1251
X618 g4110_1 g4110_0 0 netg4110
X619 g6649_1 g6649_0 0 netg6649
X620 g5674_0 g5674_2 0 netg5674
X621 g6150_1 g6150_0 0 netg6150
X622 g7340_0 g7340_1 0 netg7340
X623 g1033_2 g1033_1 0 netg1033
X624 g6208_1 g6208_0 0 netg6208
X625 g5969_1 g5969_0 0 netg5969
X626 g6662_0 g6662_1 0 netg6662
X627 g4132_1 g4132_0 0 netg4132
X628 g5417_1 g5417_0 0 netg5417
X629 g3109_0 g3109_1 0 netg3109
X630 g2815_0 g2815_1 0 netg2815
X631 g7045_0 g7045_1 0 netg7045
X632 g3974_0 g3974_1 0 netg3974
X633 x481_0 x481_1 0 netx481
X634 x412_1 x412_0 0 netx412
X635 g6624_1 g6624_0 0 netg6624
X636 g5392_1 g5392_0 0 netg5392
X637 g3477_1 g3477_0 0 netg3477
X638 g1230_1 g1230_0 0 netg1230
X639 g2944_0 g2944_1 0 netg2944
X640 g4334_1 g4334_0 0 netg4334
X641 g3682_0 g3682_1 0 netg3682
X642 g7396_1 g7396_0 0 netg7396
X643 g1480_0 g1480_1 0 netg1480
X644 g2780_1 g2780_0 0 netg2780
X645 g4299_1 g4299_0 0 netg4299
X646 g7186_1 g7186_0 0 netg7186
X647 g4308_1 g4308_0 0 netg4308
X648 g2707_0 g2707_2 0 netg2707
X649 g7272_0 g7272_1 0 netg7272
X650 g6873_1 g6873_0 0 netg6873
X651 g5247_1 g5247_0 0 netg5247
X652 g5856_0 g5856_1 0 netg5856
X653 g2941_0 g2941_1 0 netg2941
X654 g5997_1 g5997_0 0 netg5997
X655 g6040_0 g6040_1 0 netg6040
X656 g1261_1 g1261_0 0 netg1261
X657 g3555_1 g3555_0 0 netg3555
X658 g6292_1 g6292_0 0 netg6292
X659 g5684_1 g5684_0 0 netg5684
X660 g4288_0 g4288_1 0 netg4288
X661 g7175_1 g7175_0 0 netg7175
X662 g4618_0 g4618_1 0 netg4618
X663 g7403_1 g7403_0 0 netg7403
X664 g4208_1 g4208_0 0 netg4208
X665 g2644_2 g2644_1 0 netg2644
X666 g4261_0 g4261_1 0 netg4261
X667 g3438_2 g3438_1 0 netg3438
X668 g7409_1 g7409_0 0 netg7409
X669 g4234_0 g4234_1 0 netg4234
X670 g1922_0 g1922_1 0 netg1922
X671 g1254_0 g1254_1 0 netg1254
X672 g4311_1 g4311_0 0 netg4311
X673 g6082_1 g6082_0 0 netg6082
X674 g3349_2 g3349_1 0 netg3349
X675 g1893_1 g1893_0 0 netg1893
X676 g6845_0 g6845_1 0 netg6845
X677 g5788_1 g5788_0 0 netg5788
X678 g6929_1 g6929_0 0 netg6929
X679 g694_1 g694_0 0 netg694
X680 g5071_2 g5071_0 0 netg5071
X681 g4018_1 g4018_0 0 netg4018
X682 g4398_1 g4398_0 0 netg4398
X683 g6079_0 g6079_1 0 netg6079
X684 g7277_0 g7277_1 0 netg7277
X685 x52_0 x52_1 0 netx52
X686 g1406_1 g1406_0 0 netg1406
X687 g7439_1 g7439_0 0 netg7439
X688 g6695_1 g6695_0 0 netg6695
X689 g6490_1 g6490_0 0 netg6490
X690 g690_1 g690_0 0 netg690
X691 g6825_1 g6825_0 0 netg6825
X692 g5119_1 g5119_0 0 netg5119
X693 g7196_1 g7196_0 0 netg7196
X694 g6404_1 g6404_0 0 netg6404
X695 g5607_0 g5607_1 0 netg5607
X696 g1377_1 g1377_0 0 netg1377
X697 g4097_1 g4097_0 0 netg4097
X698 g5321_1 g5321_0 0 netg5321
X699 g3417_2 g3417_0 0 netg3417
X700 g913_1 g913_2 0 netg913
X701 g6461_0 g6461_1 0 netg6461
X702 g2779_1 g2779_0 0 netg2779
X703 g97_0 g97_1 0 netg97
X704 g985_0 g985_2 0 netg985
X705 g1259_0 g1259_1 0 netg1259
X706 g3046_1 g3046_0 0 netg3046
X707 g7389_0 g7389_1 0 netg7389
X708 g1516_0 g1516_1 0 netg1516
X709 g5367_0 g5367_1 0 netg5367
X710 g7026_1 g7026_0 0 netg7026
X711 g6579_1 g6579_0 0 netg6579
X712 g5360_0 g5360_1 0 netg5360
X713 g2477_2 g2477_1 0 netg2477
X714 g7168_0 g7168_1 0 netg7168
X715 g3892_1 g3892_0 0 netg3892
X716 g4295_1 g4295_0 0 netg4295
X717 g6365_1 g6365_0 0 netg6365
X718 g6819_1 g6819_0 0 netg6819
X719 g560_1 g560_0 0 netg560
X720 g2783_0 g2783_1 0 netg2783
X721 g5605_0 g5605_1 0 netg5605
X722 g3412_0 g3412_1 0 netg3412
X723 g3085_1 g3085_0 0 netg3085
X724 g5961_0 g5961_1 0 netg5961
X725 g1535_1 g1535_0 0 netg1535
X726 g6967_2 g6967_1 0 netg6967
X727 x401_1 x401_0 0 netx401
X728 g4182_1 g4182_0 0 netg4182
X729 g6888_1 g6888_0 0 netg6888
X730 g3982_0 g3982_1 0 netg3982
X731 g6672_1 g6672_0 0 netg6672
X732 g4112_0 g4112_1 0 netg4112
X733 g5874_1 g5874_0 0 netg5874
X734 g5317_0 g5317_1 0 netg5317
X735 g5181_1 g5181_0 0 netg5181
X736 g5890_1 g5890_0 0 netg5890
X737 g2221_0 g2221_1 0 netg2221
X738 g2810_1 g2810_0 0 netg2810
X739 g7214_0 g7214_1 0 netg7214
X740 g5200_0 g5200_1 0 netg5200
X741 g4202_0 g4202_1 0 netg4202
X742 g6516_1 g6516_0 0 netg6516
X743 g7395_1 g7395_0 0 netg7395
X744 g3410_0 g3410_1 0 netg3410
X745 g6469_0 g6469_1 0 netg6469
X746 g4278_0 g4278_1 0 netg4278
X747 g3895_0 g3895_1 0 netg3895
X748 g6405_1 g6405_0 0 netg6405
X749 g7299_1 g7299_0 0 netg7299
X750 g6606_0 g6606_1 0 netg6606
X751 g6609_0 g6609_1 0 netg6609
X752 g6015_1 g6015_0 0 netg6015
X753 g6999_0 g6999_1 0 netg6999
X754 g1009_1 g1009_2 0 netg1009
X755 g7192_0 g7192_1 0 netg7192
X756 g2921_0 g2921_1 0 netg2921
X757 g1003_1 g1003_2 0 netg1003
X758 g4229_0 g4229_1 0 netg4229
X759 g4150_0 g4150_1 0 netg4150
X760 g4042_1 g4042_0 0 netg4042
X761 g7064_1 g7064_0 0 netg7064
X762 g6170_0 g6170_1 0 netg6170
X763 x292_1 x292_0 0 netx292
X764 g6656_1 g6656_0 0 netg6656
X765 g7407_1 g7407_0 0 netg7407
X766 g4432_0 g4432_1 0 netg4432
X767 g4072_1 g4072_0 0 netg4072
X768 g2951_0 g2951_1 0 netg2951
X769 g4136_1 g4136_0 0 netg4136
X770 g4049_1 g4049_0 0 netg4049
X771 g3423_1 g3423_2 0 netg3423
X772 g4276_1 g4276_0 0 netg4276
X773 g3471_1 g3471_0 0 netg3471
X774 g5470_0 g5470_1 0 netg5470
X775 g3469_0 g3469_1 0 netg3469
X776 g4316_0 g4316_1 0 netg4316
X777 g6532_0 g6532_1 0 netg6532
X778 g2704_1 g2704_2 0 netg2704
X779 g6522_0 g6522_1 0 netg6522
X780 g7102_0 g7102_1 0 netg7102
X781 g6358_1 g6358_0 0 netg6358
X782 g6072_1 g6072_0 0 netg6072
X783 g6651_1 g6651_0 0 netg6651
X784 g3345_0 g3345_1 0 netg3345
X785 g6083_0 g6083_1 0 netg6083
X786 g4304_1 g4304_0 0 netg4304
X787 g4236_0 g4236_1 0 netg4236
X788 g3534_0 g3534_1 0 netg3534
X789 g4051_1 g4051_0 0 netg4051
X790 g4104_0 g4104_1 0 netg4104
X791 g7074_0 g7074_1 0 netg7074
X792 g6415_0 g6415_1 0 netg6415
X793 g3575_1 g3575_0 0 netg3575
X794 g5765_1 g5765_0 0 netg5765
X795 g7210_1 g7210_0 0 netg7210
X796 g6582_1 g6582_0 0 netg6582
X797 g4133_1 g4133_0 0 netg4133
X798 g7219_2 g7219_0 0 netg7219
X799 g6409_0 g6409_1 0 netg6409
X800 g7081_1 g7081_0 0 netg7081
X801 g5018_1 g5018_2 0 netg5018
X802 x482_0 x482_1 0 netx482
X803 g7123_1 g7123_0 0 netg7123
X804 g3063_1 g3063_0 0 netg3063
X805 g5667_0 g5667_1 0 netg5667
X806 g2820_0 g2820_1 0 netg2820
X807 g5466_0 g5466_1 0 netg5466
X808 g2634_1 g2634_0 0 netg2634
X809 g7127_0 g7127_1 0 netg7127
X810 g4209_1 g4209_0 0 netg4209
X811 g3898_1 g3898_0 0 netg3898
X812 g5991_1 g5991_0 0 netg5991
X813 g4277_1 g4277_0 0 netg4277
X814 g4019_0 g4019_1 0 netg4019
X815 g5525_1 g5525_0 0 netg5525
X816 g4059_0 g4059_1 0 netg4059
X817 g2765_0 g2765_1 0 netg2765
X818 g6926_1 g6926_0 0 netg6926
X819 g4038_1 g4038_0 0 netg4038
X820 g6536_0 g6536_1 0 netg6536
X821 g1509_1 g1509_0 0 netg1509
X822 g6055_0 g6055_1 0 netg6055
X823 g3492_0 g3492_1 0 netg3492
X824 g2915_1 g2915_0 0 netg2915
X825 g6115_1 g6115_0 0 netg6115
X826 g2830_1 g2830_0 0 netg2830
X827 g6211_1 g6211_0 0 netg6211
X828 g5428_1 g5428_0 0 netg5428
X829 g6165_1 g6165_0 0 netg6165
X830 g1477_1 g1477_0 0 netg1477
X831 g7211_1 g7211_0 0 netg7211
X832 g6316_0 g6316_1 0 netg6316
X833 g4052_1 g4052_0 0 netg4052
X834 g4176_0 g4176_1 0 netg4176
X835 g2225_0 g2225_1 0 netg2225
X836 g7241_1 g7241_0 0 netg7241
X837 g6185_0 g6185_1 0 netg6185
X838 g6718_0 g6718_1 0 netg6718
X839 g2504_0 g2504_2 0 netg2504
X840 g4071_0 g4071_1 0 netg4071
X841 g7101_0 g7101_1 0 netg7101
X842 g6935_0 g6935_1 0 netg6935
X843 g6875_0 g6875_1 0 netg6875
X844 g5972_0 g5972_1 0 netg5972
X845 g5142_1 g5142_0 0 netg5142
X846 g4333_0 g4333_1 0 netg4333
X847 g4128_0 g4128_1 0 netg4128
X848 g2534_2 g2534_1 0 netg2534
X849 g6245_0 g6245_1 0 netg6245
X850 g4418_1 g4418_0 0 netg4418
X851 g5619_2 g5619_1 0 netg5619
X852 g5794_1 g5794_0 0 netg5794
X853 g1923_1 g1923_0 0 netg1923
X854 g7263_0 g7263_1 0 netg7263
X855 g5279_1 g5279_0 0 netg5279
X856 g3913_0 g3913_1 0 netg3913
X857 g5740_0 g5740_2 0 netg5740
X858 g6171_0 g6171_1 0 netg6171
X859 g5430_0 g5430_1 0 netg5430
X860 g1393_1 g1393_0 0 netg1393
X861 g2359_2 g2359_1 0 netg2359
X862 g892_1 g892_2 0 netg892
X863 g3003_0 g3003_1 0 netg3003
X864 g5993_1 g5993_0 0 netg5993
X865 g7218_1 g7218_0 0 netg7218
X866 g1405_0 g1405_1 0 netg1405
X867 g5916_1 g5916_0 0 netg5916
X868 g6312_1 g6312_0 0 netg6312
X869 g4665_1 g4665_0 0 netg4665
X870 g3702_2 g3702_1 0 netg3702
X871 g4141_0 g4141_1 0 netg4141
X872 g6190_1 g6190_0 0 netg6190
X873 g2796_0 g2796_1 0 netg2796
X874 g1358_0 g1358_1 0 netg1358
X875 g6974_1 g6974_0 0 netg6974
X876 g3051_1 g3051_0 0 netg3051
X877 g6889_1 g6889_0 0 netg6889
X878 g4253_1 g4253_0 0 netg4253
X879 g3981_0 g3981_1 0 netg3981
X880 g2710_2 g2710_0 0 netg2710
X881 g6972_1 g6972_0 0 netg6972
X882 g6158_0 g6158_2 0 netg6158
X883 g1894_1 g1894_0 0 netg1894
X884 g1960_0 g1960_1 0 netg1960
X885 g1176_1 g1176_0 0 netg1176
X886 g6065_1 g6065_0 0 netg6065
X887 g6963_1 g6963_0 0 netg6963
X888 g7023_0 g7023_1 0 netg7023
X889 x391_0 x391_1 0 netx391
X890 g2356_2 g2356_1 0 netg2356
X891 g1129_1 g1129_0 0 netg1129
X892 g6383_1 g6383_0 0 netg6383
X893 g2932_0 g2932_1 0 netg2932
X894 g7334_1 g7334_0 0 netg7334
X895 g6277_1 g6277_0 0 netg6277
X896 g3533_1 g3533_0 0 netg3533
X897 g5482_1 g5482_0 0 netg5482
X898 g3973_0 g3973_1 0 netg3973
X899 g7438_0 g7438_1 0 netg7438
X900 g6418_1 g6418_0 0 netg6418
X901 g7427_1 g7427_0 0 netg7427
X902 g7410_0 g7410_1 0 netg7410
X903 g4317_0 g4317_1 0 netg4317
X904 g3499_1 g3499_0 0 netg3499
X905 g6519_0 g6519_1 0 netg6519
X906 g2770_1 g2770_0 0 netg2770
X907 g3896_1 g3896_0 0 netg3896
X908 g1385_1 g1385_0 0 netg1385
X909 g4175_1 g4175_0 0 netg4175
X910 g7116_2 g7116_1 g7116_0 0 netg7116
X911 g3916_1 g3916_0 0 netg3916
X912 g3572_1 g3572_0 0 netg3572
X913 g6100_1 g6100_0 0 netg6100
X914 g5361_1 g5361_0 0 netg5361
X915 g5347_1 g5347_0 0 netg5347
X916 g2229_1 g2229_0 0 netg2229
X917 x452_0 x452_1 0 netx452
X918 g6330_1 g6330_0 0 netg6330
X919 g5128_2 g5128_1 g5128_0 0 netg5128
X920 g7294_1 g7294_0 0 netg7294
X921 g5349_1 g5349_0 0 netg5349
X922 g1436_0 g1436_1 0 netg1436
X923 g6436_1 g6436_0 0 netg6436
X924 g3117_0 g3117_1 g3117_2 0 netg3117
X925 g6513_1 g6513_0 0 netg6513
X926 g5483_0 g5483_1 0 netg5483
X927 g6604_1 g6604_0 0 netg6604
X928 g7217_1 g7217_0 0 netg7217
X929 g3413_0 g3413_1 0 netg3413
X930 g5320_1 g5320_0 0 netg5320
X931 g6173_1 g6173_0 0 netg6173
X932 g4354_0 g4354_1 0 netg4354
X933 g5786_1 g5786_0 0 netg5786
X934 g1453_1 g1453_0 0 netg1453
X935 g6736_0 g6736_1 0 netg6736
X936 g7103_0 g7103_1 0 netg7103
X937 g4438_0 g4438_1 0 netg4438
X938 g3977_1 g3977_0 0 netg3977
X939 g6329_0 g6329_1 0 netg6329
X940 g3324_1 g3324_2 g3324_0 0 netg3324
X941 g6805_0 g6805_1 g6805_2 0 netg6805
X942 g6823_1 g6823_0 0 netg6823
X943 g4244_1 g4244_0 0 netg4244
X944 g1490_1 g1490_0 0 netg1490
X945 g5328_0 g5328_1 0 netg5328
X946 g2543_0 g2543_1 g2543_2 0 netg2543
X947 g6255_1 g6255_0 g6255_2 0 netg6255
X948 g6195_1 g6195_0 0 netg6195
X949 g3481_0 g3481_1 0 netg3481
X950 g5970_1 g5970_0 0 netg5970
X951 g6033_1 g6033_0 0 netg6033
X952 g5030_2 g5030_1 g5030_0 0 netg5030
X953 g5167_2 g5167_0 0 netg5167
X954 g6903_1 g6903_0 0 netg6903
X955 g4273_0 g4273_1 0 netg4273
X956 g6037_0 g6037_1 0 netg6037
X957 g6659_0 g6659_1 0 netg6659
X958 g4629_1 g4629_0 0 netg4629
X959 g7342_1 g7342_0 0 netg7342
X960 g1225_0 g1225_1 0 netg1225
X961 g5583_0 g5583_1 0 netg5583
X962 g1045_0 g1045_2 0 netg1045
X963 g6725_2 g6725_0 0 netg6725
X964 g6886_0 g6886_1 0 netg6886
X965 g7020_0 g7020_1 0 netg7020
X966 g6634_2 g6634_1 g6634_0 0 netg6634
X967 g4227_1 g4227_0 0 netg4227
X968 g1039_1 g1039_2 0 netg1039
X969 g1166_0 g1166_1 0 netg1166
X970 g2513_1 g2513_2 g2513_0 0 netg2513
X971 g566_0 g566_1 0 netg566
X972 g5963_1 g5963_0 0 netg5963
X973 g2519_1 g2519_2 0 netg2519
X974 g6538_1 g6538_0 0 netg6538
X975 g7350_1 g7350_0 0 netg7350
X976 g6043_1 g6043_0 0 netg6043
X977 g1305_0 g1305_1 0 netg1305
X978 g7209_0 g7209_1 0 netg7209
X979 g5691_0 g5691_2 0 netg5691
X980 g7068_1 g7068_0 g7068_2 0 netg7068
X981 g3478_1 g3478_0 0 netg3478
X982 g1130_1 g1130_0 0 netg1130
X983 g6053_0 g6053_1 0 netg6053
X984 g6328_1 g6328_0 0 netg6328
X985 g1475_0 g1475_1 0 netg1475
X986 g4437_1 g4437_0 0 netg4437
X987 g4241_1 g4241_0 0 netg4241
X988 g6921_1 g6921_2 g6921_0 0 netg6921
X989 g1384_1 g1384_0 0 netg1384
X990 g5355_0 g5355_1 0 netg5355
X991 g5488_1 g5488_0 0 netg5488
X992 x422_1 x422_0 0 netx422
X993 g4938_0 g4938_1 0 netg4938
X994 g3495_0 g3495_1 0 netg3495
X995 g6001_0 g6001_1 0 netg6001
X996 g4279_0 g4279_1 0 netg4279
X997 g6622_1 g6622_0 0 netg6622
X998 g922_2 g922_0 0 netg922
X999 x381_1 x381_0 0 netx381
X1000 g6948_1 g6948_2 0 netg6948
X1001 x361_0 x361_1 0 netx361
X1002 g5424_0 g5424_1 0 netg5424
X1003 g4056_1 g4056_0 0 netg4056
X1004 g2828_0 g2828_1 0 netg2828
X1005 g1000_1 g1000_2 0 netg1000
X1006 g5059_2 g5059_0 g5059_1 0 netg5059
X1007 g6168_1 g6168_0 0 netg6168
X1008 g4331_0 g4331_1 0 netg4331
X1009 g6484_0 g6484_1 g6484_2 0 netg6484
X1010 g3488_1 g3488_0 0 netg3488
X1011 g1390_2 g1390_0 g1390_1 0 netg1390
X1012 g3456_1 g3456_2 g3456_0 0 netg3456
X1013 g5429_0 g5429_1 0 netg5429
X1014 g1386_0 g1386_1 0 netg1386
X1015 g6220_0 g6220_2 0 netg6220
X1016 g3288_2 g3288_1 0 netg3288
X1017 g6533_1 g6533_0 0 netg6533
X1018 g5113_1 g5113_0 0 netg5113
X1019 g2949_0 g2949_1 0 netg2949
X1020 g6489_0 g6489_1 0 netg6489
X1021 g6655_1 g6655_0 0 netg6655
X1022 g3099_1 g3099_0 0 netg3099
X1023 g7383_1 g7383_0 0 netg7383
X1024 g7208_0 g7208_1 0 netg7208
X1025 g3000_1 g3000_0 0 netg3000
X1026 g6089_0 g6089_1 0 netg6089
X1027 g4293_1 g4293_0 0 netg4293
X1028 g6918_0 g6918_1 0 netg6918
X1029 g7388_1 g7388_0 0 netg7388
X1030 g4069_0 g4069_1 0 netg4069
X1031 x101_1 x101_0 0 netx101
X1032 g6119_0 g6119_1 0 netg6119
X1033 g5267_1 g5267_0 0 netg5267
X1034 g2576_2 g2576_0 g2576_1 0 netg2576
X1035 g6660_0 g6660_1 0 netg6660
X1036 g4442_1 g4442_0 0 netg4442
X1037 g6266_2 g6266_0 g6266_1 0 netg6266
X1038 g2740_2 g2740_0 g2740_1 0 netg2740
X1039 g7165_0 g7165_1 0 netg7165
X1040 g2492_2 g2492_1 0 netg2492
X1041 g7406_1 g7406_0 0 netg7406
X1042 g6901_0 g6901_1 0 netg6901
X1043 g5444_0 g5444_1 0 netg5444
X1044 g3544_0 g3544_1 0 netg3544
X1045 g5050_1 g5050_0 g5050_2 0 netg5050
X1046 g7206_1 g7206_0 0 netg7206
X1047 g2838_1 g2838_0 0 netg2838
X1048 g1223_1 g1223_0 0 netg1223
X1049 g1557_1 g1557_0 0 netg1557
X1050 g6790_2 g6790_1 g6790_0 0 netg6790
X1051 g4204_0 g4204_1 0 netg4204
X1052 g6048_1 g6048_0 0 netg6048
X1053 g6613_1 g6613_0 0 netg6613
X1054 g5357_0 g5357_1 0 netg5357
X1055 g2483_2 g2483_1 0 netg2483
X1056 g4275_0 g4275_1 0 netg4275
X1057 g979_0 g979_1 g979_2 0 netg979
X1058 g4228_1 g4228_0 0 netg4228
X1059 g3531_0 g3531_1 0 netg3531
X1060 g5024_2 g5024_0 0 netg5024
X1061 g4450_0 g4450_1 0 netg4450
X1062 g2759_1 g2759_0 0 netg2759
X1063 g5885_0 g5885_1 0 netg5885
X1064 g3062_1 g3062_0 0 netg3062
X1065 g6381_0 g6381_1 0 netg6381
X1066 g7349_1 g7349_0 0 netg7349
X1067 g6511_0 g6511_1 0 netg6511
X1068 g4976_2 g4976_1 g4976_0 0 netg4976
X1069 g4007_1 g4007_0 0 netg4007
X1070 x421_1 x421_0 0 netx421
X1071 g5325_1 g5325_0 0 netg5325
X1072 g6433_2 g6433_0 g6433_1 0 netg6433
X1073 g7079_1 g7079_0 0 netg7079
X1074 g6692_0 g6692_1 0 netg6692
X1075 g3102_1 g3102_0 0 netg3102
X1076 g1161_0 g1161_1 0 netg1161
X1077 g6462_1 g6462_0 0 netg6462
X1078 g970_0 g970_1 g970_2 0 netg970
X1079 g5245_0 g5245_1 0 netg5245
X1080 g3919_0 g3919_1 0 netg3919
X1081 g1154_0 g1154_1 0 netg1154
X1082 g1407_1 g1407_0 0 netg1407
X1083 g6980_0 g6980_2 g6980_1 0 netg6980
X1084 g4024_1 g4024_0 0 netg4024
X1085 g3466_0 g3466_1 0 netg3466
X1086 g7167_1 g7167_0 0 netg7167
X1087 g4083_1 g4083_0 0 netg4083
X1088 g5990_1 g5990_0 0 netg5990
X1089 g7254_1 g7254_0 0 netg7254
X1090 g7432_0 g7432_1 0 netg7432
X1091 g7161_2 g7161_0 g7161_1 0 netg7161
X1092 g2999_0 g2999_1 0 netg2999
X1093 g2447_0 g2447_1 g2447_2 0 netg2447
X1094 g7413_1 g7413_0 0 netg7413
X1095 g2936_0 g2936_1 0 netg2936
X1096 x62_1 x62_0 0 netx62
X1097 g4433_0 g4433_1 0 netg4433
X1098 g1082_2 g1082_1 0 netg1082
X1099 g6388_1 g6388_0 0 netg6388
X1100 g4335_1 g4335_0 0 netg4335
X1101 g3985_0 g3985_1 0 netg3985
X1102 g7016_0 g7016_1 0 netg7016
X1103 g5296_1 g5296_0 0 netg5296
X1104 g5348_1 g5348_0 0 netg5348
X1105 g4037_1 g4037_0 0 netg4037
X1106 g4330_1 g4330_0 0 netg4330
X1107 g2441_1 g2441_0 g2441_2 0 netg2441
X1108 x172_1 x172_0 0 netx172
X1109 g5625_1 g5625_2 0 netg5625
X1110 g5104_2 g5104_0 g5104_1 0 netg5104
X1111 g5528_1 g5528_0 0 netg5528
X1112 g931_2 g931_1 g931_0 0 netg931
X1113 g7345_1 g7345_0 0 netg7345
X1114 g5120_0 g5120_1 0 netg5120
X1115 g6971_1 g6971_0 0 netg6971
X1116 g5131_0 g5131_2 0 netg5131
X1117 g5273_0 g5273_1 0 netg5273
X1118 g5184_1 g5184_0 0 netg5184
X1119 g6526_0 g6526_1 0 netg6526
X1120 g6983_0 g6983_1 0 netg6983
X1121 g6735_0 g6735_1 0 netg6735
X1122 g1428_1 g1428_0 0 netg1428
X1123 g2224_1 g2224_0 0 netg2224
X1124 x92_0 x92_1 0 netx92
X1125 g7371_0 g7371_1 0 netg7371
X1126 g7077_0 g7077_1 0 netg7077
X1127 g7296_0 g7296_1 0 netg7296
X1128 x501_0 x501_1 0 netx501
X1129 g880_2 g880_0 0 netg880
X1130 g6130_1 g6130_0 0 netg6130
X1131 g83_0 g83_1 0 netg83
X1132 g7278_1 g7278_0 0 netg7278
X1133 g1531_1 g1531_0 0 netg1531
X1134 g2489_2 g2489_1 g2489_0 0 netg2489
X1135 g6307_1 g6307_0 0 netg6307
X1136 g6505_1 g6505_0 0 netg6505
X1137 g5767_1 g5767_0 0 netg5767
X1138 g6652_0 g6652_1 0 netg6652
X1139 g6291_1 g6291_0 0 netg6291
X1140 g5505_1 g5505_2 0 netg5505
X1141 x261_0 x261_1 0 netx261
X1142 g6172_0 g6172_1 0 netg6172
X1143 g5300_1 g5300_0 0 netg5300
X1144 g5833_1 g5833_0 0 netg5833
X1145 g6612_0 g6612_1 0 netg6612
X1146 g4416_1 g4416_0 0 netg4416
X1147 g4073_1 g4073_0 0 netg4073
X1148 g946_2 g946_1 0 netg946
X1149 g7124_0 g7124_1 0 netg7124
X1150 g3336_0 g3336_1 g3336_2 0 netg3336
X1151 g871_1 g871_2 0 netg871
X1152 g3216_0 g3216_2 g3216_1 0 netg3216
X1153 g2516_2 g2516_1 0 netg2516
X1154 g4011_1 g4011_0 0 netg4011
X1155 g3532_1 g3532_0 0 netg3532
X1156 g4186_1 g4186_0 0 netg4186
X1157 g4274_1 g4274_0 0 netg4274
X1158 g2674_1 g2674_2 g2674_0 0 netg2674
X1159 g4269_1 g4269_0 0 netg4269
X1160 g5229_2 g5229_1 g5229_0 0 netg5229
X1161 g7130_0 g7130_1 0 netg7130
X1162 g5223_2 g5223_1 g5223_0 0 netg5223
X1163 g3574_0 g3574_1 0 netg3574
X1164 g3525_0 g3525_1 0 netg3525
X1165 g5467_1 g5467_0 0 netg5467
X1166 g682_1 g682_0 0 netg682
X1167 g1132_0 g1132_1 0 netg1132
X1168 g856_2 g856_1 g856_0 0 netg856
X1169 g3890_0 g3890_1 0 netg3890
X1170 g1256_0 g1256_1 0 netg1256
X1171 g4235_1 g4235_0 0 netg4235
X1172 g3512_0 g3512_1 0 netg3512
X1173 g5077_0 g5077_2 0 netg5077
X1174 g868_2 g868_0 g868_1 0 netg868
X1175 g1410_0 g1410_1 0 netg1410
X1176 g2633_1 g2633_0 0 netg2633
X1177 g5000_0 g5000_2 0 netg5000
X1178 g6621_0 g6621_1 0 netg6621
X1179 g1888_0 g1888_1 0 netg1888
X1180 g6650_0 g6650_1 0 netg6650
X1181 g7113_0 g7113_1 0 netg7113
X1182 g5519_1 g5519_0 0 netg5519
X1183 g5920_1 g5920_2 0 netg5920
X1184 g886_0 g886_2 0 netg886
X1185 g3364_1 g3364_0 0 netg3364
X1186 g7271_1 g7271_0 0 netg7271
X1187 g5386_0 g5386_1 0 netg5386
X1188 g7426_0 g7426_1 0 netg7426
X1189 g5469_1 g5469_0 0 netg5469
X1190 g6878_0 g6878_1 0 netg6878
X1191 g4320_0 g4320_1 0 netg4320
X1192 g7140_0 g7140_1 0 netg7140
X1193 g1901_1 g1901_0 0 netg1901
X1194 g3065_1 g3065_0 0 netg3065
X1195 g5513_1 g5513_0 0 netg5513
X1196 g4946_2 g4946_0 g4946_1 0 netg4946
X1197 g7080_0 g7080_1 0 netg7080
X1198 g4439_0 g4439_1 0 netg4439
X1199 g3498_1 g3498_0 0 netg3498
X1200 g3078_0 g3078_1 0 netg3078
X1201 g5658_1 g5658_2 0 netg5658
X1202 g2609_2 g2609_1 0 netg2609
X1203 g3969_0 g3969_1 0 netg3969
X1204 g6699_0 g6699_1 0 netg6699
X1205 g1309_1 g1309_0 0 netg1309
X1206 g5640_0 g5640_2 0 netg5640
X1207 g5056_1 g5056_2 0 netg5056
X1208 g3339_2 g3339_1 0 netg3339
X1209 g6517_1 g6517_0 0 netg6517
X1210 g1257_1 g1257_0 0 netg1257
X1211 g5468_0 g5468_1 0 netg5468
X1212 g5331_1 g5331_0 0 netg5331
X1213 g5768_1 g5768_0 0 netg5768
X1214 g5543_1 g5543_0 g5543_2 0 netg5543
X1215 g3156_0 g3156_1 g3156_2 0 netg3156
X1216 g3905_0 g3905_1 0 netg3905
X1217 g3306_1 g3306_2 0 netg3306
X1218 g6506_0 g6506_1 0 netg6506
X1219 g5356_1 g5356_0 0 netg5356
X1220 g916_2 g916_1 0 netg916
X1221 g6394_0 g6394_1 0 netg6394
X1222 g5015_1 g5015_2 g5015_0 0 netg5015
X1223 g6422_1 g6422_0 0 netg6422
X1224 g3059_0 g3059_1 0 netg3059
X1225 g2811_1 g2811_0 0 netg2811
X1226 g3926_0 g3926_1 0 netg3926
X1227 g3110_0 g3110_2 g3110_1 0 netg3110
X1228 g1889_0 g1889_1 0 netg1889
X1229 g6925_0 g6925_1 0 netg6925
X1230 g6313_1 g6313_0 0 netg6313
X1231 g3055_1 g3055_0 0 netg3055
X1232 g4016_1 g4016_0 0 netg4016
X1233 g2653_2 g2653_0 0 netg2653
X1234 g6518_0 g6518_1 0 netg6518
X1235 g6010_0 g6010_1 0 netg6010
X1236 g3494_0 g3494_1 0 netg3494
X1237 g2928_0 g2928_1 0 netg2928
X1238 g4389_2 g4389_0 g4389_1 0 netg4389
X1239 g5953_0 g5953_1 0 netg5953
X1240 g2837_1 g2837_0 0 netg2837
X1241 g6499_2 g6499_0 0 netg6499
X1242 g6555_0 g6555_1 0 netg6555
X1243 g4341_0 g4341_1 0 netg4341
X1244 g3300_1 g3300_2 g3300_0 0 netg3300
X1245 g7072_0 g7072_1 0 netg7072
X1246 g5646_2 g5646_1 0 netg5646
X1247 g3312_1 g3312_2 0 netg3312
X1248 g4420_0 g4420_1 0 netg4420
X1249 g7253_0 g7253_1 0 netg7253
X1250 g6410_1 g6410_0 0 netg6410
X1251 g1018_1 g1018_2 g1018_0 0 netg1018
X1252 g5813_1 g5813_0 g5813_2 0 netg5813
X1253 g4890_2 g4890_1 g4890_0 0 netg4890
X1254 g1288_1 g1288_0 0 netg1288
X1255 g4310_0 g4310_1 0 netg4310
X1256 g5774_0 g5774_1 0 netg5774
X1257 g3168_0 g3168_1 g3168_2 0 netg3168
X1258 g1951_2 g1951_1 g1951_0 0 netg1951
X1259 g2817_1 g2817_0 0 netg2817
X1260 g5790_1 g5790_0 0 netg5790
X1261 g3159_1 g3159_2 0 netg3159
X1262 g3101_0 g3101_1 0 netg3101
X1263 g4142_0 g4142_1 0 netg4142
X1264 g5359_1 g5359_0 0 netg5359
X1265 g4417_0 g4417_1 0 netg4417
X1266 g7054_0 g7054_2 g7054_1 0 netg7054
X1267 g6508_0 g6508_1 0 netg6508
X1268 g6558_0 g6558_1 0 netg6558
X1269 g6344_1 g6344_0 0 netg6344
X1270 g6615_1 g6615_2 0 netg6615
X1271 g7351_0 g7351_1 0 netg7351
X1272 g6645_0 g6645_2 g6645_1 0 netg6645
X1273 g6984_1 g6984_0 0 netg6984
X1274 g2591_0 g2591_1 g2591_2 0 netg2591
X1275 g1312_1 g1312_0 0 netg1312
X1276 g1070_2 g1070_0 g1070_1 0 netg1070
X1277 g5409_1 g5409_0 0 netg5409
X1278 g4258_1 g4258_0 0 netg4258
X1279 g7170_0 g7170_1 0 netg7170
X1280 g7391_1 g7391_2 0 netg7391
X1281 g5147_2 g5147_0 0 netg5147
X1282 g5585_0 g5585_1 0 netg5585
X1283 g7280_0 g7280_1 0 netg7280
X1284 g5552_1 g5552_0 0 netg5552
X1285 g6534_1 g6534_0 0 netg6534
X1286 g6589_0 g6589_1 0 netg6589
X1287 g3975_0 g3975_1 0 netg3975
X1288 g7234_2 g7234_1 g7234_0 0 netg7234
X1289 g4252_1 g4252_0 0 netg4252
X1290 g2713_1 g2713_0 g2713_2 0 netg2713
X1291 g5966_1 g5966_0 0 netg5966
X1292 g7295_1 g7295_0 0 netg7295
X1293 g6104_0 g6104_1 0 netg6104
X1294 g4371_0 g4371_2 g4371_1 0 netg4371
X1295 g6151_1 g6151_0 0 netg6151
X1296 g3562_0 g3562_1 0 netg3562
X1297 g1372_1 g1372_2 0 netg1372
X1298 g5276_0 g5276_1 0 netg5276
X1299 g6877_0 g6877_1 0 netg6877
X1300 g3001_1 g3001_0 0 netg3001
X1301 g6335_0 g6335_1 0 netg6335
X1302 g3505_1 g3505_0 0 netg3505
X1303 g4753_1 g4753_2 g4753_0 0 netg4753
X1304 g5188_2 g5188_1 0 netg5188
X1305 g2840_1 g2840_0 0 netg2840
X1306 g4187_1 g4187_0 0 netg4187
X1307 g3348_1 g3348_0 0 netg3348
X1308 g1556_0 g1556_1 0 netg1556
X1309 g7422_0 g7422_1 0 netg7422
X1310 g6212_1 g6212_0 0 netg6212
X1311 g4205_1 g4205_0 0 netg4205
X1312 g3426_2 g3426_1 0 netg3426
X1313 g4231_0 g4231_1 0 netg4231
X1314 g4970_0 g4970_2 g4970_1 0 netg4970
X1315 g6700_1 g6700_2 0 netg6700
X1316 g4337_0 g4337_1 0 netg4337
X1317 g2943_0 g2943_1 0 netg2943
X1318 g6230_0 g6230_1 g6230_2 0 netg6230
X1319 g4902_2 g4902_0 0 netg4902
X1320 x251_0 x251_1 0 netx251
X1321 g5301_0 g5301_1 0 netg5301
X1322 g7369_1 g7369_0 0 netg7369
X1323 g2976_1 g2976_0 0 netg2976
X1324 g2621_2 g2621_0 g2621_1 0 netg2621
X1325 g6821_1 g6821_0 0 netg6821
X1326 g6808_2 g6808_1 g6808_0 0 netg6808
X1327 g6993_0 g6993_1 0 netg6993
X1328 g5393_1 g5393_0 0 netg5393
X1329 g3566_1 g3566_0 0 netg3566
X1330 g4441_1 g4441_0 0 netg4441
X1331 g2827_0 g2827_1 0 netg2827
X1332 g5021_2 g5021_0 0 netg5021
X1333 g7010_0 g7010_1 0 netg7010
X1334 x42_1 x42_0 0 netx42
X1335 g4109_0 g4109_1 0 netg4109
X1336 g7387_0 g7387_1 0 netg7387
X1337 g3561_0 g3561_1 0 netg3561
X1338 g7355_1 g7355_0 0 netg7355
X1339 g1514_1 g1514_0 0 netg1514
X1340 g3970_0 g3970_1 0 netg3970
X1341 g1512_0 g1512_1 0 netg1512
X1342 g1379_1 g1379_0 0 netg1379
X1343 g3050_0 g3050_1 0 netg3050
X1344 g6661_0 g6661_1 0 netg6661
X1345 g5535_2 g5535_1 g5535_0 0 netg5535
X1346 g2689_0 g2689_1 g2689_2 0 netg2689
X1347 g5237_1 g5237_0 0 netg5237
X1348 g6676_1 g6676_0 0 netg6676
X1349 g4224_0 g4224_1 0 netg4224
X1350 g2841_1 g2841_0 0 netg2841
X1351 g5426_0 g5426_1 0 netg5426
X1352 g7292_1 g7292_0 0 netg7292
X1353 g2831_0 g2831_1 0 netg2831
X1354 g75_1 g75_0 0 netg75
X1355 g4427_0 g4427_1 0 netg4427
X1356 g6209_0 g6209_1 0 netg6209
X1357 g5962_0 g5962_1 0 netg5962
X1358 x12_1 x12_0 0 netx12
X1359 g6666_1 g6666_0 0 netg6666
X1360 g6133_0 g6133_1 0 netg6133
X1361 g7187_0 g7187_1 0 netg7187
X1362 g6892_1 g6892_0 0 netg6892
X1363 g7078_0 g7078_1 0 netg7078
X1364 g1549_1 g1549_0 0 netg1549
X1365 g4453_1 g4453_0 0 netg4453
X1366 g6734_1 g6734_0 0 netg6734
X1367 g5457_1 g5457_0 0 netg5457
X1368 g6411_1 g6411_0 0 netg6411
X1369 g2453_0 g2453_2 g2453_1 0 netg2453
X1370 g6468_0 g6468_1 0 netg6468
X1371 g5265_0 g5265_1 0 netg5265
X1372 g2803_1 g2803_0 0 netg2803
X1373 g4668_1 g4668_0 0 netg4668
X1374 g4305_1 g4305_0 0 netg4305
X1375 g6036_1 g6036_0 0 netg6036
X1376 g7402_0 g7402_1 0 netg7402
X1377 g4246_1 g4246_0 0 netg4246
X1378 g6273_0 g6273_1 0 netg6273
X1379 g6449_0 g6449_1 0 netg6449
X1380 g5602_0 g5602_1 0 netg5602
X1381 g7417_2 g7417_1 g7417_0 0 netg7417
X1382 g4362_2 g4362_1 0 netg4362
X1383 g6155_1 g6155_2 g6155_0 0 netg6155
X1384 g949_0 g949_2 g949_1 0 netg949
X1385 g7290_1 g7290_0 0 netg7290
X1386 g7539_1 g7539_0 0 netg7539
X1387 g5324_0 g5324_1 0 netg5324
X1388 g6543_1 g6543_2 0 netg6543
X1389 g3716_0 g3716_1 0 netg3716
X1390 g6494_1 g6494_0 0 netg6494
X1391 g6837_2 g6837_1 g6837_0 0 netg6837
X1392 g6498_1 g6498_0 0 netg6498
X1393 g4040_0 g4040_1 0 netg4040
X1394 g5074_2 g5074_0 g5074_1 0 netg5074
X1395 g6605_0 g6605_1 0 netg6605
X1396 g6355_1 g6355_0 0 netg6355
X1397 g3048_0 g3048_1 0 netg3048
X1398 g6738_2 g6738_1 0 netg6738
X1399 g7137_1 g7137_0 0 netg7137
X1400 g6197_0 g6197_1 0 netg6197
X1401 g4291_0 g4291_1 0 netg4291
X1402 g4266_0 g4266_1 0 netg4266
X1403 g777_0 g777_2 g777_1 0 netg777
X1404 g5427_1 g5427_0 0 netg5427
X1405 g3503_0 g3503_1 0 netg3503
X1406 g7199_1 g7199_0 0 netg7199
X1407 g6251_1 g6251_2 0 netg6251
X1408 g4064_0 g4064_1 0 netg4064
X1409 g3520_0 g3520_1 0 netg3520
X1410 g1937_0 g1937_1 0 netg1937
X1411 g1362_1 g1362_0 0 netg1362
X1412 g6487_1 g6487_0 0 netg6487
X1413 g5481_1 g5481_0 0 netg5481
X1414 g4218_1 g4218_0 0 netg4218
X1415 g6108_1 g6108_0 0 netg6108
X1416 g1429_1 g1429_0 0 netg1429
X1417 g3404_2 g3404_1 g3404_0 0 netg3404
X1418 g3906_1 g3906_0 0 netg3906
X1419 g3435_1 g3435_0 g3435_2 0 netg3435
X1420 g1258_1 g1258_0 0 netg1258
X1421 g7169_1 g7169_0 0 netg7169
X1422 g6308_1 g6308_0 0 netg6308
X1423 g3383_0 g3383_2 g3383_1 0 netg3383
X1424 g4426_0 g4426_1 0 netg4426
X1425 g6512_0 g6512_1 0 netg6512
X1426 g4207_0 g4207_1 0 netg4207
X1427 g6847_0 g6847_1 g6847_2 0 netg6847
X1428 g7390_0 g7390_1 0 netg7390
X1429 g4454_1 g4454_0 0 netg4454
X1430 g4221_0 g4221_1 0 netg4221
X1431 g3972_1 g3972_0 0 netg3972
X1432 g6463_0 g6463_1 0 netg6463
X1433 g1356_1 g1356_0 0 netg1356
X1434 g6675_0 g6675_1 0 netg6675
X1435 g7215_1 g7215_0 0 netg7215
X1436 g439_2 g439_1 0 netg439
X1437 g2462_2 g2462_1 0 netg2462
X1438 g1136_1 g1136_0 0 netg1136
X1439 g6196_0 g6196_1 0 netg6196
X1440 g5294_0 g5294_1 0 netg5294
X1441 g4339_1 g4339_0 0 netg4339
X1442 g4425_1 g4425_0 0 netg4425
X1443 g6728_1 g6728_0 0 netg6728
X1444 g6890_0 g6890_1 0 netg6890
X1445 g1589_0 g1589_1 0 netg1589
X1446 g4248_1 g4248_0 0 netg4248
X1447 g3231_1 g3231_2 g3231_0 0 netg3231
X1448 g3228_2 g3228_1 g3228_0 0 netg3228
X1449 g6872_0 g6872_1 0 netg6872
X1450 g4991_0 g4991_2 g4991_1 0 netg4991
X1451 g1924_1 g1924_0 0 netg1924
X1452 g994_1 g994_0 g994_2 0 netg994
X1453 g988_1 g988_2 0 netg988
X1454 g6066_0 g6066_1 0 netg6066
X1455 g1220_0 g1220_1 0 netg1220
X1456 g5983_0 g5983_1 0 netg5983
X1457 g6334_1 g6334_0 0 netg6334
X1458 g7108_0 g7108_1 0 netg7108
X1459 g1237_1 g1237_0 0 netg1237
X1460 g620_1 g620_0 0 netg620
X1461 g4994_0 g4994_2 0 netg4994
X1462 g6588_1 g6588_0 0 netg6588
X1463 g5560_2 g5560_1 0 netg5560
X1464 x411_1 x411_0 0 netx411
X1465 g4107_1 g4107_0 0 netg4107
X1466 g5329_1 g5329_0 0 netg5329
X1467 g5906_0 g5906_1 g5906_2 0 netg5906
X1468 g2807_1 g2807_0 0 netg2807
X1469 g7083_1 g7083_0 0 netg7083
X1470 g3327_2 g3327_0 g3327_1 0 netg3327
X1471 g4939_1 g4939_0 0 netg4939
X1472 g997_1 g997_2 g997_0 0 netg997
X1473 g2465_1 g2465_2 0 netg2465
X1474 g4446_0 g4446_1 0 netg4446
X1475 g1304_1 g1304_0 0 netg1304
X1476 x252_1 x252_0 0 netx252
X1477 g7231_2 g7231_0 0 netg7231
X1478 g6488_0 g6488_1 0 netg6488
X1479 g3392_2 g3392_0 g3392_1 0 netg3392
X1480 g485_0 g485_1 0 netg485
X1481 g3530_1 g3530_0 0 netg3530
X1482 g4435_1 g4435_0 0 netg4435
X1483 g3479_1 g3479_0 0 netg3479
X1484 g5875_1 g5875_2 g5875_0 0 netg5875
X1485 g3984_1 g3984_0 0 netg3984
X1486 x532_0 x532_1 0 netx532
X1487 g6039_1 g6039_0 0 netg6039
X1488 g6664_0 g6664_1 0 netg6664
X1489 g7531_1 g7531_0 0 netg7531
X1490 g7105_1 g7105_0 0 netg7105
X1491 g2996_1 g2996_0 0 netg2996
X1492 g1366_0 g1366_2 g1366_1 0 netg1366
X1493 g4307_0 g4307_1 0 netg4307
X1494 g3401_0 g3401_1 g3401_2 0 netg3401
X1495 g1498_1 g1498_0 0 netg1498
X1496 g7384_0 g7384_1 0 netg7384
X1497 g5959_0 g5959_1 0 netg5959
X1498 g3917_0 g3917_1 0 netg3917
X1499 g2946_1 g2946_0 0 netg2946
X1500 g2767_1 g2767_0 0 netg2767
X1501 g407_0 g407_1 g407_2 0 netg407
X1502 g5608_0 g5608_1 0 netg5608
X1503 g6822_0 g6822_1 0 netg6822
X1504 g678_0 g678_2 0 netg678
X1505 g6614_0 g6614_1 0 netg6614
X1506 x41_1 x41_0 0 netx41
X1507 g877_1 g877_2 0 netg877
X1508 g2814_1 g2814_0 0 netg2814
X1509 g6009_0 g6009_1 0 netg6009
X1510 g7251_0 g7251_1 0 netg7251
X1511 g2746_1 g2746_0 0 netg2746
X1512 g5566_1 g5566_0 g5566_2 0 netg5566
X1513 g7177_1 g7177_2 0 netg7177
X1514 g6311_1 g6311_0 0 netg6311
X1515 g2926_0 g2926_1 0 netg2926
X1516 x531_0 x531_1 0 netx531
X1517 g7401_1 g7401_0 0 netg7401
X1518 g1233_1 g1233_0 0 netg1233
X1519 g5777_0 g5777_1 0 netg5777
X1520 g7398_1 g7398_0 0 netg7398
X1521 g5887_1 g5887_2 0 netg5887
X1522 g3450_1 g3450_2 0 netg3450
X1523 g6364_1 g6364_0 0 netg6364
X1524 g2954_1 g2954_0 0 netg2954
X1525 g6691_1 g6691_0 0 netg6691
X1526 g1303_0 g1303_1 0 netg1303
X1527 g1155_1 g1155_0 0 netg1155
X1528 g5532_2 g5532_1 g5532_0 0 netg5532
X1529 g5006_1 g5006_2 0 netg5006
X1530 g1994_1 g1994_0 0 netg1994
X1531 g5363_0 g5363_1 0 netg5363
X1532 g2028_1 g2028_0 0 netg2028
X1533 g7090_0 g7090_1 0 netg7090
X1534 g2222_1 g2222_0 0 netg2222
X1535 g5931_1 g5931_0 0 netg5931
X1536 g6973_0 g6973_1 0 netg6973
X1537 g4179_1 g4179_2 0 netg4179
X1538 g6933_0 g6933_1 0 netg6933
X1539 g1383_0 g1383_1 0 netg1383
X1540 x301_0 x301_1 0 netx301
X1541 g3420_1 g3420_2 0 netg3420
X1542 g2771_1 g2771_0 0 netg2771
X1543 g517_1 g517_0 0 netg517
X1544 g2438_1 g2438_0 g2438_2 0 netg2438
X1545 g2233_1 g2233_0 0 netg2233
X1546 g5463_1 g5463_0 0 netg5463
X1547 g2925_1 g2925_0 0 netg2925
X1548 g7126_1 g7126_0 0 netg7126
X1549 g6391_1 g6391_0 0 netg6391
X1550 g4356_0 g4356_1 0 netg4356
X1551 g7537_1 g7537_0 0 netg7537
X1552 x152_0 x152_1 0 netx152
X1553 g3558_1 g3558_0 0 netg3558
X1554 g4270_0 g4270_1 0 netg4270
X1555 g7011_1 g7011_0 0 netg7011
X1556 g862_2 g862_0 g862_1 0 netg862
X1557 g7394_1 g7394_0 0 netg7394
X1558 g4440_1 g4440_0 0 netg4440
X1559 g6663_0 g6663_1 0 netg6663
X1560 g5346_0 g5346_1 0 netg5346
X1561 g7538_0 g7538_1 0 netg7538
X1562 g2737_1 g2737_2 g2737_0 0 netg2737
X1563 g3258_2 g3258_1 g3258_0 0 netg3258
X1564 g6187_0 g6187_1 0 netg6187
X1565 g1550_0 g1550_1 0 netg1550
X1566 g2799_0 g2799_1 0 netg2799
X1567 g5263_1 g5263_0 0 netg5263
X1568 g7324_2 g7324_1 0 netg7324
X1569 g4979_2 g4979_0 g4979_1 0 netg4979
X1570 g3571_0 g3571_1 0 netg3571
X1571 g4101_1 g4101_0 0 netg4101
X1572 g5110_0 g5110_2 g5110_1 0 netg5110
X1573 g4935_0 g4935_2 g4935_1 0 netg4935
X1574 g7352_0 g7352_1 0 netg7352
X1575 g6332_1 g6332_0 0 netg6332
X1576 g3476_1 g3476_0 0 netg3476
X1577 g3066_1 g3066_0 0 netg3066
X1578 g3047_0 g3047_1 0 netg3047
X1579 g4015_0 g4015_1 0 netg4015
X1580 g2772_1 g2772_0 0 netg2772
X1581 g2750_0 g2750_1 0 netg2750
X1582 g5683_1 g5683_0 0 netg5683
X1583 g2606_2 g2606_0 0 netg2606
X1584 g4315_1 g4315_0 0 netg4315
X1585 g7386_1 g7386_0 0 netg7386
X1586 g6817_1 g6817_0 0 netg6817
X1587 g6293_0 g6293_1 0 netg6293
X1588 g967_0 g967_2 g967_1 0 netg967
X1589 g5985_1 g5985_0 0 netg5985
X1590 g1883_2 g1883_1 0 netg1883
X1591 g5445_0 g5445_2 g5445_1 0 netg5445
X1592 g6456_2 g6456_1 g6456_0 0 netg6456
X1593 g7252_1 g7252_0 0 netg7252
X1594 g2836_0 g2836_1 0 netg2836
X1595 g1226_0 g1226_1 0 netg1226
X1596 g4225_0 g4225_1 0 netg4225
X1597 g4050_1 g4050_0 0 netg4050
X1598 g1357_0 g1357_1 0 netg1357
X1599 g6430_2 g6430_0 0 netg6430
X1600 g5009_1 g5009_2 0 netg5009
X1601 g4289_0 g4289_1 0 netg4289
X1602 g696_0 g696_1 g696_2 0 netg696
X1603 g2422_1 g2422_0 0 netg2422
X1604 g5554_1 g5554_2 g5554_0 0 netg5554
X1605 g7173_1 g7173_0 0 netg7173
X1606 g6274_2 g6274_0 g6274_1 0 netg6274
X1607 g3346_1 g3346_0 0 netg3346
X1608 g5314_0 g5314_1 0 netg5314
X1609 g5591_1 g5591_0 0 netg5591
X1610 g7302_0 g7302_1 0 netg7302
X1611 g5462_0 g5462_1 0 netg5462
X1612 g4411_1 g4411_0 0 netg4411
X1613 g4415_1 g4415_0 0 netg4415
X1614 g7024_1 g7024_0 0 netg7024
X1615 g4111_0 g4111_1 0 netg4111
X1616 g7171_0 g7171_1 0 netg7171
X1617 g4251_1 g4251_0 0 netg4251
X1618 g4988_2 g4988_0 0 netg4988
X1619 g883_1 g883_0 g883_2 0 netg883
X1620 g3077_0 g3077_1 0 netg3077
X1621 g2582_0 g2582_1 g2582_2 0 netg2582
X1622 x222_1 x222_0 0 netx222
X1623 g4021_0 g4021_1 0 netg4021
X1624 g2843_0 g2843_1 0 netg2843
X1625 g4355_1 g4355_0 0 netg4355
X1626 g4267_1 g4267_0 0 netg4267
X1627 g5299_1 g5299_0 0 netg5299
X1628 g3398_0 g3398_1 g3398_2 0 netg3398
X1629 g6954_2 g6954_0 0 netg6954
X1630 g2171_2 g2171_3 g2171_0 0 netg2171
X1631 g6402_1 g6402_0 0 netg6402
X1632 g1765_1 g1765_0 0 netg1765
X1633 g2444_2 g2444_1 g2444_0 0 netg2444
X1634 g6608_1 g6608_0 0 netg6608
X1635 g3543_1 g3543_0 0 netg3543
X1636 g2368_1 g2368_2 g2368_0 0 netg2368
X1637 g2588_2 g2588_0 0 netg2588
X1638 g3475_1 g3475_0 0 netg3475
X1639 g6041_0 g6041_1 0 netg6041
X1640 g2920_0 g2920_1 0 netg2920
X1641 g6561_1 g6561_0 0 netg6561
X1642 g1015_0 g1015_2 g1015_1 0 netg1015
X1643 g5520_0 g5520_1 0 netg5520
X1644 x211_0 x211_1 0 netx211
X1645 g2776_1 g2776_0 0 netg2776
X1646 g6683_0 g6683_1 0 netg6683
X1647 g1583_0 g1583_1 0 netg1583
X1648 g1219_0 g1219_1 0 netg1219
X1649 g6034_0 g6034_1 0 netg6034
X1650 g559_1 g559_0 0 netg559
X1651 g6417_1 g6417_0 0 netg6417
X1652 g6412_1 g6412_0 0 netg6412
X1653 g4222_1 g4222_0 0 netg4222
X1654 g3377_2 g3377_1 0 netg3377
X1655 g6698_1 g6698_0 0 netg6698
X1656 g4054_1 g4054_0 0 netg4054
X1657 g4262_1 g4262_0 0 netg4262
X1658 g5274_1 g5274_0 0 netg5274
X1659 g5829_0 g5829_1 0 netg5829
X1660 g5454_1 g5454_0 g5454_2 0 netg5454
X1661 g1887_1 g1887_0 0 netg1887
X1662 g1024_2 g1024_1 g1024_0 0 netg1024
X1663 g6654_0 g6654_1 0 netg6654
X1664 g4285_1 g4285_0 0 netg4285
X1665 g7086_1 g7086_0 0 netg7086
X1666 g7372_0 g7372_1 0 netg7372
X1667 g1076_2 g1076_1 0 netg1076
X1668 g6530_1 g6530_0 0 netg6530
X1669 g2392_2 g2392_1 0 netg2392
X1670 g7424_1 g7424_0 0 netg7424
X1671 g6924_1 g6924_0 0 netg6924
X1672 g5121_0 g5121_1 0 netg5121
X1673 g5027_1 g5027_2 g5027_0 0 netg5027
X1674 g5995_1 g5995_0 0 netg5995
X1675 g5033_2 g5033_0 g5033_1 0 netg5033
X1676 g7180_2 g7180_1 g7180_0 0 netg7180
X1677 g1315_0 g1315_1 0 netg1315
X1678 g6174_0 g6174_1 0 netg6174
X1679 g2763_1 g2763_0 0 netg2763
X1680 g5846_1 g5846_0 0 netg5846
X1681 g5700_1 g5700_0 g5700_2 0 netg5700
X1682 g3459_2 g3459_0 0 netg3459
X1683 g3465_1 g3465_0 0 netg3465
X1684 g7348_0 g7348_1 0 netg7348
X1685 g5864_1 g5864_0 0 netg5864
X1686 g3891_0 g3891_1 0 netg3891
X1687 g7339_1 g7339_0 0 netg7339
X1688 g5981_1 g5981_0 0 netg5981
X1689 g7115_0 g7115_1 0 netg7115
X1690 g6670_1 g6670_0 0 netg6670
X1691 g2507_1 g2507_2 g2507_0 0 netg2507
X1692 g6070_0 g6070_1 0 netg6070
X1693 g7256_1 g7256_0 0 netg7256
X1694 g4041_1 g4041_0 0 netg4041
X1695 x522_0 x522_1 0 netx522
X1696 g99_1 g99_0 0 netg99
X1697 g5086_0 g5086_2 g5086_1 0 netg5086
X1698 g4343_0 g4343_1 0 netg4343
X1699 g1587_0 g1587_1 0 netg1587
X1700 g3472_1 g3472_0 0 netg3472
X1701 g7014_1 g7014_0 0 netg7014
X1702 g3186_2 g3186_1 g3186_0 0 netg3186
X1703 g1048_0 g1048_2 g1048_1 0 netg1048
X1704 g6370_1 g6370_0 0 netg6370
X1705 g5214_0 g5214_1 g5214_2 0 netg5214
X1706 g6722_0 g6722_2 0 netg6722
X1707 g5492_1 g5492_0 0 netg5492
X1708 x232_0 x232_1 0 netx232
X1709 g6687_2 g6687_1 g6687_3 g6687_0 0 netg6687
X1710 g2880_0 g2880_1 0 netg2880
X1711 g2594_2 g2594_0 g2594_1 0 netg2594
X1712 g6917_0 g6917_1 0 netg6917
X1713 x302_1 x302_0 0 netx302
X1714 g6044_1 g6044_0 0 netg6044
X1715 g1938_0 g1938_1 0 netg1938
X1716 g2624_1 g2624_2 g2624_0 0 netg2624
X1717 g1877_0 g1877_2 g1877_1 0 netg1877
X1718 g5598_0 g5598_1 0 netg5598
X1719 g6198_1 g6198_0 0 netg6198
X1720 g2231_1 g2231_0 0 netg2231
X1721 g2665_0 g2665_1 g2665_2 0 netg2665
X1722 g6975_1 g6975_0 0 netg6975
X1723 g544_1 g544_0 0 netg544
X1724 g4893_1 g4893_0 g4893_2 0 netg4893
X1725 g3114_0 g3114_2 g3114_1 0 netg3114
X1726 g6927_0 g6927_1 0 netg6927
X1727 g3165_1 g3165_2 g3165_0 0 netg3165
X1728 g3902_1 g3902_0 0 netg3902
X1729 g5153_2 g5153_1 g5153_0 0 netg5153
X1730 g5578_0 g5578_1 g5578_2 0 netg5578
X1731 g4657_0 g4657_1 g4657_2 0 netg4657
X1732 g6288_0 g6288_2 g6288_1 0 netg6288
X1733 g82_0 g82_1 0 netg82
X1734 g1907_0 g1907_1 0 netg1907
X1735 g4953_0 g4953_2 0 netg4953
X1736 g6653_1 g6653_0 0 netg6653
X1737 g5047_0 g5047_2 0 netg5047
X1738 g6164_1 g6164_0 0 netg6164
X1739 g5422_1 g5422_0 0 netg5422
X1740 g1936_1 g1936_0 0 netg1936
X1741 g2498_0 g2498_1 g2498_2 0 netg2498
X1742 g2722_2 g2722_0 g2722_1 0 netg2722
X1743 g3276_0 g3276_2 g3276_1 0 netg3276
X1744 g958_1 g958_2 0 netg958
X1745 g5539_1 g5539_0 0 netg5539
X1746 g4066_1 g4066_0 0 netg4066
X1747 g2769_0 g2769_1 0 netg2769
X1748 g6049_0 g6049_1 0 netg6049
X1749 g3380_1 g3380_0 g3380_2 0 netg3380
X1750 g6007_0 g6007_1 0 netg6007
X1751 g4905_2 g4905_1 g4905_0 0 netg4905
X1752 g2695_1 g2695_0 g2695_2 0 netg2695
X1753 g6552_0 g6552_1 0 netg6552
X1754 g3368_2 g3368_1 g3368_0 0 netg3368
X1755 g5622_0 g5622_2 0 netg5622
X1756 g3318_0 g3318_2 g3318_1 0 netg3318
X1757 g2401_1 g2401_0 g2401_2 0 netg2401
X1758 g1439_1 g1439_0 0 netg1439
X1759 g2232_1 g2232_0 0 netg2232
X1760 g6466_0 g6466_1 0 netg6466
X1761 g5929_0 g5929_1 0 netg5929
X1762 g4319_1 g4319_0 0 netg4319
X1763 g3019_1 g3019_0 0 netg3019
X1764 g7138_0 g7138_1 0 netg7138
X1765 g6262_0 g6262_1 0 netg6262
X1766 g3545_0 g3545_1 0 netg3545
X1767 g6540_0 g6540_1 0 netg6540
X1768 g6964_1 g6964_0 g6964_2 0 netg6964
X1769 g1454_0 g1454_1 0 netg1454
X1770 g2468_1 g2468_2 g2468_0 0 netg2468
X1771 g5915_0 g5915_1 0 netg5915
X1772 g5668_2 g5668_0 g5668_1 0 netg5668
X1773 g6387_1 g6387_0 0 netg6387
X1774 g5923_2 g5923_1 g5923_0 0 netg5923
X1775 g2528_1 g2528_0 g2528_2 0 netg2528
X1776 g5685_2 g5685_0 g5685_1 0 netg5685
X1777 g6934_0 g6934_1 0 netg6934
X1778 x321_0 x321_1 0 netx321
X1779 g1057_2 g1057_0 g1057_1 0 netg1057
X1780 g4292_0 g4292_1 0 netg4292
X1781 g2615_0 g2615_2 g2615_1 0 netg2615
X1782 g6796_2 g6796_1 g6796_0 0 netg6796
X1783 g3567_0 g3567_1 0 netg3567
X1784 g1157_0 g1157_1 0 netg1157
X1785 g6495_0 g6495_2 g6495_1 0 netg6495
X1786 g2346_1 g2346_0 0 netg2346
X1787 g2418_0 g2418_2 g2418_1 0 netg2418
X1788 g3539_1 g3539_0 0 netg3539
X1789 g4044_1 g4044_0 0 netg4044
X1790 g2825_0 g2825_1 0 netg2825
X1791 g4003_1 g4003_2 g4003_0 0 netg4003
X1792 g2395_2 g2395_1 g2395_0 0 netg2395
X1793 g3893_0 g3893_1 0 netg3893
X1794 g1513_0 g1513_1 0 netg1513
X1795 g5677_0 g5677_2 g5677_1 0 netg5677
X1796 g5553_0 g5553_1 0 netg5553
X1797 g7433_2 g7433_0 g7433_1 0 netg7433
X1798 g5861_0 g5861_2 g5861_1 0 netg5861
X1799 g6074_1 g6074_0 0 netg6074
X1800 g5734_1 g5734_2 0 netg5734
X1801 g4190_2 g4190_0 g4190_1 0 netg4190
X1802 g3504_1 g3504_0 0 netg3504
X1803 g5967_1 g5967_0 0 netg5967
X1804 g7000_1 g7000_0 0 netg7000
X1805 g5522_2 g5522_0 g5522_1 0 netg5522
X1806 g3441_1 g3441_2 0 netg3441
X1807 g6535_1 g6535_0 0 netg6535
X1808 g6541_1 g6541_0 0 netg6541
X1809 g3485_1 g3485_0 0 netg3485
X1810 g4617_1 g4617_0 0 netg4617
X1811 g1579_1 g1579_0 0 netg1579
X1812 g4151_1 g4151_2 g4151_0 0 netg4151
X1813 g4213_1 g4213_2 0 netg4213
X1814 g6093_2 g6093_1 g6093_0 0 netg6093
X1815 g3569_0 g3569_1 0 netg3569
X1816 g2800_0 g2800_1 0 netg2800
X1817 g5089_0 g5089_2 g5089_1 0 netg5089
X1818 g6467_1 g6467_0 0 netg6467
X1819 g6856_1 g6856_2 g6856_0 0 netg6856
X1820 g7312_2 g7312_0 g7312_1 0 netg7312
X1821 g2958_0 g2958_1 0 netg2958
X1822 g6327_0 g6327_1 0 netg6327
X1823 g4178_1 g4178_0 0 netg4178
X1824 g5886_1 g5886_0 0 netg5886
X1825 g6315_1 g6315_0 0 netg6315
X1826 g2561_2 g2561_1 g2561_0 0 netg2561
X1827 g1571_1 g1571_0 0 netg1571
X1828 g1435_1 g1435_0 0 netg1435
X1829 g991_2 g991_0 0 netg991
X1830 g6551_0 g6551_1 0 netg6551
X1831 g6374_1 g6374_2 g6374_0 0 netg6374
X1832 g2353_0 g2353_1 g2353_2 0 netg2353
X1833 g2618_1 g2618_2 0 netg2618
X1834 g1253_1 g1253_0 0 netg1253
X1835 g2450_0 g2450_1 g2450_2 0 netg2450
X1836 g5731_0 g5731_1 g5731_2 0 netg5731
X1837 g2627_0 g2627_2 g2627_1 0 netg2627
X1838 g3303_1 g3303_2 0 netg3303
X1839 g6124_1 g6124_0 g6124_2 0 netg6124
X1840 g6893_1 g6893_0 0 netg6893
X1841 g3058_0 g3058_1 0 netg3058
X1842 g6987_2 g6987_1 g6987_0 0 netg6987
X1843 g5036_1 g5036_0 g5036_2 0 netg5036
X1844 g1581_0 g1581_1 0 netg1581
X1845 g6625_2 g6625_1 g6625_0 0 netg6625
X1846 g4448_1 g4448_0 0 netg4448
X1847 g955_0 g955_2 g955_1 0 netg955
X1848 g3987_0 g3987_1 0 netg3987
X1849 g4045_0 g4045_1 0 netg4045
X1850 g1932_0 g1932_1 0 netg1932
X1851 g3538_1 g3538_0 0 netg3538
X1852 g2659_1 g2659_0 g2659_2 0 netg2659
X1853 x272_0 x272_1 0 netx272
X1854 g2805_0 g2805_1 0 netg2805
X1855 g5107_0 g5107_2 g5107_1 0 netg5107
X1856 g3918_1 g3918_0 0 netg3918
X1857 g6904_1 g6904_0 0 netg6904
X1858 g6400_0 g6400_1 0 netg6400
X1859 g6515_1 g6515_0 0 netg6515
X1860 g2573_2 g2573_1 g2573_0 0 netg2573
X1861 g6096_1 g6096_2 0 netg6096
X1862 g6829_2 g6829_1 g6829_0 g6829_3 0 netg6829
X1863 g5407_1 g5407_0 0 netg5407
X1864 g4303_0 g4303_1 0 netg4303
X1865 g3321_0 g3321_1 g3321_2 0 netg3321
X1866 g895_2 g895_1 g895_0 0 netg895
X1867 g6715_0 g6715_1 g6715_2 0 netg6715
X1868 x382_1 x382_0 0 netx382
X1869 g2600_2 g2600_0 g2600_1 0 netg2600
X1870 g3386_1 g3386_2 g3386_0 0 netg3386
X1871 g3297_2 g3297_1 g3297_0 0 netg3297
X1872 g3527_0 g3527_1 0 netg3527
X1873 g7444_1 g7444_0 0 netg7444
X1874 g4296_0 g4296_1 0 netg4296
X1875 g5593_2 g5593_1 g5593_0 0 netg5593
X1876 g2806_1 g2806_0 0 netg2806
X1877 g2917_1 g2917_0 0 netg2917
X1878 g4985_2 g4985_1 g4985_0 0 netg4985
X1879 g4060_0 g4060_1 0 netg4060
X1880 g1387_0 g1387_1 g1387_2 0 netg1387
X1881 g5003_1 g5003_2 g5003_0 0 netg5003
X1882 g2044_0 g2044_1 0 netg2044
X1883 g6685_0 g6685_1 0 netg6685
X1884 g5387_0 g5387_1 0 netg5387
X1885 g1871_2 g1871_1 g1871_0 0 netg1871
X1886 g4401_0 g4401_1 0 netg4401
X1887 g1865_1 g1865_0 g1865_2 0 netg1865
X1888 g4887_1 g4887_2 g4887_0 0 netg4887
X1889 g3192_1 g3192_2 g3192_0 0 netg3192
X1890 g2471_0 g2471_2 g2471_1 0 netg2471
X1891 g6226_1 g6226_0 g6226_2 0 netg6226
X1892 g5909_1 g5909_0 g5909_2 0 netg5909
X1893 g4764_1 g4764_2 g4764_0 0 netg4764
X1894 g4157_0 g4157_2 0 netg4157
X1895 g5232_0 g5232_1 0 netg5232
X1896 g1137_1 g1137_0 0 netg1137
X1897 x282_1 x282_0 0 netx282
X1898 g1553_0 g1553_1 0 netg1553
X1899 g4667_0 g4667_1 0 netg4667
X1900 g1073_1 g1073_0 g1073_2 0 netg1073
X1901 g2829_1 g2829_0 0 netg2829
X1902 g1042_1 g1042_0 g1042_2 0 netg1042
X1903 g6419_0 g6419_1 0 netg6419
X1904 g3554_1 g3554_0 0 netg3554
X1905 g3474_1 g3474_0 0 netg3474
X1906 g6824_1 g6824_0 0 netg6824
X1907 g5160_1 g5160_0 g5160_2 0 netg5160
X1908 g4781_1 g4781_0 g4781_2 0 netg4781
X1909 x441_0 x441_1 0 netx441
X1910 g7041_1 g7041_2 g7041_0 0 netg7041
X1911 g3502_1 g3502_0 0 netg3502
X1912 g5858_0 g5858_1 0 netg5858
X1913 g5951_0 g5951_1 0 netg5951
X1914 g1433_1 g1433_0 0 netg1433
X1915 g6116_0 g6116_2 g6116_1 0 netg6116
X1916 g7106_0 g7106_1 0 netg7106
X1917 g6193_0 g6193_1 0 netg6193
X1918 g6386_1 g6386_0 0 netg6386
X1919 g4405_0 g4405_1 0 netg4405
X1920 g937_2 g937_0 g937_1 0 netg937
X1921 g2347_0 g2347_2 g2347_1 0 netg2347
X1922 g3219_1 g3219_2 g3219_0 0 netg3219
X1923 g1311_1 g1311_0 0 netg1311
X1924 g3054_1 g3054_0 0 netg3054
X1925 g964_1 g964_0 g964_2 0 netg964
X1926 g6941_1 g6941_0 0 netg6941
X1927 g1552_0 g1552_1 0 netg1552
X1928 g3222_0 g3222_2 g3222_1 0 netg3222
X1929 g6527_0 g6527_1 0 netg6527
X1930 g5508_2 g5508_0 g5508_1 0 netg5508
X1931 g4095_1 g4095_0 0 netg4095
X1932 g898_1 g898_2 g898_0 0 netg898
X1933 g1175_1 g1175_0 0 netg1175
X1934 g6478_1 g6478_2 g6478_0 0 netg6478
X1935 g7357_1 g7357_0 0 netg7357
X1936 g7343_1 g7343_0 0 netg7343
X1937 g919_2 g919_1 g919_0 0 netg919
X1938 g2716_1 g2716_0 g2716_2 0 netg2716
X1939 g3138_0 g3138_2 g3138_1 0 netg3138
X1940 g1096_0 g1096_1 0 netg1096
X1941 g4046_0 g4046_1 0 netg4046
X1942 g7216_1 g7216_0 0 netg7216
X1943 g4399_1 g4399_0 0 netg4399
X1944 g7104_0 g7104_1 0 netg7104
X1945 x71_0 x71_1 0 netx71
X1946 g3264_0 g3264_1 g3264_2 0 netg3264
X1947 g5194_2 g5194_0 g5194_1 0 netg5194
X1948 g4154_1 g4154_2 0 netg4154
X1949 g6051_1 g6051_0 0 netg6051
X1950 g5954_1 g5954_0 0 netg5954
X1951 g3542_1 g3542_0 0 netg3542
X1952 g6883_1 g6883_0 0 netg6883
X1953 g1844_3 g1844_1 g1844_2 0 netg1844
X1954 g4312_1 g4312_0 0 netg4312
X1955 x351_0 x351_1 0 netx351
X1956 g3347_1 g3347_0 0 netg3347
X1957 g6932_1 g6932_0 0 netg6932
X1958 g681_1 g681_0 0 netg681
X1959 g7441_1 g7441_0 0 netg7441
X1960 g1283_0 g1283_1 0 netg1283
X1961 g3309_0 g3309_2 g3309_1 0 netg3309
X1962 g7017_0 g7017_1 0 netg7017
X1963 g6637_1 g6637_0 g6637_2 0 netg6637
X1964 g7291_1 g7291_0 0 netg7291
X1965 g2374_2 g2374_0 g2374_1 0 netg2374
X1966 g3921_1 g3921_0 0 netg3921
X1967 g1229_0 g1229_1 0 netg1229
X1968 x521_1 x521_0 0 netx521
X1969 x182_0 x182_1 0 netx182
X1970 g7134_2 g7134_0 g7134_1 0 netg7134
X1971 g6360_0 g6360_1 0 netg6360
X1972 g2638_0 g2638_2 g2638_1 0 netg2638
X1973 g6712_1 g6712_0 g6712_2 0 netg6712
X1974 g1021_0 g1021_2 g1021_1 0 netg1021
X1975 g5485_1 g5485_0 0 netg5485
X1976 g2386_1 g2386_2 g2386_0 0 netg2386
X1977 g5413_1 g5413_0 0 netg5413
X1978 g2997_1 g2997_0 0 netg2997
X1979 g1903_0 g1903_1 0 netg1903
X1980 g2662_2 g2662_1 g2662_0 0 netg2662
X1981 g5465_1 g5465_0 0 netg5465
X1982 g3395_0 g3395_1 g3395_2 0 netg3395
X1983 g6557_1 g6557_0 0 netg6557
X1984 g2698_2 g2698_0 g2698_1 0 netg2698
X1985 g7007_1 g7007_0 0 netg7007
X1986 g4255_0 g4255_1 0 netg4255
X1987 g7274_0 g7274_1 0 netg7274
X1988 g2734_2 g2734_1 0 netg2734
X1989 g859_2 g859_1 g859_0 0 netg859
X1990 g1221_1 g1221_0 0 netg1221
X1991 g4105_1 g4105_0 0 netg4105
X1992 g6421_1 g6421_0 0 netg6421
X1993 g7122_0 g7122_1 0 netg7122
X1994 g4282_1 g4282_0 0 netg4282
X1995 g3052_0 g3052_1 0 netg3052
X1996 g3120_0 g3120_2 g3120_1 0 netg3120
X1997 g2495_0 g2495_1 g2495_2 0 netg2495
X1998 g5323_0 g5323_1 0 netg5323
X1999 x241_0 x241_1 0 netx241
X2000 g1114_0 g1114_1 0 netg1114
X2001 g2630_2 g2630_0 g2630_1 0 netg2630
X2002 x112_1 x112_0 0 netx112
X2003 g5719_1 g5719_2 0 netg5719
X2004 g3234_2 g3234_1 g3234_0 0 netg3234
X2005 g5836_2 g5836_1 g5836_0 0 netg5836
X2006 g7360_2 g7360_0 g7360_1 0 netg7360
X2007 g2459_2 g2459_1 g2459_0 0 netg2459
X2008 g3352_0 g3352_2 g3352_1 0 netg3352
X2009 g5098_2 g5098_1 g5098_0 0 netg5098
X2010 g7100_0 g7100_1 0 netg7100
X2011 g5115_1 g5115_0 g5115_2 0 netg5115
X2012 g1263_1 g1263_0 0 netg1263
X2013 x142_1 x142_0 0 netx142
X2014 g3064_1 g3064_0 0 netg3064
X2015 g5062_0 g5062_1 g5062_2 0 netg5062
X2016 g7075_1 g7075_0 0 netg7075
X2017 g3095_1 g3095_0 0 netg3095
X2018 g4419_1 g4419_0 0 netg4419
X2019 g2777_1 g2777_0 0 netg2777
X2020 g928_0 g928_1 g928_2 0 netg928
X2021 g6811_2 g6811_0 g6811_1 0 netg6811
X2022 g934_0 g934_2 g934_1 0 netg934
X2023 g5118_1 g5118_0 0 netg5118
X2024 g4164_1 g4164_0 g4164_2 0 netg4164
X2025 x271_1 x271_0 0 netx271
X2026 g5600_0 g5600_1 0 netg5600
X2027 g1551_1 g1551_0 0 netg1551
X2028 g2597_1 g2597_0 g2597_2 0 netg2597
X2029 g3084_1 g3084_0 0 netg3084
X2030 g5661_1 g5661_2 g5661_0 0 netg5661
X2031 g2377_0 g2377_2 g2377_1 0 netg2377
X2032 x442_1 x442_0 0 netx442
X2033 g6607_1 g6607_0 0 netg6607
X2034 g1365_0 g1365_1 0 netg1365
X2035 g2725_0 g2725_1 g2725_2 0 netg2725
X2036 g5728_1 g5728_2 g5728_0 0 netg5728
X2037 g5616_1 g5616_0 g5616_2 0 netg5616
X2038 g7018_1 g7018_0 0 netg7018
X2039 g7370_1 g7370_0 0 netg7370
X2040 g3279_1 g3279_2 0 netg3279
X2041 g6523_1 g6523_0 0 netg6523
X2042 g3342_1 g3342_2 g3342_0 0 netg3342
X2043 g6445_0 g6445_1 0 netg6445
X2044 g7184_0 g7184_1 0 netg7184
X2045 g6063_1 g6063_0 0 netg6063
X2046 g5664_0 g5664_2 g5664_1 0 netg5664
X2047 g3273_1 g3273_0 g3273_2 0 netg3273
X2048 g3246_0 g3246_2 g3246_1 0 netg3246
X2049 x111_1 x111_0 0 netx111
X2050 x551_0 x551_1 0 netx551
X2051 g5351_1 g5351_0 0 netg5351
X2052 g5588_1 g5588_0 0 netg5588
X2053 g4130_1 g4130_0 0 netg4130
X2054 g2603_1 g2603_2 g2603_0 0 netg2603
X2055 g1517_1 g1517_0 0 netg1517
X2056 g3267_0 g3267_1 g3267_2 0 netg3267
X2057 g4012_0 g4012_1 0 netg4012
X2058 g6556_0 g6556_1 0 netg6556
X2059 g3162_0 g3162_1 g3162_2 0 netg3162
X2060 g4271_1 g4271_0 0 netg4271
X2061 g3709_0 g3709_3 g3709_2 g3709_1 0 netg3709
X2062 g6562_0 g6562_1 0 netg6562
X2063 g1927_0 g1927_1 0 netg1927
X2064 g5852_2 g5852_0 g5852_1 0 netg5852
X2065 g6802_1 g6802_0 g6802_2 0 netg6802
X2066 g5226_0 g5226_2 g5226_1 0 netg5226
X2067 g6951_1 g6951_0 g6951_2 0 netg6951
X2068 g904_2 g904_1 g904_0 0 netg904
X2069 g1995_2 g1995_0 g1995_1 0 netg1995
X2070 g5068_1 g5068_0 g5068_2 0 netg5068
X2071 g5549_2 g5549_1 g5549_0 0 netg5549
X2072 g5243_0 g5243_1 0 netg5243
X2073 g3090_2 g3090_1 g3090_0 0 netg3090
X2074 g6745_2 g6745_0 g6745_1 0 netg6745
X2075 g6086_1 g6086_0 0 netg6086
X2076 g5474_1 g5474_0 0 netg5474
X2077 g901_2 g901_0 g901_1 0 netg901
X2078 g3171_2 g3171_0 g3171_1 0 netg3171
X2079 g5385_0 g5385_1 0 netg5385
X2080 g1012_0 g1012_2 g1012_1 0 netg1012
X2081 g982_2 g982_1 g982_0 0 netg982
X2082 g1079_0 g1079_2 g1079_1 0 netg1079
X2083 g3126_0 g3126_1 g3126_2 0 netg3126
X2084 g6080_0 g6080_1 0 netg6080
X2085 g5139_2 g5139_1 g5139_0 0 netg5139
X2086 g5486_1 g5486_0 0 netg5486
X2087 g7301_1 g7301_0 0 netg7301
X2088 g4167_0 g4167_2 g4167_1 0 netg4167
X2089 g1310_1 g1310_0 0 netg1310
X2090 g7174_1 g7174_0 0 netg7174
X2091 g5694_1 g5694_2 g5694_0 0 netg5694
X2092 g3249_1 g3249_0 g3249_2 0 netg3249
X2093 g5697_0 g5697_1 g5697_2 0 netg5697
X2094 g943_0 g943_2 g943_1 0 netg943
X2095 g6898_0 g6898_1 0 netg6898
X2096 g6109_1 g6109_2 0 netg6109
X2097 x552_0 x552_1 0 netx552
X2098 g3507_0 g3507_1 0 netg3507
X2099 g6389_0 g6389_1 0 netg6389
X2100 g1574_0 g1574_1 0 netg1574
X2101 g5332_1 g5332_0 0 netg5332
X2102 g3536_1 g3536_0 0 netg3536
X2103 g2564_2 g2564_1 0 netg2564
X2104 g4374_0 g4374_1 g4374_2 0 netg4374
X2105 g7109_2 g7109_1 g7109_0 0 netg7109
X2106 g4421_1 g4421_0 0 netg4421
X2107 g2415_2 g2415_1 g2415_0 0 netg2415
X2108 g5041_0 g5041_1 g5041_2 0 netg5041
X2109 g2570_1 g2570_2 g2570_0 0 netg2570
X2110 g5867_2 g5867_0 g5867_1 0 netg5867
X2111 g6879_1 g6879_0 0 netg6879
X2112 g6876_0 g6876_1 0 netg6876
X2113 g5725_1 g5725_0 g5725_2 0 netg5725
X2114 g1942_0 g1942_1 g1942_2 0 netg1942
X2115 g3183_0 g3183_1 g3183_2 0 netg3183
X2116 g4263_1 g4263_0 0 netg4263
X2117 g7425_0 g7425_1 0 netg7425
X2118 g1508_0 g1508_1 0 netg1508
X2119 g1558_0 g1558_1 0 netg1558
X2120 g5434_2 g5434_0 g5434_1 0 netg5434
X2121 g7203_2 g7203_1 g7203_0 0 netg7203
X2122 g7341_1 g7341_0 0 netg7341
X2123 g2804_0 g2804_1 0 netg2804
X2124 g7119_1 g7119_0 g7119_2 0 netg7119
X2125 g4349_1 g4349_0 0 netg4349
X2126 g4260_0 g4260_1 0 netg4260
X2127 g6528_1 g6528_0 0 netg6528
X2128 g7264_1 g7264_0 0 netg7264
X2129 g6905_3 g6905_2 0 netg6905
X2130 g7084_1 g7084_0 0 netg7084
X2131 g4973_0 g4973_2 g4973_1 0 netg4973
X2132 g2656_1 g2656_0 g2656_2 0 netg2656
X2133 g6054_1 g6054_0 0 netg6054
X2134 g5945_2 g5945_1 g5945_0 0 netg5945
X2135 g7207_1 g7207_0 0 netg7207
X2136 g3899_0 g3899_1 0 netg3899
X2137 g889_2 g889_1 g889_0 0 netg889
X2138 g5989_0 g5989_1 0 netg5989
X2139 g2924_1 g2924_0 0 netg2924
X2140 g7176_1 g7176_0 0 netg7176
X2141 g7200_2 g7200_1 g7200_0 0 netg7200
X2142 g1159_0 g1159_1 0 netg1159
X2143 g1121_0 g1121_1 0 netg1121
X2144 g5012_0 g5012_1 g5012_2 0 netg5012
X2145 g4896_2 g4896_1 g4896_0 0 netg4896
X2146 g2832_1 g2832_0 0 netg2832
X2147 g976_2 g976_0 g976_1 0 netg976
X2148 g2866_0 g2866_1 0 netg2866
X2149 g2027_1 g2027_0 0 netg2027
X2150 g7197_0 g7197_1 0 netg7197
X2151 g2942_0 g2942_1 0 netg2942
X2152 x341_1 x341_0 0 netx341
X2153 g6384_0 g6384_1 0 netg6384
X2154 g7309_1 g7309_0 g7309_2 0 netg7309
X2155 g3560_1 g3560_0 0 netg3560
X2156 g1511_1 g1511_0 0 netg1511
X2157 g7327_2 g7327_0 g7327_1 0 netg7327
X2158 g4346_0 g4346_1 g4346_2 0 netg4346
X2159 g6299_0 g6299_1 0 netg6299
X2160 g5529_2 g5529_0 g5529_1 0 netg5529
X2161 g3100_0 g3100_1 0 netg3100
X2162 g6223_0 g6223_2 g6223_1 0 netg6223
X2163 g6247_1 g6247_2 g6247_0 0 netg6247
X2164 g3389_2 g3389_1 g3389_0 0 netg3389
X2165 g7009_1 g7009_0 0 netg7009
X2166 g4259_1 g4259_0 0 netg4259
X2167 x451_0 x451_1 0 netx451
X2168 g1085_0 g1085_1 0 netg1085
X2169 g705_4 g705_6 g705_3 g705_2 g705_0 0 netg705
X2170 g2013_4 g2013_5 g2013_2 g2013_1 g2013_3 0 netg2013
X2171 g6668_1 g6668_0 0 netg6668
X2172 g5414_1 g5414_0 0 netg5414
X2173 g3177_1 g3177_2 0 netg3177
X2174 x202_0 x202_1 0 netx202
X2175 g7431_1 g7431_0 0 netg7431
X2176 g5484_0 g5484_1 0 netg5484
X2177 g5855_0 g5855_1 0 netg5855
X2178 g6884_0 g6884_1 0 netg6884
X2179 g6361_0 g6361_1 0 netg6361
X2180 g7356_0 g7356_1 0 netg7356
X2181 g5440_0 g5440_1 g5440_2 0 netg5440
X2182 g2677_2 g2677_1 0 netg2677
X2183 g6189_0 g6189_1 0 netg6189
X2184 g7375_2 g7375_1 g7375_0 0 netg7375
X2185 g1027_1 g1027_2 g1027_0 0 netg1027
X2186 g812_3 g812_1 g812_2 g812_0 0 netg812
X2187 g1054_1 g1054_0 g1054_2 0 netg1054
X2188 g5575_1 g5575_2 g5575_0 0 netg5575
X2189 g7225_1 g7225_0 g7225_2 0 netg7225
X2190 g6258_1 g6258_0 0 netg6258
X2191 g7060_2 g7060_0 g7060_1 0 netg7060
X2192 g2474_0 g2474_1 g2474_2 0 netg2474
X2193 g6161_1 g6161_0 0 netg6161
X2194 g4350_1 g4350_0 0 netg4350
X2195 g4899_2 g4899_1 g4899_0 0 netg4899
X2196 x32_0 x32_1 0 netx32
X2197 g7540_0 g7540_1 0 netg7540
X2198 g1554_0 g1554_1 0 netg1554
X2199 g5326_1 g5326_0 0 netg5326
X2200 g5150_2 g5150_0 g5150_1 0 netg5150
X2201 g2809_0 g2809_1 0 netg2809
X2202 g6162_0 g6162_1 0 netg6162
X2203 g5451_2 g5451_0 g5451_1 0 netg5451
X2204 g3141_1 g3141_2 g3141_0 0 netg3141
X2205 g3943_1 g3943_3 g3943_0 g3943_2 0 netg3943
X2206 g5080_1 g5080_0 g5080_2 0 netg5080
X2207 g3965_1 g3965_0 g3965_2 0 netg3965
X2208 g5053_1 g5053_0 g5053_2 0 netg5053
X2209 g6217_2 g6217_0 g6217_1 0 netg6217
X2210 g6853_0 g6853_2 g6853_1 0 netg6853
X2211 g4639_0 g4639_2 g4639_1 0 netg4639
X2212 g1917_1 g1917_0 0 netg1917
X2213 x181_1 x181_0 0 netx181
X2214 g6152_1 g6152_0 0 netg6152
X2215 g6121_0 g6121_2 g6121_1 0 netg6121
X2216 g5746_1 g5746_2 g5746_0 0 netg5746
X2217 g3123_1 g3123_2 0 netg3123
X2218 g1468_0 g1468_1 g1468_4 g1468_3 g1468_5 0 netg1468
X2219 g1774_1 g1774_2 g1774_3 g1774_0 0 netg1774
X2220 g4358_0 g4358_1 0 netg4358
X2221 g6237_0 g6237_1 g6237_2 0 netg6237
X2222 g4619_2 g4619_1 0 netg4619
X2223 g5092_0 g5092_2 g5092_1 0 netg5092
X2224 g3240_2 g3240_1 g3240_0 0 netg3240
X2225 g2313_1 g2313_0 0 netg2313
X2226 g4434_1 g4434_0 0 netg4434
X2227 g6300_2 g6300_1 g6300_0 0 netg6300
X2228 g1908_1 g1908_0 0 netg1908
X2229 g1572_0 g1572_1 0 netg1572
X2230 g952_2 g952_0 g952_1 0 netg952
X2231 g5477_0 g5477_1 0 netg5477
X2232 g2480_2 g2480_1 g2480_0 0 netg2480
X2233 g4413_1 g4413_0 0 netg4413
X2234 g5936_1 g5936_0 g5936_2 0 netg5936
X2235 g2510_0 g2510_2 g2510_1 0 netg2510
X2236 g2867_1 g2867_2 g2867_0 0 netg2867
X2237 g6140_1 g6140_0 0 netg6140
X2238 g6188_0 g6188_1 0 netg6188
X2239 g1306_0 g1306_1 0 netg1306
X2240 g6127_1 g6127_2 0 netg6127
X2241 g1434_1 g1434_0 0 netg1434
X2242 g5315_0 g5315_1 0 netg5315
X2243 g6314_1 g6314_0 0 netg6314
X2244 g7363_2 g7363_0 g7363_1 0 netg7363
X2245 g3285_2 g3285_0 g3285_1 0 netg3285
X2246 g3243_1 g3243_2 g3243_0 0 netg3243
X2247 g1036_2 g1036_0 0 netg1036
X2248 g3147_1 g3147_2 g3147_0 0 netg3147
X2249 g3447_1 g3447_2 g3447_0 0 netg3447
X2250 g7245_2 g7245_0 g7245_1 0 netg7245
X2251 g5125_0 g5125_2 g5125_1 0 netg5125
X2252 x262_1 x262_0 0 netx262
X2253 g5271_1 g5271_0 0 netg5271
X2254 g7012_1 g7012_0 0 netg7012
X2255 g7242_1 g7242_2 g7242_0 0 netg7242
X2256 g6471_2 g6471_1 g6471_0 0 netg6471
X2257 g6793_1 g6793_2 g6793_0 0 netg6793
X2258 g7051_0 g7051_2 g7051_1 0 netg7051
X2259 g6658_1 g6658_0 0 netg6658
X2260 g7255_0 g7255_1 0 netg7255
X2261 g1361_0 g1361_1 0 netg1361
X2262 x311_1 x311_0 0 netx311
X2263 g6686_0 g6686_1 0 netg6686
X2264 g925_2 g925_0 g925_1 0 netg925
X2265 g6799_0 g6799_2 g6799_1 0 netg6799
X2266 g6144_2 g6144_1 g6144_0 0 netg6144
X2267 x331_0 x331_1 0 netx331
X2268 g3135_1 g3135_0 g3135_2 0 netg3135
X2269 g7527_0 g7527_1 0 netg7527
X2270 g6524_1 g6524_0 0 netg6524
X2271 g3559_0 g3559_1 0 netg3559
X2272 g1555_0 g1555_1 0 netg1555
X2273 g940_2 g940_1 g940_0 0 netg940
X2274 g5487_1 g5487_0 0 netg5487
X2275 g5412_0 g5412_1 0 netg5412
X2276 g567_1 g567_0 g567_2 0 netg567
X2277 x561_1 x561_0 0 netx561
X2278 g5716_0 g5716_2 g5716_1 0 netg5716
X2279 g1302_0 g1302_1 0 netg1302
X2280 g7404_1 g7404_0 0 netg7404
X2281 g3371_2 g3371_1 g3371_0 0 netg3371
X2282 g2241_1 g2241_0 g2241_2 0 netg2241
X2283 g6509_0 g6509_1 0 netg6509
X2284 g4943_2 g4943_1 g4943_0 0 netg4943
X2285 g6310_0 g6310_1 0 netg6310
X2286 g6085_1 g6085_0 0 netg6085
X2287 g1438_0 g1438_1 0 netg1438
X2288 g5778_1 g5778_0 0 netg5778
X2289 g7414_0 g7414_2 g7414_1 0 netg7414
X2290 g7237_2 g7237_0 g7237_1 0 netg7237
X2291 g3150_1 g3150_2 g3150_0 0 netg3150
X2292 g7153_1 g7153_0 g7153_2 0 netg7153
X2293 g1520_1 g1520_0 0 netg1520
X2294 g5722_2 g5722_1 g5722_0 0 netg5722
X2295 g1497_1 g1497_0 0 netg1497
X2296 g4447_0 g4447_1 0 netg4447
X2297 g5843_2 g5843_1 g5843_0 0 netg5843
X2298 g98_0 g98_1 0 netg98
X2299 g5521_0 g5521_1 0 netg5521
X2300 g2612_1 g2612_2 g2612_0 0 netg2612
X2301 g7428_1 g7428_2 g7428_0 0 netg7428
X2302 g1853_2 g1853_1 g1853_0 0 netg1853
X2303 g7027_2 g7027_1 0 netg7027
X2304 g2752_0 g2752_3 g2752_2 g2752_1 0 netg2752
X2305 g4217_1 g4217_0 0 netg4217
X2306 g5563_0 g5563_2 g5563_1 0 netg5563
X2307 g2728_0 g2728_1 g2728_2 0 netg2728
X2308 g7336_0 g7336_2 g7336_1 0 netg7336
X2309 g3060_1 g3060_0 0 netg3060
X2310 g6453_1 g6453_0 g6453_2 0 netg6453
X2311 g7193_1 g7193_0 g7193_2 0 netg7193
X2312 g5917_1 g5917_2 g5917_0 0 netg5917
X2313 g4117_0 g4117_3 g4117_1 g4117_2 0 netg4117
X2314 g2686_1 g2686_0 g2686_2 0 netg2686
X2315 g5643_2 g5643_0 g5643_1 0 netg5643
X2316 g4357_0 g4357_1 0 netg4357
X2317 g3213_2 g3213_1 0 netg3213
X2318 x51_1 x51_0 0 netx51
X2319 x151_0 x151_1 0 netx151
X2320 g6995_0 g6995_1 0 netg6995
X2321 g4423_0 g4423_1 0 netg4423
X2322 g6537_1 g6537_0 0 netg6537
X2323 g6560_1 g6560_0 0 netg6560
X2324 g7015_1 g7015_0 0 netg7015
X2325 g3086_1 g3086_2 g3086_0 0 netg3086
X2326 g6396_1 g6396_0 0 netg6396
X2327 g5710_2 g5710_0 g5710_1 0 netg5710
X2328 g5044_1 g5044_0 g5044_2 0 netg5044
X2329 g5834_1 g5834_0 0 netg5834
X2330 g5871_2 g5871_0 0 netg5871
X2331 g6850_1 g6850_0 g6850_2 0 netg6850
X2332 g2023_2 g2023_3 g2023_1 0 netg2023
X2333 g1940_0 g1940_1 0 netg1940
X2334 g2549_0 g2549_1 g2549_2 0 netg2549
X2335 g1030_1 g1030_2 0 netg1030
X2336 g2070_1 g2070_0 0 netg2070
X2337 g1478_0 g1478_1 0 netg1478
X2338 g4666_1 g4666_0 0 netg4666
X2339 g4625_1 g4625_0 0 netg4625
X2340 g3914_0 g3914_1 0 netg3914
X2341 g7321_0 g7321_2 g7321_1 0 netg7321
X2342 g5780_1 g5780_2 0 netg5780
X2343 g6318_2 g6318_0 g6318_1 g6318_3 0 netg6318
X2344 g1060_2 g1060_3 g1060_5 g1060_4 g1060_1 g1060_0 0 netg1060
X2345 g3407_1 g3407_2 g3407_0 0 netg3407
X2346 g5083_0 g5083_1 g5083_2 0 netg5083
X2347 g5489_0 g5489_1 0 netg5489
X2348 g3270_0 g3270_1 g3270_2 0 netg3270
X2349 g7421_1 g7421_0 0 netg7421
X2350 x472_1 x472_0 0 netx472
X2351 g3947_0 g3947_1 g3947_2 0 netg3947
X2352 g1897_0 g1897_1 0 netg1897
X2353 g5903_1 g5903_0 g5903_2 0 netg5903
X2354 g4931_0 g4931_3 g4931_1 g4931_2 0 netg4931
X2355 g7033_0 g7033_1 g7033_4 g7033_3 0 netg7033
X2356 g6826_0 g6826_1 0 netg6826
X2357 g5649_0 g5649_2 g5649_1 0 netg5649
X2358 g3526_0 g3526_1 0 netg3526
X2359 g4967_1 g4967_2 g4967_0 0 netg4967
X2360 g1066_0 g1066_1 g1066_2 0 netg1066
X2361 g5707_1 g5707_0 g5707_2 0 netg5707
X2362 g7088_0 g7088_1 0 netg7088
X2363 g5912_2 g5912_0 g5912_1 0 netg5912
X2364 g5942_2 g5942_1 g5942_0 0 netg5942
X2365 g4940_2 g4940_0 g4940_1 0 netg4940
X2366 g2756_0 g2756_2 g2756_1 0 netg2756
X2367 g3444_1 g3444_0 g3444_2 0 netg3444
X2368 g4183_0 g4183_1 g4183_2 0 netg4183
X2369 g1536_1 g1536_0 0 netg1536
X2370 g1006_2 g1006_0 g1006_1 0 netg1006
X2371 g2938_1 g2938_0 0 netg2938
X2372 g4964_1 g4964_2 g4964_0 0 netg4964
X2373 g2848_1 g2848_0 0 netg2848
X2374 g1101_1 g1101_0 0 netg1101
X2375 g1458_1 g1458_0 0 netg1458
X2376 g5095_2 g5095_1 g5095_0 0 netg5095
X2377 g3483_1 g3483_0 0 netg3483
X2378 g4188_0 g4188_1 0 netg4188
X2379 g3002_1 g3002_0 0 netg3002
X2380 g5464_1 g5464_0 0 netg5464
X2381 g2522_2 g2522_1 g2522_0 0 netg2522
X2382 g1330_6 g1330_5 g1330_4 g1330_0 g1330_3 g1330_1 0 netg1330
X2383 g5272_0 g5272_1 0 netg5272
X2384 g5761_0 g5761_1 g5761_2 0 netg5761
X2385 g1152_0 g1152_1 0 netg1152
X2386 g7411_0 g7411_1 0 netg7411
X2387 g1120_1 g1120_0 0 netg1120
X2388 g5881_2 g5881_1 g5881_0 0 netg5881
X2389 x541_1 x541_0 0 netx541
X2390 g5894_1 g5894_2 g5894_0 0 netg5894
X2391 g6269_0 g6269_2 g6269_1 0 netg6269
X2392 g6990_1 g6990_2 g6990_0 0 netg6990
X2393 g7366_0 g7366_2 g7366_1 0 netg7366
X2394 g7158_1 g7158_2 g7158_0 0 netg7158
X2395 g5220_0 g5220_2 g5220_1 0 netg5220
X2396 g3255_2 g3255_1 g3255_0 0 netg3255
X2397 g1344_0 g1344_1 g1344_3 g1344_2 g1344_5 g1344_4 0 netg1344
X2398 g5926_1 g5926_2 g5926_0 0 netg5926
X2399 g487_0 g487_1 0 netg487
X2400 g5891_1 g5891_2 g5891_0 0 netg5891
X2401 g7303_2 g7303_1 g7303_0 0 netg7303
X2402 g4756_0 g4756_3 g4756_2 g4756_1 0 netg4756
X2403 g5758_0 g5758_1 g5758_2 0 netg5758
X2404 g5478_1 g5478_0 0 netg5478
X2405 g5613_0 g5613_1 g5613_2 0 netg5613
X2406 g4661_1 g4661_0 0 netg4661
X2407 g2650_1 g2650_0 g2650_2 0 netg2650
X2408 g100_0 g100_1 0 netg100
X2409 g6631_1 g6631_2 g6631_0 0 netg6631
X2410 g6346_1 g6346_3 g6346_0 0 netg6346
X2411 g5930_1 g5930_0 0 netg5930
X2412 g5688_0 g5688_2 g5688_1 0 netg5688
X2413 g6023_1 g6023_0 g6023_2 0 netg6023
X2414 g2423_2 g2423_1 g2423_0 0 netg2423
X2415 g1404_1 g1404_0 0 netg1404
X2416 g6818_1 g6818_0 0 netg6818
X2417 g747_3 g747_1 g747_4 g747_2 g747_0 0 netg747
X2418 g6147_2 g6147_0 g6147_1 0 netg6147
X2419 g2761_1 g2761_0 0 netg2761
X2420 g5431_0 g5431_2 g5431_1 0 netg5431
X2421 g6481_1 g6481_2 g6481_0 0 netg6481
X2422 g7551_1 g7551_0 0 netg7551
X2423 g4030_0 g4030_3 g4030_1 g4030_2 0 netg4030
X2424 g5743_0 g5743_2 g5743_1 0 netg5743
X2425 g3482_1 g3482_0 0 netg3482
X2426 g1286_1 g1286_0 0 netg1286
X2427 g4422_0 g4422_1 0 netg4422
X2428 g2668_2 g2668_0 0 netg2668
X2429 g7065_1 g7065_0 g7065_2 0 netg7065
X2430 g4368_1 g4368_0 g4368_2 0 netg4368
X2431 g4913_2 g4913_1 g4913_3 0 netg4913
X2432 g3106_0 g3106_2 g3106_1 0 netg3106
X2433 g3374_0 g3374_1 g3374_2 0 netg3374
X2434 g1986_1 g1986_0 g1986_2 g1986_3 0 netg1986
X2435 g1484_1 g1484_5 g1484_4 g1484_0 g1484_2 0 netg1484
X2436 g5174_2 g5174_1 g5174_0 0 netg5174
X2437 g4400_0 g4400_1 0 netg4400
X2438 g6867_1 g6867_2 g6867_0 0 netg6867
X2439 g5352_1 g5352_0 0 netg5352
X2440 g973_2 g973_1 g973_0 0 netg973
X2441 g4017_1 g4017_0 0 netg4017
X2442 g3068_1 g3068_0 0 netg3068
X2443 g3189_1 g3189_2 g3189_0 0 netg3189
X2444 g5479_1 g5479_0 0 netg5479
X2445 g4917_2 g4917_0 g4917_1 0 netg4917
X2446 g5437_2 g5437_0 g5437_1 0 netg5437
X2447 g1287_1 g1287_0 0 netg1287
X2448 g4429_0 g4429_2 g4429_1 0 netg4429
X2449 g1911_1 g1911_0 0 netg1911
X2450 g1150_1 g1150_0 0 netg1150
X2451 g2230_1 g2230_0 0 netg2230
X2452 g110_0 g110_1 0 netg110
X2453 g6864_1 g6864_0 g6864_2 0 netg6864
X2454 g5900_0 g5900_1 g5900_2 0 netg5900
X2455 g1912_0 g1912_1 0 netg1912
X2456 g2567_1 g2567_2 g2567_0 0 netg2567
X2457 g5572_2 g5572_1 0 netg5572
X2458 g6350_0 g6350_1 0 netg6350
X2459 g4193_2 g4193_1 g4193_0 0 netg4193
X2460 g4778_2 g4778_0 g4778_1 0 netg4778
X2461 g1719_1 g1719_2 g1719_3 0 netg1719
X2462 g7287_1 g7287_0 g7287_2 0 netg7287
X2463 g6407_1 g6407_0 0 netg6407
X2464 g3522_1 g3522_0 0 netg3522
X2465 g5652_0 g5652_1 g5652_2 0 netg5652
X2466 g3490_1 g3490_0 0 netg3490
X2467 g5749_0 g5749_2 g5749_1 0 netg5749
X2468 g2383_0 g2383_2 g2383_1 0 netg2383
X2469 g5631_1 g5631_0 g5631_2 0 netg5631
X2470 g4078_0 g4078_3 g4078_2 g4078_1 0 netg4078
X2471 g7423_0 g7423_1 0 netg7423
X2472 g4196_1 g4196_2 0 netg4196
X2473 g3528_1 g3528_0 0 netg3528
X2474 g5984_0 g5984_1 0 netg5984
X2475 g3210_1 g3210_2 0 netg3210
X2476 g5655_0 g5655_1 g5655_2 0 netg5655
X2477 g4074_3 g4074_1 g4074_2 g4074_0 0 netg4074
X2478 g5202_1 g5202_0 g5202_2 0 netg5202
X2479 g6442_1 g6442_2 g6442_0 0 netg6442
X2480 g3291_2 g3291_0 g3291_1 0 netg3291
X2481 g907_2 g907_1 g907_0 0 netg907
X2482 g5637_0 g5637_2 g5637_1 0 netg5637
X2483 g4232_1 g4232_0 0 netg4232
X2484 x141_0 x141_1 0 netx141
X2485 g4449_1 g4449_0 0 netg4449
X2486 g2671_1 g2671_0 g2671_2 0 netg2671
X2487 g2365_0 g2365_2 g2365_1 0 netg2365
X2488 g5610_0 g5610_2 g5610_1 0 netg5610
X2489 g5309_0 g5309_1 g5309_3 g5309_2 0 netg5309
X2490 g413_1 g413_2 g413_0 g413_3 g413_4 0 netg413
X2491 g6880_1 g6880_0 0 netg6880
X2492 g3432_1 g3432_0 g3432_2 0 netg3432
X2493 g4161_1 g4161_2 g4161_0 0 netg4161
X2494 g3462_0 g3462_1 g3462_2 0 netg3462
X2495 g1575_1 g1575_0 0 netg1575
X2496 g2088_0 g2088_1 0 netg2088
X2497 g6754_0 g6754_2 g6754_1 0 netg6754
X2498 g1529_1 g1529_0 0 netg1529
X2499 x502_0 x502_1 0 netx502
X2500 g4026_2 g4026_3 g4026_1 g4026_0 0 netg4026
X2501 g1532_1 g1532_0 0 netg1532
X2502 g1868_2 g1868_0 0 netg1868
X2503 g7150_2 g7150_0 g7150_1 0 netg7150
X2504 g4250_1 g4250_0 0 netg4250
X2505 g1762_2 g1762_1 g1762_0 0 netg1762
X2506 g2239_1 g2239_0 0 netg2239
X2507 g3333_1 g3333_2 g3333_0 0 netg3333
X2508 g1364_1 g1364_0 0 netg1364
X2509 g6075_2 g6075_0 g6075_3 g6075_1 0 netg6075
X2510 g1896_1 g1896_0 0 netg1896
X2511 g6882_0 g6882_1 0 netg6882
X2512 g500_0 g500_1 0 netg500
X2513 g5806_1 g5806_2 g5806_0 0 netg5806
X2514 g2647_2 g2647_1 g2647_0 0 netg2647
X2515 g6618_0 g6618_1 g6618_2 0 netg6618
X2516 g6911_4 g6911_1 g6911_3 g6911_2 g6911_0 0 netg6911
X2517 g2935_0 g2935_1 0 netg2935
X2518 g4365_1 g4365_0 g4365_2 0 netg4365
X2519 g5897_2 g5897_1 g5897_0 0 netg5897
X2520 g7222_2 g7222_1 g7222_0 0 netg7222
X2521 g1496_1 g1496_0 0 netg1496
X2522 g7281_1 g7281_0 g7281_2 0 netg7281
X2523 g2989_2 g2989_3 g2989_1 g2989_5 g2989_4 g2989_0 0 netg2989
X2524 g2081_0 g2081_3 g2081_2 g2081_1 g2081_5 g2081_6 g2081_4 0 netg2081
X2525 g7318_2 g7318_1 0 netg7318
X2526 g1506_0 g1506_1 0 netg1506
X2527 g1590_1 g1590_0 0 netg1590
X2528 g4767_2 g4767_0 g4767_1 g4767_3 0 netg4767
X2529 g4113_2 g4113_3 g4113_1 g4113_0 0 netg4113
X2530 g4392_2 g4392_0 g4392_1 0 netg4392
X2531 g1399_0 g1399_1 0 netg1399
X2532 g1910_0 g1910_1 0 netg1910
X2533 x161_0 x161_1 0 netx161
X2534 g5820_2 g5820_1 g5820_0 g5820_3 0 netg5820
X2535 g1588_0 g1588_1 0 netg1588
X2536 g3961_3 g3961_2 g3961_0 g3961_1 0 netg3961
X2537 g2019_3 g2019_1 g2019_0 0 netg2019
X2538 g4210_2 g4210_0 0 netg4210
X2539 g3195_2 g3195_0 g3195_1 0 netg3195
X2540 g6475_1 g6475_2 0 netg6475
X2541 g6304_0 g6304_2 g6304_1 0 netg6304
X2542 g3174_0 g3174_2 g3174_1 0 netg3174
X2543 g109_0 g109_1 0 netg109
X2544 g4653_3 g4653_2 g4653_1 g4653_0 0 netg4653
X2545 g6438_0 g6438_1 0 netg6438
X2546 g561_4 g561_0 g561_3 g561_1 g561_2 0 netg561
X2547 g4760_1 g4760_3 g4760_2 g4760_0 0 netg4760
X2548 g1400_1 g1400_0 0 netg1400
X2549 g1559_5 g1559_4 g1559_2 g1559_0 g1559_1 g1559_3 0 netg1559
X2550 x191_1 x191_0 0 netx191
X2551 x372_0 x372_1 0 netx372
X2552 g4456_4 g4456_6 g4456_5 g4456_2 g4456_1 g4456_3 g4456_0 0 netg4456
X2553 x431_0 x431_1 0 netx431
X2554 g3484_0 g3484_1 0 netg3484
X2555 g4630_0 g4630_3 g4630_1 g4630_4 g4630_2 0 netg4630
X2556 g1503_1 g1503_0 0 netg1503
X2557 g5939_1 g5939_2 g5939_0 0 netg5939
X2558 g785_6 g785_2 g785_3 g785_0 g785_5 g785_4 0 netg785
X2559 g5971_1 g5971_0 0 netg5971
X2560 g4146_0 g4146_1 g4146_2 0 netg4146
X2561 g3144_2 g3144_1 g3144_0 0 netg3144
X2562 g1543_5 g1543_0 g1543_2 g1543_4 g1543_3 g1543_1 0 netg1543
X2563 g1323_6 g1323_1 g1323_4 g1323_5 g1323_3 0 netg1323
X2564 g7549_1 g7549_0 0 netg7549
X2565 g6840_2 g6840_0 g6840_1 0 netg6840
X2566 g6284_1 g6284_0 g6284_2 0 netg6284
X2567 g4383_2 g4383_1 g4383_0 0 netg4383
X2568 g5933_1 g5933_2 0 netg5933
X2569 g1537_1 g1537_4 g1537_2 g1537_5 g1537_3 g1537_0 0 netg1537
X2570 g4750_2 g4750_0 g4750_1 0 netg4750
X2571 g7141_0 g7141_2 g7141_1 0 netg7141
X2572 g5122_2 g5122_1 g5122_0 0 netg5122
X2573 g3201_2 g3201_0 g3201_1 0 netg3201
X2574 g1493_0 g1493_1 0 netg1493
X2575 g6322_3 g6322_1 g6322_0 g6322_2 0 netg6322
X2576 g5459_2 g5459_1 g5459_0 0 netg5459
X2577 g5795_0 g5795_1 g5795_2 g5795_3 0 netg5795
X2578 g6491_1 g6491_2 0 netg6491
X2579 g3971_1 g3971_0 0 netg3971
X2580 g1153_1 g1153_0 0 netg1153
X2581 g1499_0 g1499_1 0 netg1499
X2582 g6919_0 g6919_1 0 netg6919
X2583 g2456_1 g2456_2 0 netg2456
X2584 g4949_3 g4949_0 g4949_1 g4949_2 0 netg4949
X2585 g3153_0 g3153_2 0 netg3153
X2586 g2585_1 g2585_0 g2585_2 0 netg2585
X2587 g5177_1 g5177_0 0 netg5177
X2588 g3938_4 g3938_0 g3938_1 g3938_3 g3938_2 0 netg3938
X2589 g1848_0 g1848_1 g1848_3 g1848_2 0 netg1848
X2590 g5217_2 g5217_0 0 netg5217
X2591 g2223_1 g2223_0 0 netg2223
X2592 g6628_1 g6628_2 g6628_0 0 netg6628
X2593 g4660_1 g4660_0 0 netg4660
X2594 g1961_3 g1961_1 g1961_0 g1961_2 0 netg1961
X2595 g2004_1 g2004_3 g2004_0 g2004_2 0 netg2004
X2596 g1423_1 g1423_0 g1423_4 g1423_3 g1423_2 0 netg1423
X2597 g5388_2 g5388_1 g5388_0 0 netg5388
X2598 g5974_0 g5974_1 g5974_2 0 netg5974
X2599 x462_0 x462_1 0 netx462
X2600 g780_3 g780_1 g780_2 g780_0 g780_4 0 netg780
X2601 g7048_2 g7048_1 g7048_0 0 netg7048
X2602 g7030_1 g7030_2 0 netg7030
X2603 g6559_1 g6559_0 0 netg6559
X2604 g3698_3 g3698_0 g3698_2 g3698_1 0 netg3698
X2605 g4960_3 g4960_0 g4960_2 g4960_1 0 netg4960
X2606 g4775_1 g4775_0 g4775_2 0 netg4775
X2607 g7378_1 g7378_0 g7378_2 0 netg7378
X2608 g4006_1 g4006_0 0 netg4006
X2609 g1206_2 g1206_4 g1206_3 g1206_1 g1206_0 g1206_5 0 netg1206
X2610 x31_1 x31_0 0 netx31
X2611 g4386_2 g4386_0 g4386_1 0 netg4386
X2612 g7420_0 g7420_1 0 netg7420
X2613 g3999_3 g3999_1 g3999_2 g3999_0 0 netg3999
X2614 g5713_1 g5713_0 g5713_2 0 netg5713
X2615 g1289_3 g1289_2 g1289_5 g1289_1 g1289_4 0 netg1289
X2616 g7315_2 g7315_0 0 netg7315
X2617 g95_1 g95_0 0 netg95
X2618 g6263_0 g6263_2 g6263_1 0 netg6263
X2619 g5680_2 g5680_1 g5680_0 0 netg5680
X2620 g3330_2 g3330_0 g3330_1 0 netg3330
X2621 g1716_2 g1716_0 g1716_1 0 netg1716
X2622 g6881_0 g6881_1 0 netg6881
X2623 g3491_0 g3491_1 0 netg3491
X2624 g3053_1 g3053_0 0 netg3053
X2625 g3705_2 g3705_0 g3705_3 g3705_1 0 netg3705
X2626 g4635_3 g4635_0 g4635_2 g4635_1 0 netg4635
X2627 g2525_1 g2525_2 g2525_0 0 netg2525
X2628 g115_1 g115_0 0 netg115
X2629 g1246_1 g1246_3 g1246_2 g1246_0 0 netg1246
X2630 g3637_5 g3637_1 g3637_6 g3637_4 g3637_0 g3637_3 g3637_2 0 netg3637
X2631 g6760_4 g6760_3 g6760_2 g6760_1 g6760_0 0 netg6760
X2632 g5404_0 g5404_1 g5404_2 0 netg5404
X2633 g792_1 g792_0 g792_3 g792_2 0 netg792
X2634 g6176_3 g6176_2 g6176_1 g6176_0 0 netg6176
X2635 g6710_1 g6710_0 0 netg6710
X2636 g4920_5 g4920_0 g4920_4 g4920_1 g4920_2 g4920_3 0 netg4920
X2637 g3132_2 g3132_0 g3132_1 0 netg3132
X2638 g2870_3 g2870_0 g2870_1 0 netg2870
X2639 g691_2 g691_0 g691_1 0 netg691
X2640 g5211_2 g5211_1 g5211_0 0 netg5211
X2641 g6957_1 g6957_2 g6957_0 0 netg6957
X2642 g1316_3 g1316_2 g1316_6 g1316_1 g1316_5 g1316_4 0 netg1316
X2643 g5948_0 g5948_1 g5948_2 0 netg5948
X2644 g2062_0 g2062_3 g2062_2 g2062_7 g2062_5 g2062_4 g2062_1 0 netg2062
X2645 g6294_1 g6294_2 g6294_0 0 netg6294
X2646 g5628_1 g5628_2 g5628_0 0 netg5628
X2647 g6372_1 g6372_0 0 netg6372
X2648 g7057_0 g7057_1 g7057_2 0 netg7057
X2649 g3252_1 g3252_2 g3252_0 0 netg3252
X2650 g796_2 g796_1 g796_0 0 netg796
X2651 g4648_1 g4648_3 g4648_0 g4648_4 g4648_2 0 netg4648
X2652 g5752_0 g5752_2 g5752_1 0 netg5752
X2653 g4642_2 g4642_1 g4642_5 g4642_3 g4642_0 g4642_4 0 netg4642
X2654 g113_0 g113_1 0 netg113
X2655 g2235_3 g2235_1 g2235_2 g2235_0 0 netg2235
X2656 g5783_0 g5783_1 0 netg5783
X2657 g816_4 g816_0 g816_3 0 netg816
X2658 g3013_1 g3013_4 g3013_2 g3013_0 g3013_5 g3013_3 0 netg3013
X2659 g7284_2 g7284_1 0 netg7284
X2660 g6859_0 g6859_2 g6859_1 0 netg6859
X2661 g1576_1 g1576_0 0 netg1576
X2662 g4884_2 g4884_0 0 netg4884
X2663 g3988_2 g3988_4 g3988_3 g3988_1 g3988_5 g3988_0 0 netg3988
X2664 g2896_1 g2896_0 0 netg2896
X2665 g2977_0 g2977_1 g2977_2 0 netg2977
X2666 g3683_1 g3683_0 g3683_3 0 netg3683
X2667 g4233_1 g4233_0 0 netg4233
X2668 g4771_3 g4771_2 g4771_1 g4771_0 0 netg4771
X2669 g1363_0 g1363_1 0 netg1363
X2670 g116_1 g116_0 0 netg116
X2671 g1909_1 g1909_0 0 netg1909
X2672 g1397_1 g1397_0 0 netg1397
X2673 g1914_0 g1914_1 0 netg1914
X2674 g1880_1 g1880_0 g1880_2 0 netg1880
X2675 g5197_2 g5197_1 0 netg5197
X2676 g6045_0 g6045_1 0 netg6045
X2677 g5496_2 g5496_0 g5496_1 0 netg5496
X2678 g4908_2 g4908_4 g4908_1 g4908_3 g4908_0 0 netg4908
X2679 g1505_1 g1505_0 0 netg1505
X2680 g5234_1 g5234_0 0 netg5234
X2681 g1898_0 g1898_1 0 netg1898
X2682 g1504_0 g1504_1 0 netg1504
X2683 g7038_1 g7038_0 g7038_2 0 netg7038
X2684 g4088_2 g4088_1 g4088_3 g4088_0 0 netg4088
X2685 g5235_0 g5235_1 0 netg5235
X2686 g1144_2 g1144_5 g1144_3 g1144_1 g1144_4 g1144_0 0 netg1144
X2687 g1580_1 g1580_0 0 netg1580
X2688 g4314_1 g4314_0 0 netg4314
X2689 g2890_3 g2890_1 g2890_5 g2890_0 g2890_4 g2890_2 0 netg2890
X2690 g1670_3 g1670_2 g1670_0 g1670_1 0 netg1670
X2691 g1495_0 g1495_1 0 netg1495
X2692 g6781_1 g6781_0 g6781_2 0 netg6781
X2693 g3204_2 g3204_1 0 netg3204
X2694 g6757_2 g6757_1 g6757_0 0 netg6757
X2695 g1527_1 g1527_0 0 netg1527
X2696 g2922_0 g2922_1 0 netg2922
X2697 g1920_0 g1920_1 0 netg1920
X2698 g5755_2 g5755_1 g5755_0 0 netg5755
X2699 g4611_2 g4611_5 g4611_1 g4611_4 g4611_0 g4611_3 0 netg4611
X2700 g1437_0 g1437_1 0 netg1437
X2701 g1891_0 g1891_1 0 netg1891
X2702 g1915_1 g1915_0 0 netg1915
X2703 g2167_1 g2167_0 g2167_3 g2167_2 0 netg2167
X2704 g3282_2 g3282_1 g3282_0 0 netg3282
X2705 g3713_1 g3713_0 g3713_2 0 netg3713
X2706 g4124_2 g4124_3 g4124_1 g4124_0 0 netg4124
X2707 g117_0 g117_1 0 netg117
X2708 g3725_9 g3725_8 g3725_6 g3725_5 g3725_10 g3725_0 g3725_2 g3725_3 g3725_7 0 netg3725
X2709 g4143_1 g4143_0 g4143_2 0 netg4143
X2710 g1192_1 g1192_0 g1192_5 g1192_2 g1192_6 g1192_3 0 netg1192
X2711 g6336_0 g6336_1 g6336_3 g6336_2 0 netg6336
X2712 g518_1 g518_0 0 netg518
X2713 g1528_1 g1528_0 0 netg1528
X2714 g3797_2 g3797_5 g3797_0 g3797_4 g3797_3 0 netg3797
X2715 g85_0 g85_1 0 netg85
X2716 g1990_2 g1990_0 g1990_3 g1990_1 0 netg1990
X2717 g1515_0 g1515_1 0 netg1515
X2718 g1440_5 g1440_2 g1440_3 g1440_1 g1440_4 g1440_0 0 netg1440
X2719 g3907_2 g3907_4 g3907_1 g3907_0 g3907_5 g3907_3 0 netg3907
X2720 g6016_5 g6016_4 g6016_3 g6016_2 g6016_0 g6016_6 g6016_1 0 netg6016
X2721 g6204_0 g6204_1 0 netg6204
X2722 g7096_1 g7096_0 g7096_2 0 netg7096
X2723 g7412_1 g7412_0 0 netg7412
X2724 g1723_0 g1723_2 g1723_3 g1723_1 0 netg1723
X2725 g5824_0 g5824_1 g5824_2 0 netg5824
X2726 g3004_3 g3004_2 g3004_0 g3004_1 0 netg3004
X2727 g5156_2 g5156_3 g5156_0 g5156_1 0 netg5156
X2728 g6939_1 g6939_0 0 netg6939
X2729 g7528_0 g7528_1 0 netg7528
X2730 g6377_3 g6377_1 g6377_2 g6377_0 0 netg6377
X2731 g2901_2 g2901_5 g2901_4 g2901_3 g2901_1 g2901_0 0 netg2901
X2732 g5136_2 g5136_1 g5136_0 0 netg5136
X2733 g1402_0 g1402_1 0 netg1402
X2734 g6359_1 g6359_0 0 netg6359
X2735 g4199_0 g4199_1 g4199_2 0 netg4199
X2736 g4926_3 g4926_2 g4926_4 g4926_0 g4926_1 0 netg4926
X2737 g2033_4 g2033_1 g2033_0 g2033_3 g2033_2 0 netg2033
X2738 g5956_1 g5956_0 0 netg5956
X2739 g4863_4 g4863_5 g4863_2 g4863_1 g4863_3 g4863_0 0 netg4863
X2740 g2897_3 g2897_2 g2897_1 g2897_0 0 netg2897
X2741 g2881_3 g2881_2 g2881_0 0 netg2881
X2742 g2163_2 g2163_3 g2163_1 0 netg2163
X2743 g5770_3 g5770_2 g5770_1 g5770_0 0 netg5770
X2744 g5163_2 g5163_1 g5163_0 0 netg5163
X2745 g1401_1 g1401_0 0 netg1401
X2746 g2980_2 g2980_0 g2980_3 g2980_1 0 netg2980
X2747 g1577_0 g1577_1 0 netg1577
X2748 g835_1 g835_4 g835_3 g835_2 g835_6 g835_5 g835_0 0 netg835
X2749 g3489_0 g3489_1 0 netg3489
X2750 g4532_5 g4532_4 g4532_2 g4532_6 g4532_1 g4532_3 g4532_0 0 netg4532
X2751 g1902_1 g1902_0 0 netg1902
X2752 g6563_1 g6563_0 0 netg6563
X2753 g4622_0 g4622_1 0 netg4622
X2754 g3008_1 g3008_4 g3008_2 g3008_3 g3008_0 0 netg3008
X2755 g4623_0 g4623_1 0 netg4623
X2756 g6833_3 g6833_2 g6833_0 g6833_1 0 netg6833
X2757 g78_0 g78_1 0 netg78
X2758 g1521_3 g1521_1 g1521_2 g1521_5 g1521_4 g1521_0 0 netg1521
X2759 g5802_3 g5802_1 g5802_2 g5802_0 0 netg5802
X2760 x511_0 x511_1 0 netx511
X2761 g1892_1 g1892_0 0 netg1892
X2762 g4624_1 g4624_0 0 netg4624
X2763 g3994_1 g3994_4 g3994_0 g3994_2 g3994_3 0 netg3994
X2764 g1507_1 g1507_0 0 netg1507
X2765 g2984_1 g2984_3 g2984_0 g2984_4 g2984_2 0 netg2984
X2766 g2071_2 g2071_0 g2071_1 g2071_3 0 netg2071
X2767 g3675_1 g3675_0 g3675_3 g3675_6 g3675_2 g3675_5 g3675_4 0 netg3675
X2768 g1446_2 g1446_5 g1446_0 g1446_1 g1446_4 g1446_3 0 netg1446
X2769 g3654_8 g3654_7 g3654_10 g3654_4 g3654_9 g3654_0 g3654_2 g3654_3 g3654_1 g3654_6 g3654_5 0 netg3654
X2770 g92_1 g92_0 0 netg92
X2771 g7533_0 g7533_1 0 netg7533
X2772 g2874_1 g2874_3 g2874_2 g2874_0 g2874_4 0 netg2874
X2773 g1199_2 g1199_0 g1199_5 g1199_3 g1199_1 g1199_6 g1199_4 0 netg1199
X2774 g1586_1 g1586_0 0 netg1586
X2775 g1403_0 g1403_1 0 netg1403
X2776 g107_1 g107_0 0 netg107
X2777 g1097_1 g1097_0 0 netg1097
X2778 g2885_2 g2885_4 g2885_1 g2885_3 g2885_0 0 netg2885
X2779 x492_1 x492_0 0 netx492
X2780 g6677_2 g6677_1 g6677_3 g6677_4 g6677_0 0 netg6677
X2781 g5205_1 g5205_2 g5205_0 0 netg5205
X2782 g4742_5 g4742_3 g4742_4 g4742_2 g4742_0 g4742_6 g4742_1 0 netg4742
X2783 g94_1 g94_0 0 netg94
X2784 g1565_0 g1565_2 g1565_4 g1565_5 g1565_3 0 netg1565
X2785 g5493_0 g5493_2 g5493_1 0 netg5493
X2786 g767_4 g767_2 g767_0 g767_1 g767_3 0 netg767
X2787 g1795_2 g1795_3 g1795_1 0 netg1795
X2788 g5178_1 g5178_0 g5178_2 0 netg5178
X2789 g2959_1 g2959_3 g2959_0 g2959_2 0 netg2959
X2790 g1766_3 g1766_2 g1766_1 g1766_0 0 netg1766
X2791 g418_3 g418_4 g418_2 g418_0 0 netg418
X2792 g5395_0 g5395_4 g5395_2 g5395_1 g5395_5 g5395_3 g5395_6 g5395_8 g5395_7 0 netg5395
X2793 g1295_4 g1295_2 g1295_1 g1295_6 g1295_0 g1295_5 g1295_3 0 netg1295
X2794 x542_1 x542_0 0 netx542
X2795 g1778_0 g1778_3 g1778_1 g1778_2 0 netg1778
X2796 g2038_0 g2038_3 g2038_5 g2038_4 g2038_2 g2038_1 0 netg2038
X2797 g734_1 g734_5 g734_4 g734_2 g734_0 0 netg734
X2798 g1269_2 g1269_4 g1269_5 g1269_3 g1269_0 g1269_1 0 netg1269
X2799 g1608_3 g1608_0 g1608_1 g1608_2 0 netg1608
X2800 g1957_0 g1957_1 g1957_2 0 netg1957
X2801 g1799_1 g1799_0 g1799_2 g1799_3 0 netg1799
X2802 g7535_1 g7535_0 0 netg7535
X2803 g1624_1 g1624_2 g1624_3 g1624_0 0 netg1624
X2804 g106_0 g106_1 0 netg106
X2805 g1913_1 g1913_0 0 netg1913
X2806 g2029_3 g2029_2 g2029_1 g2029_0 0 netg2029
X2807 g2322_2 g2322_0 g2322_1 g2322_3 0 netg2322
X2808 g4508_8 g4508_0 g4508_9 g4508_5 g4508_10 g4508_7 g4508_6 g4508_3 g4508_2 g4508_1 g4508_4 0 netg4508
X2809 g4669_0 g4669_2 g4669_5 g4669_3 g4669_4 g4669_1 g4669_6 0 netg4669
X2810 g6046_1 g6046_0 0 netg6046
X2811 g3928_4 g3928_3 g3928_7 g3928_6 g3928_0 g3928_1 g3928_2 g3928_5 0 netg3928
X2812 g3020_3 g3020_1 g3020_0 g3020_2 0 netg3020
X2813 g4324_0 g4324_2 g4324_3 g4324_1 0 netg4324
X2814 g6704_1 g6704_0 0 netg6704
X2815 g1117_0 g1117_1 0 netg1117
X2816 g5381_0 g5381_2 g5381_3 g5381_1 0 netg5381
X2817 g1138_2 g1138_1 g1138_5 g1138_3 g1138_4 g1138_0 0 netg1138
X2818 g6711_0 g6711_1 0 netg6711
X2819 g6240_1 g6240_0 g6240_2 0 netg6240
X2820 g2406_1 g2406_0 g2406_2 0 netg2406
X2821 g3358_2 g3358_1 g3358_0 0 netg3358
X2822 g5253_0 g5253_3 g5253_4 g5253_2 g5253_1 0 netg5253
X2823 g2008_2 g2008_3 g2008_1 g2008_0 g2008_4 0 netg2008
X2824 g1820_0 g1820_3 g1820_1 g1820_2 0 netg1820
X2825 g716_4 g716_1 g716_0 g716_2 g716_3 0 netg716
X2826 g5955_0 g5955_1 0 netg5955
X2827 g4443_0 g4443_1 g4443_2 0 netg4443
X2828 g1396_1 g1396_0 0 netg1396
X2829 g6340_3 g6340_0 g6340_2 g6340_1 0 netg6340
X2830 g93_0 g93_1 0 netg93
X2831 g4380_2 g4380_1 g4380_0 0 netg4380
X2832 g5166_0 g5166_1 0 netg5166
X2833 g1675_2 g1675_3 g1675_0 g1675_1 0 netg1675
X2834 g1895_0 g1895_1 0 netg1895
X2835 g84_1 g84_0 0 netg84
X2836 g91_1 g91_0 0 netg91
X2837 g1409_0 g1409_1 0 netg1409
X2838 g2963_2 g2963_0 g2963_1 g2963_4 g2963_5 0 netg2963
X2839 g5848_1 g5848_3 g5848_2 g5848_0 0 netg5848
X2840 g5208_2 g5208_1 g5208_0 0 netg5208
X2841 g7408_0 g7408_1 0 netg7408
X2842 g2798_0 g2798_1 0 netg2798
X2843 g2969_4 g2969_1 g2969_2 g2969_6 g2969_3 g2969_5 0 netg2969
X2844 g4485_2 g4485_5 g4485_0 g4485_4 g4485_1 g4485_3 0 netg4485
X2845 g5809_3 g5809_1 g5809_0 g5809_2 0 netg5809
X2846 g1919_1 g1919_0 0 netg1919
X2847 g5471_1 g5471_2 g5471_0 0 netg5471
X2848 g2159_3 g2159_0 g2159_1 g2159_2 0 netg2159
X2849 g828_6 g828_4 g828_3 g828_0 g828_2 g828_5 g828_1 0 netg828
X2850 g6565_0 g6565_1 g6565_2 0 netg6565
X2851 g1770_0 g1770_2 g1770_1 g1770_3 0 netg1770
X2852 g1578_1 g1578_0 0 netg1578
X2853 g114_0 g114_1 0 netg114
X2854 g1411_6 g1411_1 g1411_5 g1411_8 g1411_4 g1411_0 g1411_9 g1411_2 g1411_7 g1411_3 0 netg1411
X2855 g5515_1 g5515_2 g5515_3 g5515_0 0 netg5515
X2856 g3883_0 g3883_6 g3883_2 g3883_1 g3883_5 g3883_3 g3883_4 0 netg3883
X2857 g112_1 g112_0 0 netg112
X2858 g1899_1 g1899_0 0 netg1899
X2859 g2405_0 g2405_1 0 netg2405
X2860 g4687_8 g4687_0 g4687_1 g4687_2 g4687_4 g4687_5 g4687_10 g4687_9 g4687_6 g4687_7 g4687_3 0 netg4687
X2861 g2859_0 g2859_4 g2859_1 g2859_6 g2859_2 g2859_5 g2859_3 0 netg2859
X2862 g740_2 g740_5 g740_6 g740_3 g740_0 g740_1 g740_4 0 netg740
X2863 g6202_1 g6202_0 0 netg6202
X2864 g2398_2 g2398_0 g2398_1 0 netg2398
X2865 g1092_2 g1092_1 g1092_0 g1092_3 0 netg1092
X2866 g1212_4 g1212_0 g1212_3 g1212_2 g1212_5 g1212_6 g1212_1 0 netg1212
X2867 g1918_1 g1918_0 0 netg1918
X2868 g7550_0 g7550_1 0 netg7550
X2869 g6765_4 g6765_5 g6765_1 g6765_2 g6765_0 g6765_3 0 netg6765
X2870 g4539_2 g4539_9 g4539_5 g4539_8 g4539_6 g4539_1 g4539_4 g4539_10 g4539_3 g4539_7 g4539_0 0 netg4539
X2871 g1115_1 g1115_0 0 netg1115
X2872 g6002_3 g6002_2 g6002_1 g6002_0 0 netg6002
X2873 g90_0 g90_1 0 netg90
X2874 g6657_0 g6657_1 0 netg6657
X2875 g4704_6 g4704_1 g4704_0 g4704_2 g4704_5 g4704_4 g4704_3 0 netg4704
X2876 g3817_9 g3817_5 g3817_4 g3817_7 g3817_10 g3817_8 g3817_1 g3817_2 g3817_6 g3817_3 0 netg3817
X2877 g4550_3 g4550_9 g4550_0 g4550_4 g4550_8 g4550_7 g4550_1 g4550_2 g4550_5 g4550_6 0 netg4550
X2878 g3630_6 g3630_4 g3630_3 g3630_2 g3630_1 g3630_0 g3630_5 0 netg3630
X2879 g2432_0 g2432_1 g2432_2 0 netg2432
X2880 g4407_1 g4407_2 g4407_0 0 netg4407
X2881 g1108_1 g1108_0 g1108_5 g1108_4 g1108_3 g1108_2 0 netg1108
X2882 g1285_1 g1285_0 0 netg1285
X2883 g5334_4 g5334_2 g5334_6 g5334_1 g5334_3 g5334_0 g5334_5 0 netg5334
X2884 g6542_0 g6542_1 0 netg6542
X2885 g3810_3 g3810_4 g3810_1 g3810_0 g3810_6 g3810_5 g3810_2 0 netg3810
X2886 g2200_1 g2200_2 0 netg2200
X2887 g127_1 g127_0 0 netg127
X2888 g849_6 g849_4 g849_2 g849_3 g849_0 g849_5 g849_1 0 netg849
X2889 g3644_4 g3644_8 g3644_5 g3644_1 g3644_7 g3644_9 g3644_2 g3644_3 g3644_0 0 netg3644
X2890 g2092_0 g2092_1 g2092_3 g2092_2 0 netg2092
X2891 g4092_2 g4092_1 g4092_0 0 netg4092
X2892 g1792_2 g1792_0 g1792_1 0 netg1792
X2893 g2537_1 g2537_2 g2537_0 0 netg2537
X2894 g2226_1 g2226_0 0 netg2226
X2895 g1803_1 g1803_3 g1803_0 g1803_2 0 netg1803
X2896 g4698_2 g4698_1 g4698_4 g4698_3 g4698_0 g4698_5 0 netg4698
X2897 g4732_9 g4732_5 g4732_6 g4732_2 g4732_4 g4732_0 g4732_8 g4732_3 g4732_7 g4732_1 0 netg4732
X2898 g2338_2 g2338_1 g2338_3 g2338_0 0 netg2338
X2899 g2429_2 g2429_1 g2429_0 0 netg2429
X2900 g805_4 g805_6 g805_2 g805_5 g805_3 g805_0 g805_1 0 netg805
X2901 g3665_2 g3665_9 g3665_6 g3665_3 g3665_1 g3665_7 g3665_5 g3665_8 g3665_4 g3665_0 0 netg3665
X2902 g5380_0 g5380_1 0 netg5380
X2903 g2101_2 g2101_3 g2101_0 g2101_5 g2101_4 g2101_1 0 netg2101
X2904 g4519_6 g4519_5 g4519_4 g4519_8 g4519_2 g4519_9 g4519_3 g4519_1 g4519_7 g4519_0 0 netg4519
X2905 g1978_4 g1978_1 g1978_5 g1978_6 g1978_2 g1978_7 g1978_0 g1978_3 0 netg1978
X2906 g4956_2 g4956_1 g4956_0 g4956_3 0 netg4956
X2907 g1240_5 g1240_3 g1240_4 g1240_2 g1240_1 g1240_0 0 netg1240
X2908 g1281_1 g1281_0 0 netg1281
X2909 g5264_1 g5264_0 0 netg5264
X2910 g5341_2 g5341_3 g5341_1 g5341_0 0 netg5341
X2911 g1099_0 g1099_1 0 netg1099
X2912 g7526_1 g7526_0 0 netg7526
X2913 g4676_6 g4676_3 g4676_1 g4676_2 g4676_4 g4676_9 g4676_7 g4676_8 g4676_10 g4676_5 0 netg4676
X2914 g4491_4 g4491_5 g4491_3 g4491_2 g4491_1 g4491_6 g4491_0 0 netg4491
X2915 g772_2 g772_3 g772_0 g772_1 g772_4 0 netg772
X2916 g77_1 g77_0 0 netg77
X2917 g7529_0 g7529_1 0 netg7529
X2918 g6351_0 g6351_1 g6351_3 g6351_2 0 netg6351
X2919 g1456_0 g1456_1 0 netg1456
X2920 g2318_1 g2318_3 g2318_2 0 netg2318
X2921 g753_5 g753_6 g753_0 g753_2 g753_3 g753_1 0 netg753
X2922 g4802_6 g4802_9 g4802_7 g4802_3 g4802_1 g4802_5 g4802_0 g4802_8 g4802_2 g4802_4 0 netg4802
X2923 g1965_4 g1965_5 g1965_0 g1965_3 g1965_1 g1965_2 0 netg1965
X2924 g695_1 g695_0 0 netg695
X2925 g2001_1 g2001_0 g2001_2 0 netg2001
X2926 g4177_0 g4177_1 0 netg4177
X2927 g608_2 g608_1 g608_5 g608_3 g608_0 g608_4 0 netg608
X2928 g68_0 g68_1 0 netg68
X2929 g507_1 g507_3 g507_4 g507_0 g507_2 0 netg507
X2930 g2907_6 g2907_4 g2907_1 g2907_0 g2907_5 g2907_3 g2907_2 0 netg2907
X2931 g5280_5 g5280_4 g5280_6 g5280_0 g5280_1 g5280_3 g5280_2 0 netg5280
X2932 g3718_4 g3718_6 g3718_5 g3718_1 g3718_0 g3718_2 g3718_3 0 netg3718
X2933 g1840_3 g1840_1 g1840_0 g1840_2 0 netg1840
X2934 g4626_0 g4626_1 0 netg4626
X2935 g6446_1 g6446_0 0 netg6446
X2936 g1275_5 g1275_4 g1275_0 g1275_3 g1275_1 g1275_2 0 netg1275
X2937 g108_0 g108_1 0 netg108
X2938 g4395_1 g4395_0 g4395_2 0 netg4395
X2939 g3736_8 g3736_6 g3736_5 g3736_9 g3736_1 g3736_4 g3736_7 g3736_0 g3736_3 g3736_2 0 netg3736
X2940 g1455_1 g1455_0 0 netg1455
X2941 g1100_0 g1100_1 0 netg1100
X2942 g3839_0 g3839_5 g3839_4 g3839_2 g3839_1 g3839_3 0 netg3839
X2943 g4084_2 g4084_1 g4084_0 g4084_3 0 netg4084
X2944 g3746_3 g3746_0 g3746_1 g3746_6 g3746_7 g3746_4 g3746_2 g3746_5 0 netg3746
X2945 g2849_1 g2849_2 g2849_0 g2849_3 0 netg2849
X2946 g3103_0 g3103_2 g3103_1 0 netg3103
X2947 g2075_3 g2075_5 g2075_4 g2075_2 g2075_1 g2075_0 0 netg2075
X2948 g6573_4 g6573_0 g6573_2 g6573_1 g6573_5 g6573_3 0 netg6573
X2949 g1086_3 g1086_5 g1086_1 g1086_4 0 netg1086
X2950 g2540_1 g2540_2 g2540_0 0 netg2540
X2951 g2096_4 g2096_2 g2096_1 g2096_3 g2096_0 0 netg2096
X2952 g1337_3 g1337_1 g1337_2 g1337_5 g1337_0 g1337_6 g1337_4 0 netg1337
X2953 g6090_2 g6090_1 g6090_0 0 netg6090
X2954 g1592_3 g1592_1 g1592_0 g1592_2 0 netg1592
X2955 g570_1 g570_5 g570_0 g570_4 g570_3 g570_2 0 netg570
X2956 g7147_2 g7147_1 g7147_0 0 netg7147
X2957 g5514_0 g5514_1 0 netg5514
X2958 g4598_5 g4598_3 g4598_12 g4598_8 g4598_6 g4598_0 g4598_9 g4598_4 g4598_1 g4598_2 g4598_10 g4598_7 g4598_11 0 netg4598
X2959 g5258_0 g5258_1 g5258_4 g5258_3 g5258_2 0 netg5258
X2960 g70_0 g70_1 g70_2 0 netg70
X2961 g1971_4 g1971_0 g1971_2 g1971_6 g1971_5 g1971_3 g1971_1 0 netg1971
X2962 x491_1 x491_0 0 netx491
X2963 g423_4 g423_1 g423_0 g423_3 g423_2 0 netg423
X2964 g760_1 g760_4 g760_2 g760_0 g760_6 g760_3 g760_5 0 netg760
X2965 g4498_7 g4498_6 g4498_2 g4498_8 g4498_1 g4498_9 g4498_4 g4498_5 g4498_0 g4498_3 0 netg4498
X2966 g67_1 g67_0 0 netg67
X2967 g6784_2 g6784_0 g6784_1 0 netg6784
X2968 g7436_1 g7436_0 0 netg7436
X2969 g1807_0 g1807_1 g1807_3 g1807_2 0 netg1807
X2970 g72_0 g72_1 g72_2 0 netg72
X2971 g602_4 g602_2 g602_1 g602_0 g602_5 g602_3 0 netg602
X2972 g6423_5 g6423_2 g6423_3 g6423_4 g6423_1 g6423_0 g6423_6 0 netg6423
X2973 g6942_3 g6942_4 g6942_5 g6942_0 g6942_2 g6942_1 0 netg6942
X2974 g3828_10 g3828_2 g3828_5 g3828_9 g3828_8 g3828_6 g3828_1 g3828_0 g3828_7 g3828_4 g3828_3 0 netg3828
X2975 g2045_3 g2045_1 g2045_0 g2045_2 0 netg2045
X2976 g103_1 g103_0 0 netg103
X2977 g1816_3 g1816_2 g1816_1 g1816_0 0 netg1816
X2978 g1500_0 g1500_1 0 netg1500
X2979 g125_1 g125_0 0 netg125
X2980 g6281_2 g6281_0 g6281_1 0 netg6281
X2981 g7144_1 g7144_2 g7144_0 0 netg7144
X2982 g4568_13 g4568_12 g4568_9 g4568_6 g4568_4 g4568_10 g4568_8 g4568_2 g4568_11 g4568_1 g4568_3 g4568_7 0 netg4568
X2983 g126_0 g126_1 0 netg126
X2984 g7511_1 g7511_0 0 netg7511
X2985 g2801_1 g2801_0 0 netg2801
X2986 g105_0 g105_1 0 netg105
X2987 g1282_1 g1282_0 0 netg1282
X2988 g1856_2 g1856_0 g1856_1 0 netg1856
X2989 g6366_3 g6366_2 g6366_0 g6366_1 0 netg6366
X2990 g73_2 g73_1 g73_0 0 netg73
X2991 g7534_1 g7534_0 0 netg7534
X2992 g81_1 g81_0 0 netg81
X2993 g6610_1 g6610_0 0 netg6610
X2994 g1600_2 g1600_3 g1600_1 g1600_0 0 netg1600
X2995 g6026_6 g6026_4 g6026_0 g6026_5 g6026_3 g6026_1 g6026_2 0 netg6026
X2996 g80_0 g80_1 0 netg80
X2997 g1350_5 g1350_4 g1350_2 g1350_0 g1350_3 g1350_1 0 netg1350
X2998 g2049_5 g2049_0 g2049_1 g2049_4 g2049_2 g2049_3 0 netg2049
X2999 g71_1 g71_2 g71_0 0 netg71
X3000 g4812_6 g4812_1 g4812_3 g4812_7 g4812_5 g4812_2 g4812_4 0 netg4812
X3001 g104_0 g104_1 0 netg104
X3002 g6703_1 g6703_0 0 netg6703
X3003 g1616_3 g1616_2 g1616_0 g1616_1 0 netg1616
X3004 g6401_0 g6401_1 0 netg6401
X3005 g3694_3 g3694_1 g3694_2 g3694_0 0 netg3694
X3006 g1679_0 g1679_3 g1679_2 g1679_1 0 netg1679
X3007 g3024_5 g3024_1 g3024_4 g3024_2 g3024_3 g3024_0 0 netg3024
X3008 g628_4 g628_2 g628_5 g628_3 g628_1 g628_0 0 netg628
X3009 g4711_4 g4711_7 g4711_2 g4711_1 g4711_8 g4711_6 g4711_0 g4711_3 g4711_9 g4711_5 0 netg4711
X3010 g4463_10 g4463_5 g4463_9 g4463_4 g4463_8 g4463_2 g4463_6 g4463_0 g4463_1 g4463_7 g4463_3 0 netg4463
X3011 g5799_1 g5799_2 g5799_0 0 netg5799
X3012 g3517_1 g3517_0 0 netg3517
X3013 g4721_5 g4721_2 g4721_8 g4721_4 g4721_0 g4721_3 g4721_9 g4721_6 g4721_1 g4721_7 g4721_10 0 netg4721
X3014 g79_1 g79_0 0 netg79
X3015 g2055_2 g2055_4 g2055_3 g2055_6 g2055_5 g2055_0 0 netg2055
X3016 g7499_1 g7499_0 0 netg7499
X3017 g1395_1 g1395_0 0 netg1395
X3018 g1836_0 g1836_2 g1836_1 g1836_3 0 netg1836
X3019 g614_3 g614_0 g614_4 g614_1 g614_5 g614_2 0 netg614
X3020 g1786_5 g1786_2 g1786_4 g1786_3 g1786_0 g1786_1 0 netg1786
X3021 g5847_1 g5847_0 0 netg5847
X3022 g5170_1 g5170_3 g5170_0 g5170_2 0 netg5170
X3023 g6071_1 g6071_0 0 netg6071
X3024 g5287_1 g5287_6 g5287_5 g5287_0 g5287_4 g5287_3 g5287_2 0 netg5287
X3025 g3516_1 g3516_0 0 netg3516
X3026 g6583_1 g6583_0 0 netg6583
X3027 g1727_1 g1727_2 g1727_0 g1727_3 0 netg1727
X3028 g1596_1 g1596_2 g1596_0 g1596_3 0 netg1596
X3029 g124_1 g124_0 0 netg124
X3030 g3768_1 g3768_8 g3768_3 g3768_0 g3768_13 g3768_2 g3768_10 g3768_12 g3768_11 g3768_6 g3768_7 g3768_9 g3768_5 g3768_4 g3768_15 g3768_14 0 netg3768
X3031 g1687_1 g1687_0 g1687_2 g1687_3 0 netg1687
X3032 g3873_8 g3873_3 g3873_9 g3873_0 g3873_6 g3873_1 g3873_7 g3873_5 g3873_2 g3873_4 0 netg3873
X3033 g4791_2 g4791_3 g4791_7 g4791_9 g4791_5 g4791_10 g4791_8 g4791_0 g4791_1 g4791_4 g4791_6 0 netg4791
X3034 g2123_1 g2123_3 g2123_2 g2123_0 0 netg2123
X3035 g4850_9 g4850_1 g4850_4 g4850_8 g4850_6 g4850_3 g4850_10 g4850_2 g4850_12 g4850_7 g4850_11 g4850_5 0 netg4850
X3036 g3617_12 g3617_3 g3617_9 g3617_7 g3617_5 g3617_2 g3617_8 g3617_1 g3617_4 g3617_10 g3617_0 g3617_6 g3617_11 0 netg3617
X3037 g2326_1 g2326_0 g2326_3 g2326_2 0 netg2326
X3038 g2330_3 g2330_1 g2330_0 0 netg2330
X3039 g1098_1 g1098_0 0 netg1098
X3040 g7257_0 g7257_1 g7257_2 0 netg7257
X3041 g134_1 g134_0 0 netg134
X3042 g128_1 g128_0 0 netg128
X3043 g1474_1 g1474_0 0 netg1474
X3044 g4869_1 g4869_6 g4869_5 g4869_2 g4869_0 g4869_4 g4869_3 0 netg4869
X3045 g7521_1 g7521_0 0 netg7521
X3046 g727_4 g727_5 g727_6 g727_1 g727_3 0 netg727
X3047 g2531_2 g2531_0 0 netg2531
X3048 g2342_3 g2342_1 g2342_0 0 netg2342
X3049 g7501_1 g7501_0 0 netg7501
X3050 g7445_1 g7445_0 0 netg7445
X3051 g3803_3 g3803_0 g3803_6 g3803_4 g3803_2 g3803_1 0 netg3803
X3052 g6371_1 g6371_0 0 netg6371
X3053 g7500_1 g7500_0 0 netg7500
X3054 g69_0 g69_2 g69_1 0 netg69
X3055 g4834_8 g4834_12 g4834_5 g4834_15 g4834_9 g4834_1 g4834_3 g4834_13 g4834_4 g4834_14 g4834_0 g4834_11 g4834_10 g4834_6 g4834_2 0 netg4834
X3056 g428_4 g428_8 g428_1 g428_5 g428_9 g428_6 g428_7 g428_2 g428_10 g428_3 0 netg428
X3057 g7532_0 g7532_1 0 netg7532
X3058 g4820_4 g4820_1 g4820_10 g4820_7 g4820_6 g4820_0 g4820_11 g4820_13 g4820_12 g4820_9 g4820_2 g4820_8 g4820_5 0 netg4820
X3059 g5986_1 g5986_0 g5986_2 0 netg5986
X3060 g1900_0 g1900_1 0 netg1900
X3061 g576_1 g576_3 g576_5 g576_2 g576_0 g576_4 0 netg576
X3062 g1664_0 g1664_3 g1664_2 g1664_5 g1664_4 g1664_1 0 netg1664
X3063 g3030_5 g3030_4 g3030_1 g3030_3 g3030_0 g3030_6 g3030_2 0 netg3030
X3064 x171_0 x171_1 0 netx171
X3065 g666_4 g666_3 g666_2 g666_5 g666_1 g666_0 0 netg666
X3066 g4560_6 g4560_5 g4560_4 g4560_3 g4560_0 g4560_7 g4560_2 g4560_1 0 netg4560
X3067 g2334_3 g2334_1 g2334_2 g2334_0 0 netg2334
X3068 g120_1 g120_0 0 netg120
X3069 g2683_2 g2683_1 g2683_0 0 netg2683
X3070 g3862_8 g3862_0 g3862_7 g3862_6 g3862_9 g3862_2 g3862_10 g3862_3 g3862_1 g3862_5 g3862_4 0 netg3862
X3071 g2853_5 g2853_2 g2853_3 g2853_4 g2853_1 0 netg2853
X3072 g102_0 g102_1 0 netg102
X3073 g89_0 g89_1 0 netg89
X3074 g44_0 g44_1 0 netg44
X3075 g634_3 g634_1 g634_0 g634_2 g634_5 g634_4 0 netg634
X3076 g821_0 g821_6 g821_3 g821_1 g821_4 g821_2 g821_5 0 netg821
X3077 g1459_1 g1459_0 0 netg1459
X3078 g3784_3 g3784_2 g3784_0 g3784_9 g3784_12 g3784_8 g3784_7 g3784_6 g3784_4 g3784_1 g3784_11 g3784_10 g3784_5 0 netg3784
X3079 g3579_2 g3579_5 g3579_0 g3579_4 g3579_1 g3579_6 g3579_3 g3579_7 0 netg3579
X3080 g5977_2 g5977_0 g5977_1 0 netg5977
X3081 g5502_2 g5502_1 g5502_0 0 netg5502
X3082 g5839_3 g5839_1 g5839_0 g5839_2 0 netg5839
X3083 g2280_2 g2280_3 g2280_1 g2280_0 0 netg2280
X3084 g133_0 g133_1 0 netg133
X3085 g6568_2 g6568_0 g6568_4 g6568_1 g6568_3 0 netg6568
X3086 g652_5 g652_4 g652_2 g652_0 g652_1 g652_3 g652_7 g652_6 0 netg652
X3087 g7512_0 g7512_1 0 netg7512
X3088 g3037_0 g3037_6 g3037_5 g3037_3 g3037_1 g3037_2 g3037_7 g3037_4 0 netg3037
X3089 g2409_0 g2409_2 g2409_1 0 netg2409
X3090 g1683_2 g1683_3 g1683_1 0 netg1683
X3091 g7513_0 g7513_1 0 netg7513
X3092 g5418_1 g5418_0 g5418_2 0 netg5418
X3093 g7515_0 g7515_1 0 netg7515
X3094 g45_0 g45_1 0 netg45
X3095 g683_3 g683_2 g683_0 g683_5 g683_6 g683_1 g683_4 0 netg683
X3096 g3057_1 g3057_0 0 netg3057
X3097 g588_2 g588_3 g588_1 g588_4 g588_5 g588_0 0 netg588
X3098 g6590_2 g6590_1 g6590_4 g6590_0 g6590_3 g6590_6 0 netg6590
X3099 g56_1 g56_0 0 netg56
X3100 g7497_0 g7497_1 0 netg7497
X3101 g2284_1 g2284_0 g2284_3 g2284_2 0 netg2284
X3102 g3587_8 g3587_9 g3587_2 g3587_12 g3587_0 g3587_3 g3587_13 g3587_6 g3587_11 g3587_4 g3587_10 g3587_1 g3587_7 0 netg3587
X3103 g582_5 g582_4 g582_2 g582_3 g582_1 g582_0 0 netg582
X3104 g2552_1 g2552_0 g2552_2 0 netg2552
X3105 g1102_4 g1102_2 g1102_1 g1102_0 g1102_3 g1102_5 0 netg1102
X3106 g7498_1 g7498_0 0 netg7498
X3107 g7510_1 g7510_0 0 netg7510
X3108 g4582_6 g4582_5 g4582_3 g4582_12 g4582_10 g4582_15 g4582_9 g4582_0 g4582_11 g4582_2 g4582_7 g4582_1 g4582_8 g4582_13 g4582_4 g4582_14 0 netg4582
X3109 g46_1 g46_0 0 netg46
X3110 g7506_1 g7506_0 0 netg7506
X3111 g2680_2 g2680_0 g2680_1 0 netg2680
X3112 g594_3 g594_7 g594_5 g594_2 g594_6 g594_4 g594_1 0 netg594
X3113 g3552_1 g3552_0 0 netg3552
X3114 g842_6 g842_0 g842_1 g842_4 g842_3 g842_2 g842_5 0 netg842
X3115 g660_4 g660_1 g660_2 g660_0 g660_5 g660_3 0 netg660
X3116 g2314_2 g2314_3 g2314_1 0 netg2314
X3117 g7495_1 g7495_0 0 netg7495
X3118 g1398_1 g1398_0 0 netg1398
X3119 g1811_3 g1811_0 g1811_2 g1811_1 0 netg1811
X3120 g1620_0 g1620_3 g1620_2 g1620_1 0 netg1620
X3121 g2276_2 g2276_1 g2276_3 g2276_0 0 netg2276
X3122 g1116_0 g1116_1 0 netg1116
X3123 g2089_0 g2089_2 g2089_1 0 netg2089
X3124 g123_0 g123_1 0 netg123
X3125 g138_1 g138_0 0 netg138
X3126 g58_1 g58_0 0 netg58
X3127 g4662_0 g4662_2 g4662_1 0 netg4662
X3128 g2635_0 g2635_1 g2635_2 0 netg2635
X3129 g7260_2 g7260_0 g7260_1 0 netg7260
X3130 g2546_0 g2546_2 g2546_1 0 netg2546
X3131 g712_3 g712_1 g712_0 g712_2 0 netg712
X3132 g1905_1 g1905_0 0 netg1905
X3133 g21_0 g21_1 0 netg21
X3134 g7493_1 g7493_0 0 netg7493
X3135 g139_1 g139_0 0 netg139
X3136 g2107_3 g2107_1 g2107_0 g2107_2 0 netg2107
X3137 g1904_1 g1904_0 0 netg1904
X3138 g5968_0 g5968_1 0 netg5968
X3139 g1782_3 g1782_1 g1782_0 g1782_2 0 netg1782
X3140 g4784_3 g4784_2 g4784_4 g4784_1 g4784_6 g4784_5 g4784_0 0 netg4784
X3141 g7496_1 g7496_0 0 netg7496
X3142 g1628_1 g1628_0 g1628_2 g1628_3 0 netg1628
X3143 g1828_2 g1828_1 g1828_0 g1828_3 0 netg1828
X3144 g6234_0 g6234_1 g6234_2 0 netg6234
X3145 g7494_1 g7494_0 0 netg7494
X3146 g721_3 g721_0 g721_5 g721_1 g721_2 g721_4 0 netg721
X3147 g3294_0 g3294_2 g3294_1 0 netg3294
X3148 g43_0 g43_1 0 netg43
X3149 g5185_2 g5185_1 g5185_0 0 netg5185
X3150 g3956_3 g3956_2 g3956_0 g3956_4 0 netg3956
X3151 g512_4 g512_3 g512_1 g512_0 0 netg512
X3152 g7507_1 g7507_0 0 netg7507
X3153 g42_1 g42_0 0 netg42
X3154 g7548_0 g7548_1 0 netg7548
X3155 g2111_3 g2111_0 g2111_2 g2111_1 0 netg2111
X3156 g55_1 g55_0 0 netg55
X3157 g1862_2 g1862_1 g1862_0 0 netg1862
X3158 g101_0 g101_1 0 netg101
X3159 g3950_5 g3950_1 g3950_4 g3950_2 g3950_3 g3950_0 0 netg3950
X3160 g1118_0 g1118_1 0 netg1118
X3161 g640_0 g640_3 g640_5 g640_1 g640_2 g640_4 0 netg640
X3162 g7552_1 g7552_0 0 netg7552
X3163 g48_0 g48_1 0 netg48
X3164 g111_0 g111_1 0 netg111
X3165 g1178_6 g1178_3 g1178_4 g1178_0 g1178_5 g1178_2 g1178_1 0 netg1178
X3166 g96_0 g96_1 0 netg96
X3167 g2389_2 g2389_1 g2389_0 0 netg2389
X3168 g2288_1 g2288_3 g2288_0 g2288_2 0 netg2288
X3169 g1824_0 g1824_1 g1824_2 g1824_3 0 netg1824
X3170 g135_0 g135_1 0 netg135
X3171 g5830_0 g5830_2 g5830_1 0 netg5830
X3172 g88_1 g88_0 0 netg88
X3173 g2641_2 g2641_0 g2641_1 0 netg2641
X3174 g5302_5 g5302_3 g5302_6 g5302_4 g5302_2 g5302_1 g5302_0 0 netg5302
X3175 g136_0 g136_1 0 netg136
X3176 g2692_1 g2692_2 0 netg2692
X3177 g3366_0 g3366_1 0 netg3366
X3178 g7545_1 g7545_0 0 netg7545
X3179 g140_1 g140_0 0 netg140
X3180 g1954_2 g1954_0 g1954_1 0 netg1954
X3181 g6564_0 g6564_1 0 netg6564
X3182 g7547_1 g7547_0 0 netg7547
X3183 g7546_1 g7546_0 0 netg7546
X3184 g142_1 g142_0 0 netg142
X3185 g5569_1 g5569_0 g5569_2 0 netg5569
X3186 g501_2 g501_4 g501_1 g501_3 g501_5 0 netg501
X3187 g33_1 g33_0 0 netg33
X3188 g39_0 g39_1 0 netg39
X3189 g137_0 g137_1 0 netg137
X3190 g2292_3 g2292_1 g2292_2 g2292_0 0 netg2292
X3191 g6214_1 g6214_2 g6214_0 0 netg6214
X3192 g60_1 g60_0 0 netg60
X3193 g538_4 g538_2 g538_1 g538_3 g538_5 0 netg538
X3194 g3601_9 g3601_8 g3601_7 g3601_15 g3601_4 g3601_14 g3601_12 g3601_2 g3601_5 g3601_11 g3601_10 g3601_0 g3601_3 g3601_1 g3601_13 g3601_6 0 netg3601
X3195 g2412_2 g2412_1 g2412_0 0 netg2412
X3196 g7491_1 g7491_0 0 netg7491
X3197 g3361_2 g3361_1 g3361_0 0 netg3361
X3198 g2188_0 g2188_2 g2188_1 g2188_3 g2188_5 g2188_4 0 netg2188
X3199 g4880_1 g4880_0 g4880_2 g4880_3 0 netg4880
X3200 g6067_0 g6067_1 0 netg6067
X3201 g1502_0 g1502_1 0 netg1502
X3202 g40_0 g40_1 0 netg40
X3203 g6406_0 g6406_1 0 netg6406
X3204 g4474_5 g4474_8 g4474_6 g4474_10 g4474_1 g4474_4 g4474_0 g4474_7 g4474_9 g4474_2 g4474_3 0 netg4474
X3205 g621_2 g621_4 g621_6 g621_3 g621_1 g621_5 0 netg621
X3206 g57_1 g57_0 0 netg57
X3207 g122_1 g122_0 0 netg122
X3208 g7492_0 g7492_1 0 netg7492
X3209 g1185_6 g1185_5 g1185_1 g1185_4 g1185_2 g1185_3 g1185_0 0 netg1185
X3210 g6064_1 g6064_0 0 netg6064
X3211 g3754_5 g3754_2 g3754_12 g3754_10 g3754_4 g3754_9 g3754_6 g3754_13 g3754_3 g3754_7 g3754_11 g3754_8 g3754_0 g3754_1 0 netg3754
X3212 g6056_4 g6056_0 g6056_2 g6056_5 g6056_1 g6056_6 g6056_3 0 netg6056
X3213 g391_1 g391_0 g391_2 0 netg391
X3214 g2802_0 g2802_1 0 netg2802
X3215 g2794_1 g2794_0 0 netg2794
X3216 g5499_0 g5499_1 g5499_2 0 netg5499
X3217 g4359_1 g4359_2 g4359_0 0 netg4359
X3218 g646_3 g646_4 g646_0 g646_5 g646_2 g646_1 0 netg646
X3219 g2300_0 g2300_2 g2300_3 g2300_1 0 netg2300
X3220 g4876_3 g4876_1 g4876_0 g4876_2 0 netg4876
X3221 g450_4 g450_0 g450_3 g450_1 g450_2 0 netg450
X3222 g2296_3 g2296_2 g2296_1 g2296_0 0 netg2296
X3223 g1832_1 g1832_3 g1832_0 g1832_2 0 netg1832
X3224 g3852_3 g3852_2 g3852_8 g3852_9 g3852_0 g3852_5 g3852_7 g3852_1 g3852_6 g3852_4 0 netg3852
X3225 g494_5 g494_4 g494_3 g494_1 g494_2 g494_0 0 netg494
X3226 g4377_0 g4377_2 g4377_1 0 netg4377
X3227 g6203_0 g6203_1 0 netg6203
X3228 g1612_2 g1612_1 g1612_0 g1612_3 0 netg1612
X3229 g1604_3 g1604_0 g1604_2 g1604_1 0 netg1604
X3230 g2115_2 g2115_3 g2115_1 0 netg2115
X3231 g3355_2 g3355_1 g3355_0 0 netg3355
X3232 g2194_0 g2194_2 g2194_5 g2194_1 g2194_4 g2194_3 0 netg2194
X3233 g59_1 g59_0 0 netg59
X3234 g532_1 g532_0 g532_5 g532_4 g532_3 0 netg532
X3235 g41_1 g41_0 0 netg41
X3236 g6520_0 g6520_1 0 netg6520
X3237 g36_1 g36_0 0 netg36
X3238 g6597_3 g6597_0 g6597_6 g6597_2 g6597_1 g6597_4 g6597_5 0 netg6597
X3239 g3845_4 g3845_2 g3845_3 g3845_1 g3845_6 g3845_5 g3845_0 0 netg3845
X3240 g2203_1 g2203_5 g2203_3 g2203_4 g2203_2 0 netg2203
X3241 g2421_1 g2421_0 0 netg2421
X3242 g6408_1 g6408_0 0 netg6408
X3243 g3687_0 g3687_2 g3687_1 g3687_3 0 netg3687
X3244 g5816_3 g5816_2 g5816_1 g5816_0 0 netg5816
X3245 g37_1 g37_0 0 netg37
X3246 g699_3 g699_2 g699_4 g699_1 g699_5 g699_0 0 netg699
X3247 g47_0 g47_1 0 netg47
X3248 g799_3 g799_1 g799_0 g799_2 g799_5 g799_4 0 netg799
X3249 g1462_3 g1462_1 g1462_2 g1462_5 g1462_4 g1462_0 0 netg1462
X3250 g672_1 g672_3 g672_2 g672_4 g672_0 g672_5 0 netg672
X3251 g38_0 g38_1 0 netg38
X3252 g6778_0 g6778_1 g6778_2 0 netg6778
X3253 g34_1 g34_0 0 netg34
X3254 g5269_1 g5269_0 0 netg5269
X3255 g3071_2 g3071_0 g3071_5 g3071_4 g3071_3 g3071_1 0 netg3071
X3256 g54_1 g54_0 g54_2 0 netg54
X3257 g2182_5 g2182_2 g2182_1 g2182_4 g2182_3 g2182_0 0 netg2182
X3258 g442_0 g442_2 g442_1 g442_3 0 netg442
X3259 g1859_0 g1859_1 g1859_2 0 netg1859
X3260 g488_3 g488_4 g488_2 g488_0 g488_1 g488_5 0 netg488
X3261 g35_0 g35_1 0 netg35
X3262 g31_1 g31_0 0 netg31
X3263 g64_1 g64_0 g64_2 0 netg64
X3264 g143_0 g143_1 0 netg143
X3265 g145_1 g145_0 0 netg145
X3266 g2209_4 g2209_3 g2209_0 g2209_5 g2209_1 g2209_2 0 netg2209
X3267 g2119_1 g2119_2 g2119_3 g2119_0 0 netg2119
X3268 g6705_0 g6705_3 g6705_2 g6705_4 g6705_1 0 netg6705
X3269 g86_0 g86_1 0 netg86
X3270 g147_1 g147_0 0 netg147
X3271 g2304_0 g2304_3 g2304_2 g2304_1 0 netg2304
X3272 g74_1 g74_0 0 netg74
X3273 g20_1 g20_0 0 netg20
X3274 g2308_2 g2308_3 g2308_1 g2308_0 0 netg2308
X3275 g18_1 g18_0 0 netg18
X3276 g146_0 g146_1 0 netg146
X3277 g29_0 g29_1 0 netg29
X3278 g26_1 g26_0 0 netg26
X3279 g144_0 g144_1 0 netg144
X3280 g2147_2 g2147_3 g2147_4 g2147_1 g2147_0 g2147_5 0 netg2147
X3281 g1710_4 g1710_2 g1710_3 g1710_5 g1710_1 g1710_0 0 netg1710
X3282 g132_0 g132_1 0 netg132
X3283 g7525_1 g7525_0 0 netg7525
X3284 g519_5 g519_3 g519_6 g519_4 g519_1 g519_0 g519_2 0 netg519
X3285 g2175_4 g2175_6 g2175_5 g2175_3 g2175_2 g2175_1 g2175_0 0 netg2175
X3286 g1632_2 g1632_4 g1632_1 g1632_5 g1632_3 g1632_0 0 netg1632
X3287 g32_0 g32_1 g32_2 0 netg32
X3288 g7502_0 g7502_1 0 netg7502
X3289 g7522_0 g7522_1 0 netg7522
X3290 g7482_0 g7482_1 0 netg7482
X3291 g446_1 g446_3 g446_0 g446_2 0 netg446
X3292 g62_1 g62_2 g62_0 0 netg62
X3293 g24_0 g24_1 0 netg24
X3294 g129_0 g129_1 0 netg129
X3295 g130_1 g130_0 0 netg130
X3296 g154_1 g154_0 0 netg154
X3297 g2215_1 g2215_4 g2215_2 g2215_5 g2215_0 g2215_3 0 netg2215
X3298 g63_0 g63_2 g63_1 0 netg63
X3299 g131_0 g131_1 0 netg131
X3300 g7524_0 g7524_1 0 netg7524
X3301 g61_1 g61_2 g61_0 0 netg61
X3302 g25_0 g25_1 0 netg25
X3303 g2127_2 g2127_5 g2127_3 g2127_4 g2127_0 g2127_1 0 netg2127
X3304 g28_1 g28_0 0 netg28
X3305 g2_1 g2_3 g2_2 g2_0 0 netg2
X3306 g19_0 g19_1 0 netg19
X3307 g141_1 g141_0 0 netg141
X3308 g7518_1 g7518_0 0 netg7518
X3309 g5_0 g5_2 g5_1 0 netg5
X3310 g66_2 g66_0 g66_1 0 netg66
X3311 g7457_0 g7457_1 0 netg7457
X3312 g27_1 g27_0 0 netg27
X3313 g6787_1 g6787_2 g6787_0 0 netg6787
X3314 g49_4 g49_0 g49_2 g49_3 g49_1 0 netg49
X3315 g17_0 g17_1 0 netg17
X3316 g76_0 g76_1 0 netg76
X3317 g7536_0 g7536_1 0 netg7536
X3318 g7464_1 g7464_0 0 netg7464
X3319 g7468_1 g7468_0 0 netg7468
X3320 g7509_1 g7509_0 0 netg7509
X3321 g6771_4 g6771_6 g6771_5 g6771_0 g6771_3 g6771_1 g6771_2 0 netg6771
X3322 g7505_1 g7505_0 0 netg7505
X3323 g118_0 g118_1 0 netg118
X3324 g7463_0 g7463_1 0 netg7463
X3325 g7469_0 g7469_1 0 netg7469
X3326 g7508_1 g7508_0 0 netg7508
X3327 g7544_1 g7544_0 0 netg7544
X3328 g5370_3 g5370_2 g5370_9 g5370_8 g5370_7 g5370_6 g5370_0 g5370_1 g5370_4 g5370_5 0 netg5370
X3329 g1698_2 g1698_5 g1698_1 g1698_3 g1698_0 g1698_4 0 netg1698
X3330 g23_1 g23_0 0 netg23
X3331 g7489_1 g7489_0 0 netg7489
X3332 g121_1 g121_0 0 netg121
X3333 g7461_0 g7461_1 0 netg7461
X3334 g7459_1 g7459_0 0 netg7459
X3335 g7481_1 g7481_0 0 netg7481
X3336 g7447_1 g7447_0 0 netg7447
X3337 g7523_1 g7523_0 0 netg7523
X3338 g7446_0 g7446_1 0 netg7446
X3339 g22_1 g22_0 0 netg22
X3340 g50_1 g50_0 g50_2 0 netg50
X3341 g157_1 g157_0 0 netg157
X3342 g7452_1 g7452_0 0 netg7452
X3343 g7543_1 g7543_0 0 netg7543
X3344 g148_0 g148_1 0 netg148
X3345 g2244_4 g2244_2 g2244_1 g2244_0 g2244_5 g2244_3 0 netg2244
X3346 g7443_1 g7443_0 0 netg7443
X3347 g158_1 g158_0 0 netg158
X3348 g7453_0 g7453_1 0 netg7453
X3349 g190_1 g190_2 g190_0 0 netg190
X3350 g1704_5 g1704_1 g1704_2 g1704_0 g1704_4 g1704_3 0 netg1704
X3351 g7530_1 g7530_0 0 netg7530
X3352 g149_1 g149_0 0 netg149
X3353 g7542_1 g7542_0 0 netg7542
X3354 g189_0 g189_2 g189_1 0 netg189
X3355 g7462_0 g7462_1 0 netg7462
X3356 g119_1 g119_0 0 netg119
X3357 g7487_1 g7487_0 0 netg7487
X3358 g159_0 g159_1 0 netg159
X3359 g163_0 g163_1 0 netg163
X3360 g170_1 g170_2 0 netg170
X3361 g7485_0 g7485_1 0 netg7485
X3362 g7472_1 g7472_0 0 netg7472
X3363 g7488_1 g7488_0 0 netg7488
X3364 g7480_0 g7480_1 0 netg7480
X3365 g51_2 g51_1 g51_0 0 netg51
X3366 g7477_0 g7477_1 0 netg7477
X3367 g2141_3 g2141_2 g2141_0 g2141_1 g2141_4 g2141_5 0 netg2141
X3368 g162_1 g162_0 0 netg162
X3369 g193_1 g193_2 g193_0 0 netg193
X3370 g151_0 g151_1 0 netg151
X3371 g161_0 g161_1 0 netg161
X3372 g155_1 g155_0 0 netg155
X3373 g171_2 g171_0 g171_1 0 netg171
X3374 g153_1 g153_0 0 netg153
X3375 g150_1 g150_0 0 netg150
X3376 g7516_1 g7516_0 0 netg7516
X3377 g7479_0 g7479_1 0 netg7479
X3378 g188_1 g188_0 g188_2 0 netg188
X3379 g526_5 g526_3 g526_0 g526_4 g526_1 g526_2 0 netg526
X3380 g7473_0 g7473_1 0 netg7473
X3381 g7476_1 g7476_0 0 netg7476
X3382 g7517_0 g7517_1 0 netg7517
X3383 g1691_6 g1691_3 g1691_5 g1691_2 g1691_1 g1691_4 g1691_0 0 netg1691
X3384 g7458_0 g7458_1 0 netg7458
X3385 g7541_0 g7541_1 0 netg7541
X3386 g479_1 g479_5 g479_3 g479_2 g479_4 g479_0 0 netg479
X3387 g156_0 g156_1 0 netg156
X3388 g164_1 g164_0 0 netg164
X3389 g7514_0 g7514_1 0 netg7514
X3390 g160_1 g160_0 0 netg160
X3391 g152_1 g152_0 0 netg152
X3392 g169_1 g169_0 g169_2 0 netg169
X3393 g12_0 g12_2 g12_1 0 netg12
X3394 g7474_1 g7474_0 0 netg7474
X3395 g53_2 g53_1 g53_0 0 netg53
X3396 g2258_4 g2258_3 g2258_2 g2258_1 g2258_5 0 netg2258
X3397 g194_2 g194_0 g194_1 0 netg194
X3398 g7478_1 g7478_0 0 netg7478
X3399 g2250_1 g2250_4 g2250_2 g2250_6 g2250_7 g2250_5 g2250_3 0 netg2250
X3400 g2133_7 g2133_0 g2133_6 g2133_4 g2133_3 g2133_2 g2133_1 0 netg2133
X3401 g52_2 g52_1 g52_0 0 netg52
X3402 g2264_4 g2264_3 g2264_5 g2264_2 g2264_1 g2264_0 0 netg2264
X3403 g2153_1 g2153_3 g2153_2 g2153_5 g2153_4 g2153_0 0 netg2153
X3404 g65_2 g65_0 g65_1 0 netg65
X3405 g394_1 g394_0 g394_2 0 netg394
X3406 g1652_0 g1652_5 g1652_2 g1652_3 g1652_4 g1652_1 0 netg1652
X3407 g400_1 g400_0 g400_2 0 netg400
X3408 g7520_0 g7520_1 0 netg7520
X3409 g7475_1 g7475_0 0 netg7475
X3410 g7451_1 g7451_0 0 netg7451
X3411 g553_5 g553_1 g553_4 g553_0 g553_3 g553_2 0 netg553
X3412 g172_1 g172_2 g172_0 0 netg172
X3413 g397_1 g397_0 g397_2 0 netg397
X3414 g545_5 g545_0 g545_6 g545_4 g545_7 g545_1 g545_2 g545_3 0 netg545
X3415 g175_1 g175_0 g175_2 0 netg175
X3416 g1658_4 g1658_1 g1658_2 g1658_5 g1658_3 g1658_0 0 netg1658
X3417 g7454_0 g7454_1 0 netg7454
X3418 g168_2 g168_1 g168_0 0 netg168
X3419 g1646_2 g1646_0 g1646_4 g1646_5 g1646_3 g1646_1 0 netg1646
X3420 g7486_1 g7486_0 0 netg7486
X3421 g470_1 g470_0 g470_2 0 netg470
X3422 g7455_0 g7455_1 0 netg7455
X3423 g473_4 g473_3 g473_0 g473_5 g473_2 g473_1 0 netg473
X3424 g1638_4 g1638_2 g1638_0 g1638_7 g1638_1 g1638_5 g1638_3 0 netg1638
X3425 g7470_1 g7470_0 0 netg7470
X3426 g7471_1 g7471_0 0 netg7471
X3427 g205_2 g205_0 g205_1 0 netg205
X3428 g7460_1 g7460_0 0 netg7460
X3429 g2270_0 g2270_3 g2270_4 g2270_5 g2270_2 g2270_1 0 netg2270
X3430 g7450_0 g7450_1 0 netg7450
X3431 g7504_0 g7504_1 0 netg7504
X3432 g7449_1 g7449_0 0 netg7449
X3433 g7503_0 g7503_1 0 netg7503
X3434 g197_0 g197_1 g197_2 0 netg197
X3435 g4_2 g4_1 g4_0 0 netg4
X3436 g1750_4 g1750_0 g1750_2 g1750_5 g1750_3 g1750_1 0 netg1750
X3437 g457_6 g457_2 g457_5 g457_1 g457_4 g457_3 g457_0 0 netg457
X3438 g1738_5 g1738_2 g1738_1 g1738_4 g1738_3 g1738_0 0 netg1738
X3439 g183_0 g183_1 g183_2 0 netg183
X3440 g7465_1 g7465_0 0 netg7465
X3441 g3_2 g3_1 g3_0 0 netg3
X3442 g1_3 g1_1 g1_0 g1_2 0 netg1
X3443 g167_1 g167_2 g167_0 0 netg167
X3444 g7448_0 g7448_1 0 netg7448
X3445 g7490_1 g7490_0 0 netg7490
X3446 g1744_1 g1744_0 g1744_4 g1744_3 g1744_2 g1744_5 0 netg1744
X3447 g7466_1 g7466_0 0 netg7466
X3448 g178_2 g178_1 g178_0 0 netg178
X3449 g30_0 g30_2 g30_1 0 netg30
X3450 g7467_0 g7467_1 0 netg7467
X3451 g191_2 g191_1 g191_0 0 netg191
X3452 g464_0 g464_4 g464_3 g464_2 g464_1 g464_5 0 netg464
X3453 g179_2 g179_1 g179_0 0 netg179
X3454 g195_0 g195_2 g195_1 0 netg195
X3455 g7456_0 g7456_1 0 netg7456
X3456 g7484_0 g7484_1 0 netg7484
X3457 g192_2 g192_1 g192_0 0 netg192
X3458 g199_0 g199_1 g199_2 0 netg199
X3459 g202_0 g202_2 g202_1 0 netg202
X3460 g14_0 g14_2 g14_1 0 netg14
X3461 g176_2 g176_1 g176_0 0 netg176
X3462 g13_2 g13_1 g13_0 0 netg13
X3463 g1731_5 g1731_4 g1731_0 g1731_3 g1731_1 g1731_2 g1731_6 0 netg1731
X3464 g1756_5 g1756_3 g1756_1 g1756_4 g1756_2 g1756_0 0 netg1756
X3465 g201_1 g201_2 g201_0 0 netg201
X3466 g203_0 g203_2 g203_1 0 netg203
X3467 g204_1 g204_2 g204_0 0 netg204
X3468 g198_0 g198_2 g198_1 0 netg198
X3469 g7_2 g7_0 g7_1 0 netg7
X3470 g186_1 g186_2 g186_0 0 netg186
X3471 g9_1 g9_2 g9_0 0 netg9
X3472 g196_2 g196_1 g196_0 0 netg196
X3473 g206_10 g206_5 g206_8 g206_7 g206_4 g206_14 g206_3 g206_1 g206_6 g206_13 g206_12 g206_2 g206_0 g206_11 g206_9 0 netg206
X3474 g16_1 g16_2 g16_0 0 netg16
X3475 g177_1 g177_0 g177_2 0 netg177
X3476 g7483_1 g7483_0 0 netg7483
X3477 g200_0 g200_2 g200_1 0 netg200
X3478 g8_1 g8_2 g8_0 0 netg8
X3479 g207_3 g207_2 g207_0 g207_4 g207_1 0 netg207
X3480 g11_2 g11_1 0 netg11
X3481 g6_0 g6_2 g6_1 g6_4 g6_3 0 netg6
X3482 g15_0 g15_2 g15_1 0 netg15
X3483 g187_2 g187_0 g187_1 0 netg187
X3484 g10_1 g10_0 g10_2 0 netg10
X3485 g182_1 g182_0 g182_2 0 netg182
X3486 g173_2 g173_0 g173_3 g173_1 0 netg173
X3487 g174_2 g174_3 g174_1 g174_0 0 netg174
X3488 g388_2 g388_1 g388_0 0 netg388
X3489 g181_0 g181_2 g181_1 g181_3 0 netg181
X3490 g87_0 g87_1 0 netg87
X3491 g166_0 g166_2 g166_1 0 netg166
X3492 g180_0 g180_1 g180_2 0 netg180
X3493 g185_0 g185_2 g185_1 g185_3 0 netg185
X3494 g184_0 g184_3 g184_2 g184_1 0 netg184
X3495 g165_1 g165_0 0 netg165

* the calls of the component sub circuits:

X3496 g2386_0 vdd 0 g2788_0 not1
X3497 g6994_0 g6881_0 vdd 0 g7532_0 or2
X3498 g49_2 g6075_0 g6016_0 vdd 0 x441_1 and3
X3499 g2284_1 vdd 0 g3192_1 not1
X3500 g3234_1 g1267_1 vdd 0 g4021_0 nand2
X3501 g1108_3 g1120_0 vdd 0 g1407_1 or2
X3502 g2618_2 vdd 0 g2995_1 not1
X3503 g1600_3 vdd 0 g2409_2 not1
X3504 g1411_3 vdd 0 g1942_2 not1
X3505 g31_0 g1330_4 vdd 0 g1571_1 and2
X3506 g4539_5 g2885_0 vdd 0 g5348_0 and2
X3507 g646_1 g2244_2 vdd 0 g3019_0 and2
X3508 g4463_8 vdd 0 g5619_2 not1
X3509 g1929_1 g1556_1 vdd 0 g2300_1 or2
X3510 g526_1 g1698_3 vdd 0 g2055_3 and2
X3511 g6371_0 g6370_1 vdd 0 g6475_1 nand2
X3512 g5086_2 g7101_0 vdd 0 g7125_1 nand2
X3513 g4913_3 g4908_4 g3060_1 vdd 0 g5520_1 and3
X3514 g3024_0 g5485_0 g5486_0 g5487_0 vdd 0 g5939_0 or4
X3515 g2338_0 g2119_1 vdd 0 g3059_1 and2
X3516 g3432_0 vdd 0 g4204_1 not1
X3517 g8_1 g785_2 vdd 0 g1222_0 and2
X3518 g747_1 g1889_0 vdd 0 g1995_0 or2
X3519 g3404_2 vdd 0 g4110_0 not1
X3520 g5535_1 g5532_1 g5549_1 vdd 0 g6089_1 and3
X3521 x171_1 x172_0 vdd 0 g5184_1 or2
X3522 g1756_0 vdd 0 g2398_0 not1
X3523 g4383_0 vdd 0 g5265_1 not1
X3524 g7008_1 g6973_0 vdd 0 g7051_0 nand2
X3525 g4006_1 g4003_0 g3999_2 vdd 0 x111_1 and3
X3526 g6281_1 vdd 0 g6440_1 not1
X3527 g553_4 vdd 0 g904_1 not1
X3528 g2650_1 g3345_0 vdd 0 g3566_0 nand2
X3529 g6631_0 g6258_0 vdd 0 g6733_0 nand2
X3530 g3665_1 g3644_1 vdd 0 x472_0 and2
X3531 g4519_3 vdd 0 g5578_0 not1
X3532 g4899_1 g4896_0 g4905_1 vdd 0 g5514_0 and3
X3533 g1836_0 g1616_1 vdd 0 g2224_1 and2
X3534 g4976_1 vdd 0 g5239_1 not1
X3535 g1948_2 g1383_0 vdd 0 g2746_1 nand2
X3536 g5139_1 vdd 0 g5684_1 not1
X3537 g486_1 g828_0 vdd 0 g1288_0 and2
X3538 g859_1 vdd 0 g1125_1 not1
X3539 g4850_11 vdd 0 g5734_1 not1
X3540 g652_5 vdd 0 g1054_1 not1
X3541 g129_0 g1206_3 vdd 0 g1494_0 and2
X3542 g2641_0 vdd 0 g3045_1 not1
X3543 g3222_0 vdd 0 g4014_1 not1
X3544 g3168_2 vdd 0 g3937_1 not1
X3545 g4704_4 vdd 0 g5557_2 not1
X3546 g73_2 g1138_4 vdd 0 g1431_1 and2
X3547 g2576_0 vdd 0 g2935_0 not1
X3548 x31_0 x32_0 vdd 0 g4346_1 and2
X3549 g5125_0 g5703_1 vdd 0 g5929_0 nand2
X3550 g5658_1 g7358_0 vdd 0 g7374_1 nand2
X3551 g7041_1 g5591_1 vdd 0 g7092_0 nand2
X3552 g4060_0 g4269_1 vdd 0 g4834_15 nand2
X3553 g4764_2 vdd 0 g5445_2 not1
X3554 g2989_0 g6919_0 vdd 0 g6957_0 or2
X3555 g140_0 g805_0 vdd 0 g1251_0 and2
X3556 g4863_0 vdd 0 g5719_1 not1
X3557 g4653_1 g4642_0 g2944_0 g4648_0 vdd 0 g5393_1 and4
X3558 g772_2 vdd 0 g1185_5 not1
X3559 g3195_0 g3980_1 vdd 0 g4238_1 nand2
X3560 g7203_2 vdd 0 g7250_1 not1
X3561 g4630_4 g2936_1 vdd 0 g5385_1 and2
X3562 g3572_0 g3573_0 vdd 0 g4196_1 nand2
X3563 g865_1 g2770_0 vdd 0 g3468_1 nand2
X3564 g518_0 g842_1 vdd 0 g1356_0 and2
X3565 g2763_0 g2764_1 vdd 0 g3106_1 nand2
X3566 g3086_0 g1386_1 vdd 0 g4139_1 nand2
X3567 g2486_1 vdd 0 g2832_1 not1
X3568 g1782_3 vdd 0 g2588_2 not1
X3569 g7260_0 g5780_1 g6687_0 vdd 0 g7299_1 and3
X3570 g6182_0 g6699_0 vdd 0 g6781_0 and2
X3571 g2746_0 g2791_1 vdd 0 g3477_0 nand2
X3572 g2215_2 vdd 0 g3282_1 not1
X3573 g3484_0 g2800_1 vdd 0 g3694_3 nand2
X3574 g883_1 g1381_1 vdd 0 g1428_1 nand2
X3575 g5092_0 vdd 0 g5606_1 not1
X3576 g3303_1 g1308_0 vdd 0 g4052_1 nand2
X3577 g6484_1 g6365_0 vdd 0 g6608_1 nand2
X3578 g3928_7 g4568_11 vdd 0 x222_1 and2
X3579 g2516_2 g4618_0 vdd 0 g5182_1 nand2
X3580 g162_1 g1484_5 vdd 0 g1913_1 and2
X3581 g4346_0 g6590_0 vdd 0 g6686_0 and2
X3582 g2062_2 g3754_2 vdd 0 x62_0 and2
X3583 g7231_2 vdd 0 g7263_1 not1
X3584 g6815_0 g6721_1 vdd 0 g6840_2 nand2
X3585 g2683_2 vdd 0 g3057_1 not1
X3586 g1910_0 g1483_1 vdd 0 g2194_5 or2
X3587 g964_2 vdd 0 g1228_1 not1
X3588 g494_5 vdd 0 g716_4 not1
X3589 g5740_2 vdd 0 g6139_0 not1
X3590 g7287_1 g6140_1 vdd 0 g7335_1 nand2
X3591 g2280_0 vdd 0 g3198_2 not1
X3592 g5875_0 g4149_0 vdd 0 g6246_1 nand2
X3593 g2848_0 g5313_0 g5314_0 g5315_0 vdd 0 g5795_1 or4
X3594 g3803_2 g3768_0 g3754_1 g3784_2 vdd 0 g4417_1 and4
X3595 g5867_1 g6451_0 vdd 0 g6550_1 nand2
X3596 g6659_1 g6606_1 vdd 0 g6703_0 nand2
X3597 g2756_0 vdd 0 g3561_0 not1
X3598 g2203_4 vdd 0 g3165_2 not1
X3599 g7_0 g1212_2 vdd 0 g1499_0 and2
X3600 g473_3 g1750_2 vdd 0 g2001_0 and2
X3601 g7231_2 g6009_0 vdd 0 g7264_1 nand2
X3602 g2885_2 g5353_1 vdd 0 g5806_2 or2
X3603 g1387_2 g4140_1 vdd 0 g4302_1 nand2
X3604 g1698_4 vdd 0 g2468_0 not1
X3605 g6667_1 g6641_1 vdd 0 g6738_2 nand2
X3606 g3453_2 g4207_1 vdd 0 g4320_1 nand2
X3607 g3426_1 g4203_1 vdd 0 g4316_1 nand2
X3608 g3159_2 vdd 0 g3923_0 not1
X3609 g3132_1 g1228_0 vdd 0 g3899_1 nand2
X3610 g7096_2 g5601_0 vdd 0 g7140_1 nand2
X3611 g621_6 g1537_5 vdd 0 g1923_1 and2
X3612 g3665_4 g2013_4 vdd 0 g4358_1 and2
X3613 g473_0 g1750_0 vdd 0 g1961_0 and2
X3614 g5015_2 vdd 0 g5587_1 not1
X3615 g36_0 g1330_1 vdd 0 g1574_0 and2
X3616 g6278_2 g6013_1 vdd 0 g6437_1 nand2
X3617 g5613_0 g6167_0 vdd 0 g6327_1 nand2
X3618 g494_0 vdd 0 g753_1 not1
X3619 g4064_1 g4271_0 vdd 0 g4863_1 nand2
X3620 g2650_2 vdd 0 g3346_1 not1
X3621 g4997_2 g6898_0 vdd 0 g6937_1 nand2
X3622 g5984_1 vdd 0 g6154_1 not1
X3623 g3705_0 g4374_1 g5268_1 vdd 0 g5779_1 and3
X3624 g2326_2 g2107_0 vdd 0 g3062_1 and2
X3625 g690_1 vdd 0 g796_1 not1
X3626 g3123_2 vdd 0 g3894_1 not1
X3627 g6990_2 vdd 0 g7073_1 not1
X3628 g5816_0 g6534_0 g6535_0 g6350_0 vdd 0 g6589_0 or4
X3629 g6196_0 g6048_1 vdd 0 g6361_0 nor2
X3630 g1431_0 g1151_0 vdd 0 g1675_2 or2
X3631 g4307_1 g4308_0 vdd 0 g5131_2 nand2
X3632 g1859_2 vdd 0 g2421_1 not1
X3633 g1874_1 g2633_0 vdd 0 g2765_1 nand2
X3634 g4313_0 g4314_1 vdd 0 g5136_2 nand2
X3635 g2870_0 g5331_0 g5332_0 g5990_0 vdd 0 g6217_0 or4
X3636 g3617_9 g3601_7 g3579_2 vdd 0 x21_1 and3
X3637 g7309_2 g5839_1 g6833_3 vdd 0 g7355_0 and3
X3638 g5234_1 g5235_1 vdd 0 g5680_2 nand2
X3639 g640_5 g1537_4 vdd 0 g1926_1 and2
X3640 g7144_2 g5609_1 vdd 0 g7186_1 nand2
X3641 g5205_2 g6623_1 vdd 0 g6666_1 nand2
X3642 g4935_0 g4931_0 g4920_0 vdd 0 x301_1 and3
X3643 g2127_1 vdd 0 g3156_0 not1
X3644 g7297_1 g7278_1 vdd 0 g7324_1 nand2
X3645 g3862_3 g2096_1 g3852_1 vdd 0 g4451_0 and3
X3646 g147_0 g1521_3 vdd 0 g1917_1 and2
X3647 g2119_3 vdd 0 g3377_2 not1
X3648 g5643_2 g7105_1 vdd 0 g7127_1 nand2
X3649 g17_1 g1337_6 vdd 0 g1577_1 and2
X3650 g5476_0 g5477_0 vdd 0 x352_1 or2
X3651 g5713_0 vdd 0 g6132_0 not1
X3652 g2859_1 vdd 0 g4154_2 not1
X3653 g6322_0 g6026_0 vdd 0 g6539_1 and2
X3654 g6214_1 vdd 0 g6405_1 not1
X3655 g1295_6 vdd 0 g1521_4 not1
X3656 g691_2 vdd 0 g1082_2 not1
X3657 g5731_2 vdd 0 g6136_1 not1
X3658 g6351_1 g5287_0 vdd 0 g6536_1 and2
X3659 g6223_0 vdd 0 g6411_0 not1
X3660 g5543_1 vdd 0 g6081_0 not1
X3661 g3637_2 g3665_2 vdd 0 x32_1 and2
X3662 g3438_1 g3085_0 vdd 0 g4133_0 nand2
X3663 g3453_0 vdd 0 g4206_1 not1
X3664 g7400_1 g7388_1 vdd 0 g7408_1 nand2
X3665 g2092_2 g4453_1 g4454_1 g6692_1 vdd 0 g6793_2 or4
X3666 g934_1 g2836_1 vdd 0 g3506_1 nand2
X3667 g2365_0 vdd 0 g3093_1 not1
X3668 g450_0 vdd 0 g1003_1 not1
X3669 g6522_0 g6412_0 vdd 0 g7509_1 nand2
X3670 g188_0 vdd 0 g7465_0 not1
X3671 g494_2 vdd 0 g727_1 not1
X3672 x541_1 x542_1 vdd 0 g7503_0 or2
X3673 g6284_2 vdd 0 g6487_0 not1
X3674 g6046_1 g6045_0 vdd 0 g6281_2 nand2
X3675 g1048_1 vdd 0 g1312_0 not1
X3676 g6335_1 g6580_1 vdd 0 g6654_1 and2
X3677 g7122_0 g7090_0 vdd 0 g7131_2 nand2
X3678 g52_0 g1185_0 vdd 0 g1461_0 and2
X3679 g2507_1 g1177_1 vdd 0 g2845_1 nand2
X3680 g1018_1 g4016_1 vdd 0 g4249_1 nand2
X3681 g7375_1 g7442_1 vdd 0 g7444_1 nand2
X3682 g7225_1 g5605_1 vdd 0 g7276_1 nand2
X3683 g2258_5 vdd 0 g3306_2 not1
X3684 g5185_0 vdd 0 g5827_0 not1
X3685 g3839_1 g3828_5 g3817_7 vdd 0 g4437_0 and3
X3686 g1902_0 g1475_1 vdd 0 g2159_2 or2
X3687 g2665_1 vdd 0 g3050_0 not1
X3688 g4568_8 vdd 0 g5661_0 not1
X3689 g3895_0 g4218_1 vdd 0 g4474_0 nand2
X3690 g1961_1 g4332_0 g4333_1 vdd 0 x191_0 or3
X3691 g6942_3 g6400_0 vdd 0 g7017_0 and2
X3692 g172_1 vdd 0 g7451_1 not1
X3693 g2200_2 vdd 0 g3270_2 not1
X3694 g1792_1 g2241_2 vdd 0 g3069_1 and2
X3695 g3165_1 g1238_1 vdd 0 g3926_0 nand2
X3696 g6705_3 vdd 0 g6833_2 not1
X3697 g3312_2 vdd 0 g4059_1 not1
X3698 g1500_0 g799_3 vdd 0 g1815_0 and2
X3699 g7237_0 g6113_1 vdd 0 g7280_0 nand2
X3700 g3725_6 vdd 0 g5062_1 not1
X3701 g3216_1 g1261_0 vdd 0 g4009_1 nand2
X3702 g1738_4 vdd 0 g2356_1 not1
X3703 g3665_9 g3654_9 g3637_6 vdd 0 x41_1 and3
X3704 g2412_2 g2801_1 vdd 0 g3485_1 nand2
X3705 g666_5 g1543_3 vdd 0 g1930_1 and2
X3706 g4179_2 g6489_0 vdd 0 g6557_1 nand2
X3707 g3300_2 vdd 0 g4051_1 not1
X3708 g6957_1 g5962_0 vdd 0 g7026_0 nand2
X3709 g2300_0 g1803_0 vdd 0 g2938_0 and2
X3710 g4568_1 g4560_1 vdd 0 x402_0 and2
X3711 g119_0 g1462_1 vdd 0 g1904_1 and2
X3712 g7078_0 g7026_1 vdd 0 g7544_0 nand2
X3713 g2453_0 vdd 0 g2814_1 not1
X3714 g479_0 vdd 0 g886_2 not1
X3715 g4687_3 g2969_6 vdd 0 g5417_0 and2
X3716 g6705_0 g7408_0 vdd 0 g7413_1 and2
X3717 g5566_0 vdd 0 g5962_1 not1
X3718 g7374_0 g7359_0 vdd 0 g7391_1 nand2
X3719 g4982_2 vdd 0 g5241_1 not1
X3720 g2456_2 vdd 0 g2816_1 not1
X3721 g104_0 g753_6 vdd 0 g1152_0 and2
X3722 g6340_3 g6056_6 g5280_4 vdd 0 g6527_1 and3
X3723 g7445_1 vdd 0 g7552_1 not1
X3724 g5448_1 vdd 0 g6042_0 not1
X3725 g907_0 vdd 0 g1163_1 not1
X3726 g5731_1 g7071_1 vdd 0 g7083_0 nand2
X3727 g6802_1 g5244_1 vdd 0 g6895_1 nand2
X3728 g61_0 g1192_3 vdd 0 g1474_0 and2
X3729 g3687_2 g3683_3 g4377_1 vdd 0 g5269_1 and3
X3730 g4284_1 g4285_0 vdd 0 g4920_1 nand2
X3731 g1840_2 vdd 0 g2725_0 not1
X3732 g4756_1 g5434_1 g6042_1 vdd 0 g6196_1 and3
X3733 g538_4 vdd 0 g940_2 not1
X3734 g5334_6 g4582_10 g4598_12 vdd 0 g6007_1 and3
X3735 g2627_1 g3000_0 vdd 0 g3545_0 nand2
X3736 g5986_0 g206_2 vdd 0 g6331_1 and2
X3737 g1670_1 vdd 0 g1999_1 not1
X3738 g4167_0 g6040_0 vdd 0 g6194_1 nand2
X3739 g6645_1 g6291_0 vdd 0 g6744_1 nand2
X3740 g3617_5 g3601_14 g1978_5 vdd 0 g4340_1 and3
X3741 g94_1 g705_4 vdd 0 g1085_1 and2
X3742 g3330_2 vdd 0 g4182_1 not1
X3743 g3144_0 g5998_0 vdd 0 g6173_0 nand2
X3744 g181_0 vdd 0 g544_0 not1
X3745 g2686_1 vdd 0 g3364_1 not1
X3746 g1423_4 vdd 0 g1951_1 not1
X3747 x251_1 x252_0 vdd 0 g5418_2 and2
X3748 g2244_5 vdd 0 g3309_2 not1
X3749 g1807_0 vdd 0 g2576_2 not1
X3750 g4519_4 g4508_0 g3907_4 vdd 0 g5332_1 and3
X3751 g456_1 g821_6 vdd 0 g1281_1 and2
X3752 g185_3 vdd 0 g423_4 not1
X3753 g2959_0 g5413_0 g5414_0 vdd 0 g5920_2 nor3
X3754 g177_0 vdd 0 g519_2 not1
X3755 g1916_0 g1762_0 vdd 0 g2235_0 and2
X3756 g1435_0 g1155_1 vdd 0 g1865_1 or2
X3757 g473_4 vdd 0 g865_1 not1
X3758 g4282_1 g4283_0 vdd 0 g4917_2 nand2
X3759 g614_4 g2153_3 vdd 0 g2848_1 and2
X3760 g4812_6 g3020_3 vdd 0 g5474_1 and2
X3761 g4617_1 g5182_0 vdd 0 g5334_5 nand2
X3762 g199_1 vdd 0 g634_1 not1
X3763 g5101_2 vdd 0 g5296_0 not1
X3764 g4407_2 vdd 0 g5275_1 not1
X3765 g7294_0 g7272_0 vdd 0 g7315_0 nand2
X3766 g4392_1 vdd 0 g5268_1 not1
X3767 g940_1 vdd 0 g1174_0 not1
X3768 g194_0 vdd 0 g7471_1 not1
X3769 g1766_0 vdd 0 g2612_0 not1
X3770 g202_1 vdd 0 g7478_0 not1
X3771 g660_2 g2258_2 vdd 0 g2963_0 and2
X3772 g5920_1 g6034_0 vdd 0 g6188_0 nand2
X3773 g3557_0 g3558_0 vdd 0 g4121_2 nand2
X3774 g2612_1 vdd 0 g2955_1 not1
X3775 g2250_6 vdd 0 g3321_2 not1
X3776 g3920_1 g4227_1 vdd 0 g4560_6 nand2
X3777 g588_5 g2127_3 vdd 0 g2866_1 and2
X3778 g179_1 vdd 0 g532_4 not1
X3779 g3549_1 g3053_1 vdd 0 g4084_3 nand2
X3780 g7398_0 g7386_0 vdd 0 g7407_0 nand2
X3781 g83_0 g760_1 vdd 0 g1158_0 and2
X3782 g4429_1 g4443_1 vdd 0 g5287_3 and2
X3783 g2071_2 g4435_0 g4436_0 g4437_1 vdd 0 g5220_0 or4
X3784 g5056_1 g7046_0 vdd 0 g7081_1 nand2
X3785 g5852_1 vdd 0 g6208_1 not1
X3786 g4598_3 g4582_3 g3928_3 vdd 0 g5367_0 and3
X3787 g7129_1 g7113_1 vdd 0 g7158_2 nand2
X3788 g2033_0 g4406_1 vdd 0 g5167_0 or2
X3789 g979_0 g3917_0 vdd 0 g4225_0 nand2
X3790 g391_0 vdd 0 g7490_0 not1
X3791 g3828_8 g3810_5 g2081_5 g3817_8 vdd 0 g4434_1 and4
X3792 g2552_1 g2925_1 vdd 0 g3522_0 nand2
X3793 g5955_1 g6307_1 g6505_1 vdd 0 x531_1 or3
X3794 g7193_2 g6120_1 vdd 0 g7241_1 nand2
X3795 g3270_0 g3002_0 vdd 0 g4044_0 nand2
X3796 g6615_1 vdd 0 g6718_0 not1
X3797 g3237_2 vdd 0 g4024_0 not1
X3798 g2_3 vdd 0 g407_1 not1
X3799 g7409_1 vdd 0 g7412_1 not1
X3800 g1006_1 vdd 0 g1260_1 not1
X3801 g4286_1 g4104_1 vdd 0 g4926_4 nand2
X3802 g2127_2 vdd 0 g3132_2 not1
X3803 g1030_2 g4024_1 vdd 0 g4253_1 nand2
X3804 g6246_1 g6392_0 vdd 0 g6456_0 nand2
X3805 g3174_0 g2933_0 vdd 0 g3971_0 nand2
X3806 g5341_0 g6002_0 vdd 0 g6336_2 and2
X3807 g1590_0 g1365_0 vdd 0 g1848_2 or2
X3808 g608_3 g2147_4 vdd 0 g2881_2 and2
X3809 g2683_1 g3056_1 vdd 0 g3552_1 nand2
X3810 g1897_0 g1458_0 vdd 0 g2133_1 or2
X3811 g6359_0 vdd 0 g6400_1 not1
X3812 g519_4 g1691_5 vdd 0 g2101_3 and2
X3813 g2867_1 g5328_1 g5329_0 vdd 0 x411_1 or3
X3814 g397_1 g391_1 vdd 0 g682_1 and2
X3815 g7321_2 vdd 0 g7346_1 not1
X3816 g3117_1 vdd 0 g3890_1 not1
X3817 g3754_11 vdd 0 g5077_0 not1
X3818 g4568_9 g4560_5 g2901_3 vdd 0 g5355_1 and3
X3819 g5217_2 vdd 0 g5890_1 not1
X3820 g1911_1 g1495_1 vdd 0 g2638_1 or2
X3821 g4896_1 g4088_3 g5511_1 vdd 0 g5846_1 and3
X3822 g65_0 g1178_0 vdd 0 g1454_0 and2
X3823 g5575_1 g6409_0 vdd 0 g6521_1 nand2
X3824 g2258_1 vdd 0 g3258_1 not1
X3825 g1401_0 g721_1 vdd 0 g1612_0 and2
X3826 g553_0 g849_0 vdd 0 g1363_1 and2
X3827 g883_0 vdd 0 g1133_1 not1
X3828 g71_1 g1144_3 vdd 0 g1435_1 and2
X3829 g4371_1 g3709_1 g5267_0 vdd 0 g5778_0 and3
X3830 g991_0 g3925_1 vdd 0 g4229_1 nand2
X3831 g7378_1 vdd 0 g7402_1 not1
X3832 g1185_1 vdd 0 g1446_0 not1
X3833 g81_0 g740_1 vdd 0 g1119_1 and2
X3834 g7211_1 g7190_1 vdd 0 g7234_1 nand2
X3835 g3961_1 g3950_0 g2228_0 g3956_4 vdd 0 g4628_0 and4
X3836 g6700_1 vdd 0 g6823_1 not1
X3837 g2029_2 g4404_0 g4405_0 vdd 0 g5205_0 nor3
X3838 g4887_2 g4078_3 g6065_0 vdd 0 g6205_1 and3
X3839 g16_0 g1295_3 vdd 0 g1535_0 and2
X3840 g6781_2 g5820_0 vdd 0 g6876_1 and2
X3841 g3374_2 vdd 0 g4097_1 not1
X3842 g2606_2 g2954_1 vdd 0 g3537_1 nand2
X3843 g6725_2 vdd 0 g6845_1 not1
X3844 g3828_7 g2081_3 vdd 0 g4442_1 and2
X3845 g3249_0 vdd 0 g4040_1 not1
X3846 g6563_1 g6583_1 g6697_1 g6698_0 vdd 0 g6778_1 and4
X3847 g4007_1 g4245_1 vdd 0 g4669_5 nand2
X3848 g2280_2 vdd 0 g3444_2 not1
X3849 g507_4 g1716_1 vdd 0 g2241_1 and2
X3850 g5024_2 vdd 0 g5252_1 not1
X3851 g3587_2 g1965_2 vdd 0 g4336_0 and2
X3852 g2585_1 g3984_0 vdd 0 g4242_0 nand2
X3853 g5015_1 g7173_0 vdd 0 g7206_0 nand2
X3854 g2194_1 vdd 0 g3228_0 not1
X3855 g5974_0 g6526_0 g6527_0 g6528_1 vdd 0 g6565_2 or4
X3856 g115_1 g1289_2 vdd 0 g1529_1 and2
X3857 g7027_1 vdd 0 g7538_1 not1
X3858 g1054_2 g4065_1 vdd 0 g4271_1 nand2
X3859 g5816_3 g5395_2 vdd 0 g6151_1 and2
X3860 g3768_3 vdd 0 g5092_2 not1
X3861 g5668_1 vdd 0 g6119_1 not1
X3862 g7_2 g785_6 vdd 0 g1223_1 and2
X3863 g2728_0 g3410_0 vdd 0 g3574_0 nand2
X3864 g2426_2 vdd 0 g2807_0 not1
X3865 g4687_8 g4669_3 g2969_4 g4676_6 vdd 0 g5409_0 and4
X3866 g187_2 vdd 0 g567_1 not1
X3867 g3564_1 g3565_0 vdd 0 g4143_1 nand2
X3868 g3389_2 vdd 0 g4102_1 not1
X3869 g404_0 vdd 0 g696_0 not1
X3870 g169_1 vdd 0 g457_4 not1
X3871 g6937_0 g6899_1 vdd 0 g7528_1 nand2
X3872 g6936_1 g6897_1 vdd 0 g7527_1 nand2
X3873 g1658_4 vdd 0 g2444_1 not1
X3874 g3465_1 g6760_4 vdd 0 g6877_1 and2
X3875 g3141_2 vdd 0 g3906_1 not1
X3876 g4639_0 g4630_0 g2939_0 g4635_0 vdd 0 g5387_0 and4
X3877 g3321_1 vdd 0 g4065_0 not1
X3878 g4121_0 vdd 0 g4970_0 not1
X3879 g2588_0 g2948_1 vdd 0 g3531_0 nand2
X3880 g2546_0 g2923_0 vdd 0 g3520_0 nand2
X3881 g5625_1 g4531_0 vdd 0 g5999_0 nand2
X3882 g7068_1 g6134_0 vdd 0 g7115_1 nand2
X3883 g6967_2 vdd 0 g7046_1 not1
X3884 g2825_1 g3501_1 vdd 0 g3797_4 nand2
X3885 g1102_4 g1114_0 vdd 0 g1401_1 or2
X3886 g3282_2 g4047_1 vdd 0 g4262_1 nand2
X3887 g747_3 g1887_1 g1994_1 vdd 0 g2756_2 or3
X3888 g6927_0 g6871_0 vdd 0 g6987_2 nand2
X3889 g2474_0 vdd 0 g2828_0 not1
X3890 g6495_0 vdd 0 g6650_0 not1
X3891 g3524_0 g3525_0 vdd 0 g3965_1 nand2
X3892 g5560_1 g7021_1 vdd 0 g7076_0 nand2
X3893 g2621_1 g2998_1 vdd 0 g3543_1 nand2
X3894 g7014_0 g6999_1 vdd 0 g7536_1 nand2
X3895 g6771_6 g4742_6 vdd 0 g6919_1 and2
X3896 g5027_0 vdd 0 g5590_1 not1
X3897 g3903_1 g4222_0 vdd 0 g4508_7 nand2
X3898 g545_5 g1638_7 vdd 0 g2038_4 and2
X3899 g2415_2 g2804_1 vdd 0 g3488_1 nand2
X3900 g2644_1 g4073_0 vdd 0 g4276_1 nand2
X3901 g6948_2 g5959_0 vdd 0 g7020_0 nand2
X3902 g5502_0 vdd 0 g6064_0 not1
X3903 g2465_1 g1165_1 vdd 0 g2821_0 nand2
X3904 g63_2 g1199_1 vdd 0 g1483_1 and2
X3905 g4661_0 g4657_1 g4653_2 vdd 0 x231_1 and3
X3906 g4582_9 g2907_3 vdd 0 g5364_1 and2
X3907 g6464_1 g6553_1 vdd 0 g6631_2 nand2
X3908 g3361_2 g4188_0 vdd 0 g4313_1 nand2
X3909 g6859_0 vdd 0 g6978_1 not1
X3910 g2326_1 vdd 0 g3386_0 not1
X3911 g4491_1 g4519_2 vdd 0 x382_0 and2
X3912 g7417_0 g7373_1 vdd 0 g7423_0 nand2
X3913 g5178_1 g4429_2 vdd 0 g5784_0 and2
X3914 g1246_2 g1255_1 vdd 0 g1506_0 or2
X3915 g6738_2 vdd 0 g6862_1 not1
X3916 g7312_2 g6442_2 g6705_4 vdd 0 g7356_1 and3
X3917 g3617_7 vdd 0 g5012_1 not1
X3918 g874_2 vdd 0 g1130_1 not1
X3919 g877_2 g1132_1 vdd 0 g1380_1 nand2
X3920 g526_5 vdd 0 g916_2 not1
X3921 g5036_0 g7273_0 vdd 0 g7295_0 nand2
X3922 g3907_0 g4498_0 vdd 0 x212_1 and2
X3923 g2552_0 vdd 0 g2926_0 not1
X3924 g3404_1 g4109_1 vdd 0 g4289_0 nand2
X3925 g185_1 vdd 0 g7462_0 not1
X3926 g7222_1 vdd 0 g7273_1 not1
X3927 g4448_0 g4449_0 vdd 0 x162_1 or2
X3928 g1862_2 vdd 0 g2422_1 not1
X3929 g28_1 g1350_4 vdd 0 g1586_1 and2
X3930 g3579_0 vdd 0 g5015_0 not1
X3931 g2773_1 g3470_1 vdd 0 g3617_11 nand2
X3932 g2001_1 g4353_0 g4354_0 vdd 0 x501_1 or3
X3933 g1807_2 vdd 0 g2656_1 not1
X3934 g58_0 g1269_0 vdd 0 g1515_0 and2
X3935 g2013_2 g6685_0 vdd 0 g6811_0 or2
X3936 g4820_9 g3024_2 vdd 0 g5478_1 and2
X3937 g78_0 g740_3 vdd 0 g1122_0 and2
X3938 g5459_1 g5471_0 vdd 0 g6056_5 and2
X3939 g666_3 g2264_3 vdd 0 g3004_2 and2
X3940 g5115_1 g6272_1 vdd 0 g6394_1 nand2
X3941 g3186_1 vdd 0 g3978_1 not1
X3942 g5280_6 g5253_3 vdd 0 x462_1 and2
X3943 g2392_1 vdd 0 g2795_1 not1
X3944 x91_1 x92_0 vdd 0 g4625_0 and2
X3945 g1036_2 g4053_0 vdd 0 g4265_1 nand2
X3946 g1995_2 g1998_1 vdd 0 g3086_2 or2
X3947 g7298_1 g7280_1 vdd 0 g7327_1 nand2
X3948 g4902_2 vdd 0 g5511_0 not1
X3949 g7411_1 g792_3 vdd 0 g7421_1 and2
X3950 g5578_2 vdd 0 g5966_1 not1
X3951 g4355_0 g6682_1 vdd 0 x502_0 or2
X3952 g5755_1 g7250_1 vdd 0 g7256_1 nand2
X3953 g2907_2 g5368_1 vdd 0 g5813_2 or2
X3954 g2827_0 g3502_1 vdd 0 g3803_3 nand2
X3955 g640_2 g2194_4 vdd 0 g2977_0 and2
X3956 g7213_1 g7197_0 vdd 0 g7242_2 nand2
X3957 g4704_5 g2977_2 vdd 0 g5421_1 and2
X3958 g1896_1 g1457_1 vdd 0 g2127_4 or2
X3959 g5006_1 vdd 0 g5583_0 not1
X3960 g4850_1 g3037_0 vdd 0 g5490_1 and2
X3961 g5820_1 vdd 0 g6181_1 not1
X3962 g5144_1 g5767_0 vdd 0 g5954_1 nand2
X3963 g2300_2 vdd 0 g3180_1 not1
X3964 g1765_0 g1510_1 vdd 0 g1916_1 nand2
X3965 g4560_4 g2897_0 vdd 0 g5354_0 and2
X3966 g4017_0 g4250_0 vdd 0 g4711_8 nand2
X3967 g4074_3 vdd 0 g4887_1 not1
X3968 g4953_2 vdd 0 g5540_2 not1
X3969 g6597_0 g3883_0 g3862_0 g3873_0 vdd 0 g6692_0 and4
X3970 g3675_0 vdd 0 g4988_2 not1
X3971 g473_1 g821_0 vdd 0 g1285_0 and2
X3972 g4485_0 vdd 0 g5249_1 not1
X3973 g1411_0 g1060_0 vdd 0 g1886_1 and2
X3974 g2591_1 vdd 0 g2948_1 not1
X3975 g4812_1 vdd 0 g5755_2 not1
X3976 g6929_1 g6876_0 vdd 0 g7520_0 or2
X3977 g7245_0 g6053_0 vdd 0 g7270_1 nand2
X3978 g5983_1 g5792_0 vdd 0 g6162_1 nand2
X3979 g4474_3 vdd 0 g5622_2 not1
X3980 g4321_1 g4322_1 vdd 0 g5150_1 nand2
X3981 g3309_1 g1310_1 vdd 0 g4056_1 nand2
X3982 g4956_2 vdd 0 g5532_2 not1
X3983 g1698_0 vdd 0 g2429_0 not1
X3984 g1811_1 vdd 0 g2573_0 not1
X3985 g2235_2 g4662_1 vdd 0 g5395_5 and2
X3986 g5074_1 g7275_0 vdd 0 g7296_0 nand2
X3987 g2653_2 vdd 0 g3347_1 not1
X3988 g6355_1 g6186_1 vdd 0 g6398_1 nand2
X3989 g3754_0 g3746_0 vdd 0 x52_0 and2
X3990 g2480_1 vdd 0 g3113_0 not1
X3991 g6519_0 g6406_0 vdd 0 g7506_0 nand2
X3992 g5909_0 g5667_0 vdd 0 g6273_1 nand2
X3993 g6615_1 g5864_0 vdd 0 g6719_1 nand2
X3994 g6346_1 g5370_0 g5395_0 vdd 0 g6508_1 and3
X3995 g413_1 g1632_2 vdd 0 g2088_0 and2
X3996 g1086_4 g705_2 vdd 0 g1394_0 or2
X3997 g5150_2 vdd 0 g5764_1 not1
X3998 g4491_3 g2867_2 vdd 0 g5324_1 and2
X3999 g1803_3 vdd 0 g2579_2 not1
X4000 g904_2 vdd 0 g1162_1 not1
X4001 g871_2 vdd 0 g1129_1 not1
X4002 g6542_0 g6446_0 vdd 0 g6610_0 nand2
X4003 g2356_1 g1128_0 vdd 0 g2773_0 nand2
X4004 g5030_2 vdd 0 g5591_0 not1
X4005 g1434_0 g1154_0 vdd 0 g1687_1 or2
X4006 g7428_2 vdd 0 g7439_1 not1
X4007 g7284_1 vdd 0 g7332_0 not1
X4008 g2288_3 g2171_3 vdd 0 g2942_1 and2
X4009 g1820_3 g1679_2 vdd 0 g2228_1 and2
X4010 g3547_0 g3548_1 vdd 0 g4078_0 nand2
X4011 g4869_3 g4850_11 g4834_0 vdd 0 x271_0 and3
X4012 g3736_1 g3718_2 g2038_1 g3725_3 vdd 0 g4400_0 and4
X4013 g3698_2 vdd 0 g4368_1 not1
X4014 g2167_0 vdd 0 g3336_1 not1
X4015 g7131_2 vdd 0 g7173_1 not1
X4016 g27_0 g1350_2 vdd 0 g1587_0 and2
X4017 g991_2 vdd 0 g1237_1 not1
X4018 g5758_1 g7334_0 vdd 0 g7341_1 nand2
X4019 g5381_1 g5824_2 vdd 0 g6183_1 and2
X4020 g3487_0 g3488_0 vdd 0 g3702_1 nand2
X4021 g2501_2 g1175_1 vdd 0 g2841_1 nand2
X4022 g5887_2 vdd 0 g6254_1 not1
X4023 g5734_2 g7164_0 vdd 0 g7171_0 nand2
X4024 g2671_0 g2313_0 vdd 0 g3053_0 nand2
X4025 g1658_0 vdd 0 g2483_1 not1
X4026 g3839_4 g3828_10 vdd 0 g4441_1 and2
X4027 g6294_0 vdd 0 g6494_0 not1
X4028 g5150_0 g5765_0 vdd 0 g5952_1 nand2
X4029 g5122_0 vdd 0 g5703_1 not1
X4030 g2843_0 g3510_0 vdd 0 g3873_3 nand2
X4031 g6745_0 g6297_1 vdd 0 g6871_1 nand2
X4032 g4834_14 g3030_3 vdd 0 g5485_1 and2
X4033 g54_1 vdd 0 g470_2 not1
X4034 g7414_2 g7079_1 vdd 0 g7424_1 nand2
X4035 g5839_2 vdd 0 g6199_2 not1
X4036 g6374_2 vdd 0 g6532_1 not1
X4037 g1517_0 g1287_1 vdd 0 g1874_2 or2
X4038 g446_3 vdd 0 g734_5 not1
X4039 g961_1 vdd 0 g1227_0 not1
X4040 g1840_3 g1620_0 vdd 0 g2223_0 and2
X4041 g3702_2 vdd 0 g4383_1 not1
X4042 g6921_2 g5958_1 vdd 0 g6999_0 nand2
X4043 g32_1 g1275_3 vdd 0 g1520_1 and2
X4044 g5926_1 g6036_0 vdd 0 g6192_1 nand2
X4045 g1658_2 vdd 0 g2450_2 not1
X4046 g5820_3 g6183_1 vdd 0 g6346_3 or2
X4047 g4359_2 g3687_3 g5263_0 vdd 0 g5774_1 and3
X4048 g3062_0 g5525_0 g5526_0 vdd 0 x361_1 or3
X4049 g5737_1 g7248_1 vdd 0 g7255_0 nand2
X4050 g7363_2 vdd 0 g7387_1 not1
X4051 g4698_4 g4687_10 g4676_8 vdd 0 g5412_1 and3
X4052 g2722_2 g3081_1 vdd 0 g3557_1 nand2
X4053 g4030_1 g4026_0 g4778_1 vdd 0 g5457_0 and3
X4054 g5836_1 vdd 0 g6288_0 not1
X4055 g1683_2 vdd 0 g2674_2 not1
X4056 g7369_0 g7343_1 vdd 0 g7381_0 nand2
X4057 g4926_3 g4920_5 vdd 0 x292_1 and2
X4058 g501_5 vdd 0 g780_4 not1
X4059 g1786_4 g3071_5 vdd 0 g4164_2 nor2
X4060 g919_0 g2826_1 vdd 0 g3501_1 nand2
X4061 g1853_0 g2405_1 vdd 0 g2762_0 nand2
X4062 x441_0 x442_0 vdd 0 g6310_0 and2
X4063 g5089_0 vdd 0 g5609_1 not1
X4064 g3159_1 g1236_0 vdd 0 g3922_1 nand2
X4065 g6921_1 vdd 0 g6998_1 not1
X4066 g3138_1 vdd 0 g3904_0 not1
X4067 g1082_1 vdd 0 g1384_1 not1
X4068 g898_1 g2812_1 vdd 0 g3494_1 nand2
X4069 g5499_2 vdd 0 g6063_1 not1
X4070 g2380_2 vdd 0 g2784_1 not1
X4071 g5680_0 g6584_0 vdd 0 g6655_0 nand2
X4072 g2071_0 g4438_0 g4439_0 vdd 0 g5223_1 nor3
X4073 g672_1 g2270_0 vdd 0 g3003_0 and2
X4074 g2395_1 g2795_0 vdd 0 g3480_1 nand2
X4075 g2771_1 g3469_1 vdd 0 g3601_1 nand2
X4076 g7041_2 vdd 0 g7091_1 not1
X4077 g5191_2 vdd 0 g5864_1 not1
X4078 g5229_2 vdd 0 g5791_1 not1
X4079 x421_0 x422_0 vdd 0 g6269_1 or2
X4080 g6634_1 vdd 0 g6734_0 not1
X4081 g2_1 vdd 0 g410_2 not1
X4082 g388_2 g410_2 vdd 0 g7496_1 nand2
X4083 g7088_0 g7018_1 vdd 0 g7548_1 or2
X4084 g3477_1 vdd 0 g3682_1 not1
X4085 g2600_2 vdd 0 g2951_0 not1
X4086 g1828_2 vdd 0 g2543_1 not1
X4087 g5777_1 g5272_1 vdd 0 g5970_1 nor2
X4088 g5220_2 vdd 0 g5785_1 not1
X4089 g2561_1 g2930_1 vdd 0 g3527_1 nand2
X4090 g5936_0 g6743_0 vdd 0 g6822_0 nand2
X4091 g168_1 vdd 0 g7448_0 not1
X4092 g2976_0 g5421_0 g5422_0 vdd 0 x341_0 or3
X4093 g6_2 vdd 0 g507_0 not1
X4094 g418_3 vdd 0 g928_1 not1
X4095 g1877_2 vdd 0 g2312_1 not1
X4096 g5540_1 vdd 0 g6080_1 not1
X4097 g2200_1 g507_3 vdd 0 g3071_3 and2
X4098 g1905_0 g1478_0 vdd 0 g2171_0 or2
X4099 g6263_0 g5114_0 vdd 0 g6468_1 nand2
X4100 g3106_0 g6416_1 vdd 0 g6524_0 nand2
X4101 g4687_7 vdd 0 g5697_1 not1
X4102 g4863_4 g4802_9 g4791_9 vdd 0 g5467_1 and3
X4103 g576_4 vdd 0 g970_2 not1
X4104 g3518_1 g3519_0 vdd 0 g3950_1 nand2
X4105 g2182_4 vdd 0 g3249_1 not1
X4106 g2318_2 vdd 0 g3414_1 not1
X4107 g6662_1 g6614_1 vdd 0 g6711_1 nand2
X4108 g6430_2 g5802_3 vdd 0 g6582_1 and2
X4109 g2462_1 vdd 0 g2820_1 not1
X4110 g614_3 g2153_1 vdd 0 g2880_1 and2
X4111 g4994_2 vdd 0 g5245_1 not1
X4112 g5710_2 vdd 0 g6131_1 not1
X4113 g5021_2 g7342_1 vdd 0 g7369_1 nand2
X4114 g176_0 vdd 0 g7454_0 not1
X4115 g6481_0 g6364_0 vdd 0 g6606_0 nand2
X4116 g71_0 g1138_0 vdd 0 g1430_1 and2
X4117 g1670_2 g1423_3 vdd 0 g2019_3 and2
X4118 g6568_3 vdd 0 g6687_2 not1
X4119 g14_1 g785_5 vdd 0 g1219_1 and2
X4120 g6957_2 vdd 0 g7025_0 not1
X4121 x311_1 x312_1 vdd 0 g5799_2 or2
X4122 g3630_5 vdd 0 g5027_2 not1
X4123 g1519_1 g828_5 vdd 0 g1786_3 or2
X4124 g4190_0 g5121_0 vdd 0 g5235_0 nand2
X4125 g5775_0 g5270_0 vdd 0 g5968_0 nor2
X4126 g3718_1 vdd 0 g5059_0 not1
X4127 g2722_1 vdd 0 g3082_0 not1
X4128 g7147_0 vdd 0 g7187_1 not1
X4129 x241_1 x242_1 vdd 0 g5394_1 and2
X4130 g6317_0 g6573_0 vdd 0 g6672_0 and2
X4131 g1638_2 vdd 0 g2441_1 not1
X4132 g5021_2 vdd 0 g5251_1 not1
X4133 g190_2 vdd 0 g7467_1 not1
X4134 g4161_0 g6465_0 vdd 0 g6554_0 nand2
X4135 g5095_1 g5785_1 vdd 0 g5980_0 nand2
X4136 g1868_2 g2995_0 vdd 0 g3541_1 nand2
X4137 g545_4 g1638_7 vdd 0 g2477_1 nor2
X4138 g7084_0 g7074_0 vdd 0 g7119_0 nand2
X4139 g41_1 g1316_1 vdd 0 g1553_0 and2
X4140 g132_0 g1206_2 vdd 0 g1490_1 and2
X4141 g4771_2 vdd 0 g5440_1 not1
X4142 g4711_2 g2980_2 vdd 0 g5425_0 and2
X4143 g3873_2 g3862_5 g2101_1 vdd 0 g4454_0 and3
X4144 g99_0 g727_4 vdd 0 g1116_1 and2
X4145 g69_2 g1138_5 vdd 0 g1434_1 and2
X4146 g5128_0 g5706_0 vdd 0 g5932_0 nand2
X4147 g512_1 vdd 0 g877_1 not1
X4148 g3336_2 g4071_0 vdd 0 g4275_1 nand2
X4149 g1731_5 vdd 0 g2389_2 not1
X4150 g6226_2 g6229_1 vdd 0 g6450_1 nand2
X4151 g1439_1 g1159_0 vdd 0 g1710_4 or2
X4152 g2941_1 g5391_1 g5392_1 vdd 0 x331_1 or3
X4153 g155_1 g1446_5 vdd 0 g1900_1 and2
X4154 g189_2 vdd 0 g576_5 not1
X4155 g450_4 vdd 0 g1000_2 not1
X4156 g3936_1 g4231_0 vdd 0 g4611_0 nand2
X4157 g4598_1 g3928_0 vdd 0 g5368_0 and2
X4158 g3240_1 vdd 0 g4025_1 not1
X4159 g6676_0 g6653_0 vdd 0 g6757_0 nand2
X4160 g5685_2 g6185_0 vdd 0 g6355_0 nand2
X4161 g5640_2 vdd 0 g6106_1 not1
X4162 g2371_2 vdd 0 g3095_1 not1
X4163 g5522_0 g49_0 vdd 0 g6074_0 nand2
X4164 g5167_2 g4427_0 vdd 0 g5871_0 or2
X4165 g4474_10 g4456_3 g2859_5 g4463_9 vdd 0 g5315_1 and4
X4166 g6220_2 vdd 0 g6409_1 not1
X4167 g20_0 g1337_5 vdd 0 g1580_1 and2
X4168 g2498_2 g1174_1 vdd 0 g2839_1 nand2
X4169 g5634_1 g7187_0 vdd 0 g7210_0 nand2
X4170 g4193_0 vdd 0 g5121_1 not1
X4171 g15_1 g1295_5 vdd 0 g1532_1 and2
X4172 g545_3 g849_2 vdd 0 g1362_0 and2
X4173 g6631_1 vdd 0 g6732_0 not1
X4174 g3965_2 g3961_2 g3950_2 vdd 0 x101_1 and3
X4175 g4791_4 vdd 0 g5728_0 not1
X4176 g4732_7 vdd 0 g5566_1 not1
X4177 g621_2 vdd 0 g1030_1 not1
X4178 g4532_5 g2881_3 vdd 0 g5345_1 and2
X4179 g886_2 g2780_1 vdd 0 g3472_1 nand2
X4180 g2330_3 vdd 0 g3401_2 not1
X4181 g6255_2 vdd 0 g6463_1 not1
X4182 g967_2 g3902_1 vdd 0 g4221_1 nand2
X4183 g69_0 g1144_0 vdd 0 g1439_0 and2
X4184 g4890_2 g4887_0 g5508_0 vdd 0 g6070_1 and3
X4185 g6210_1 g6086_1 vdd 0 g6383_0 nor2
X4186 g5194_1 g4142_1 vdd 0 g5866_1 nand2
X4187 g3071_4 vdd 0 g4151_2 not1
X4188 g4642_1 g2942_0 vdd 0 g5391_0 and2
X4189 x201_1 x202_1 vdd 0 g5211_1 or2
X4190 g4863_2 vdd 0 g5707_2 not1
X4191 g3587_12 g3579_7 vdd 0 x12_1 and2
X4192 g1945_1 g6664_1 vdd 0 g6676_1 nand2
X4193 g6987_0 g6136_1 vdd 0 g7072_0 nand2
X4194 g1027_0 vdd 0 g1267_1 not1
X4195 g7116_0 g6137_0 vdd 0 g7165_0 nand2
X4196 g640_1 vdd 0 g1045_2 not1
X4197 g2829_0 g3503_0 vdd 0 g3810_4 nand2
X4198 g1423_0 g1066_1 vdd 0 g1890_1 and2
X4199 g4732_2 g4721_2 g4704_2 vdd 0 x261_1 and3
X4200 x81_1 x82_0 vdd 0 g4449_1 and2
X4201 g22_0 g1316_5 vdd 0 g1549_0 and2
X4202 g5833_1 g5457_1 vdd 0 g6045_1 nor2
X4203 g7207_0 g7176_0 vdd 0 g7222_0 nand2
X4204 g7180_2 vdd 0 g7217_0 not1
X4205 g3279_2 vdd 0 g4047_0 not1
X4206 g5496_1 g5493_0 g5502_1 vdd 0 g6068_1 and3
X4207 g3386_1 g4102_1 vdd 0 g4285_1 nand2
X4208 g40_1 g1323_3 vdd 0 g1554_0 and2
X4209 g6673_0 g6561_1 vdd 0 g7513_0 or2
X4210 g501_4 vdd 0 g849_4 not1
X4211 g4289_1 g4290_1 vdd 0 g4938_1 nand2
X4212 g934_0 vdd 0 g1172_0 not1
X4213 g3395_1 vdd 0 g4105_1 not1
X4214 g6127_2 vdd 0 g6365_1 not1
X4215 g2701_2 vdd 0 g3065_0 not1
X4216 g2374_0 vdd 0 g2780_0 not1
X4217 g1393_1 g699_3 vdd 0 g1591_1 and2
X4218 g6790_1 g5239_1 vdd 0 g6886_0 nand2
X4219 g7128_1 g7108_1 vdd 0 g7153_2 nand2
X4220 g2665_2 g3049_1 vdd 0 g3547_1 nand2
X4221 g1405_0 g721_5 vdd 0 g1628_3 and2
X4222 g6147_0 g6613_0 vdd 0 g6662_0 nand2
X4223 g204_0 vdd 0 g666_1 not1
X4224 g6423_0 g5249_0 vdd 0 g6561_0 and2
X4225 g7075_0 g7020_1 vdd 0 g7541_1 nand2
X4226 g207_2 g517_1 vdd 0 g691_0 nand2
X4227 g696_2 vdd 0 g7499_1 not1
X4228 g7360_2 vdd 0 g7385_1 not1
X4229 g2853_4 g5321_0 g5322_1 vdd 0 g5897_2 or3
X4230 g5334_1 g4598_8 g4582_12 vdd 0 x401_0 and3
X4231 g63_0 g1192_0 vdd 0 g1478_1 and2
X4232 g1018_0 vdd 0 g1264_0 not1
X4233 g2342_1 vdd 0 g3432_1 not1
X4234 g3654_7 g2008_3 g3644_8 vdd 0 g4354_1 and3
X4235 g1778_1 g1604_1 vdd 0 g2231_1 and2
X4236 g5616_1 vdd 0 g5995_1 not1
X4237 g3019_1 g5474_0 g5475_1 vdd 0 x351_0 or3
X4238 g3926_1 g4230_0 vdd 0 g4598_10 nand2
X4239 g7093_2 vdd 0 g7137_0 not1
X4240 g5942_0 g6870_1 vdd 0 g6927_1 nand2
X4241 g2624_0 vdd 0 g2998_0 not1
X4242 g1585_0 g1360_0 vdd 0 g1828_1 or2
X4243 g608_0 vdd 0 g955_1 not1
X4244 g3153_2 vdd 0 g3919_1 not1
X4245 g4960_2 g4956_1 g5546_2 vdd 0 g6088_0 and3
X4246 g1871_2 vdd 0 g2633_1 not1
X4247 g6822_1 g6744_0 vdd 0 g6867_1 nand2
X4248 g4485_3 g4474_9 vdd 0 g5322_0 and2
X4249 g3568_0 g3569_1 vdd 0 g4190_2 nand2
X4250 g2564_1 vdd 0 g2930_0 not1
X4251 g1840_0 vdd 0 g2531_0 not1
X4252 g6456_1 vdd 0 g6623_1 not1
X4253 g602_1 vdd 0 g982_0 not1
X4254 g955_2 g3894_0 vdd 0 g4217_1 nand2
X4255 g2398_2 g2798_0 vdd 0 g3483_0 nand2
X4256 g7228_2 vdd 0 g7277_1 not1
X4257 g6322_3 g6026_6 g5287_6 vdd 0 g6537_1 and3
X4258 g4598_6 vdd 0 g5668_2 not1
X4259 g3754_9 g3746_3 g2049_0 vdd 0 g4411_0 and3
X4260 g1108_1 g1121_1 vdd 0 g1408_0 or2
X4261 g6840_1 g5590_1 vdd 0 g6963_1 nand2
X4262 g6625_1 vdd 0 g6728_1 not1
X4263 g66_1 g1185_6 vdd 0 g1458_1 and2
X4264 g2334_3 vdd 0 g3426_2 not1
X4265 g4920_2 g3064_0 vdd 0 g5525_1 and2
X4266 g3374_0 g4098_1 vdd 0 g4281_1 nand2
X4267 g5799_1 g6331_1 vdd 0 g6423_3 or2
X4268 g5_2 vdd 0 g7482_1 not1
X4269 g1515_1 g1285_1 vdd 0 g1778_2 or2
X4270 g1582_1 g1357_0 vdd 0 g1816_3 or2
X4271 g2743_1 g4132_1 vdd 0 g4296_0 nand2
X4272 g6521_1 g6410_1 vdd 0 g7508_1 nand2
X4273 g2504_2 vdd 0 g2844_1 not1
X4274 g2659_1 vdd 0 g3047_1 not1
X4275 g3297_1 g6440_0 vdd 0 g6541_0 nand2
X4276 g5427_1 g6916_1 vdd 0 x522_1 or2
X4277 g4213_1 vdd 0 g5143_0 not1
X4278 g1410_1 g734_4 vdd 0 g1658_5 and2
X4279 g7127_0 g7106_0 vdd 0 g7150_1 nand2
X4280 g5697_0 vdd 0 g6038_1 not1
X4281 g1954_0 vdd 0 g2750_0 not1
X4282 g2_2 vdd 0 g403_1 not1
X4283 g6760_2 g3682_0 vdd 0 g6909_1 and2
X4284 g3828_3 g2081_4 g3817_3 vdd 0 g4436_1 and3
X4285 g3617_4 g3601_13 g1978_3 vdd 0 g4343_1 and3
X4286 g5948_1 vdd 0 g6303_1 not1
X4287 g5795_3 g6573_3 vdd 0 g6696_1 and2
X4288 g102_0 g753_5 vdd 0 g1154_1 and2
X4289 g913_2 vdd 0 g1165_0 not1
X4290 g6524_1 g6417_1 vdd 0 g6563_0 nand2
X4291 g3768_13 g2055_4 vdd 0 g4421_0 and2
X4292 g5649_2 vdd 0 g6010_1 not1
X4293 g1961_3 g4336_1 g4337_1 g4338_1 vdd 0 g5197_2 nor4
X4294 g3644_9 g3675_6 g3654_10 vdd 0 x31_1 and3
X4295 g2182_0 vdd 0 g3318_1 not1
X4296 g5287_1 g5258_0 vdd 0 x452_0 and2
X4297 g4732_1 g2989_1 vdd 0 g5430_1 and2
X4298 x511_1 x512_1 vdd 0 g6916_0 and2
X4299 g8_2 g1212_3 vdd 0 g1498_0 and2
X4300 g7382_1 vdd 0 g7394_1 not1
X4301 g5871_2 vdd 0 g6243_1 not1
X4302 g3207_1 vdd 0 g3986_0 not1
X4303 g2468_1 vdd 0 g2824_1 not1
X4304 g7051_1 g5608_1 vdd 0 g7102_1 nand2
X4305 g1009_2 g4010_1 vdd 0 g4246_1 nand2
X4306 g3914_0 g4224_0 vdd 0 g4532_0 nand2
X4307 g59_0 g1269_1 vdd 0 g1512_0 and2
X4308 g4262_0 g4263_0 vdd 0 g4775_0 nand2
X4309 g4277_0 g4083_1 vdd 0 g4893_0 nand2
X4310 g621_5 g2175_6 vdd 0 g2989_5 and2
X4311 g2719_2 g3082_1 vdd 0 g3558_1 nand2
X4312 g1744_0 vdd 0 g2353_1 not1
X4313 g2406_0 vdd 0 g2799_0 not1
X4314 g6715_1 vdd 0 g6827_1 not1
X4315 g6516_1 g7033_4 vdd 0 g7086_1 and2
X4316 g6163_1 g5985_1 vdd 0 g6332_1 nand2
X4317 g4_0 g3_0 vdd 0 g446_0 nand2
X4318 g2070_0 g4432_0 g4433_0 g4434_0 vdd 0 g5177_0 or4
X4319 g1039_1 g4055_1 vdd 0 g4266_0 nand2
X4320 g89_0 g716_1 vdd 0 g1100_0 and2
X4321 g6942_2 g6399_0 vdd 0 g7016_1 and2
X4322 g3246_0 g4040_0 vdd 0 g4256_1 nand2
X4323 g2819_1 g3498_0 vdd 0 g3754_3 nand2
X4324 x391_1 x392_1 vdd 0 g5989_1 and2
X4325 g5074_2 vdd 0 g5605_0 not1
X4326 g7306_2 g6176_1 g792_0 vdd 0 g7350_1 and3
X4327 g3803_1 g3768_6 g3784_5 vdd 0 g4423_0 and3
X4328 g1816_1 vdd 0 g2567_1 not1
X4329 g1920_1 g1535_1 vdd 0 g2264_4 or2
X4330 g133_1 g805_6 vdd 0 g1250_1 and2
X4331 g6366_0 g6529_0 g6530_0 vdd 0 g6568_0 or3
X4332 g1529_0 g1304_0 vdd 0 g1803_1 or2
X4333 g1816_0 vdd 0 g2710_0 not1
X4334 g5197_1 g6720_0 vdd 0 g6815_1 nand2
X4335 g5740_2 g7332_1 vdd 0 g7340_1 nand2
X4336 g5381_2 g5388_2 vdd 0 g6016_6 and2
X4337 g1616_3 vdd 0 g2564_2 not1
X4338 g5628_0 g6974_0 vdd 0 g7009_0 nand2
X4339 g4052_0 g4265_0 vdd 0 g4791_5 nand2
X4340 g3180_2 g2937_0 vdd 0 g3975_1 nand2
X4341 g6294_1 g6648_0 vdd 0 g6668_1 nand2
X4342 g5970_0 g5969_1 vdd 0 g6237_2 nand2
X4343 g7169_0 g7140_0 vdd 0 g7180_0 nand2
X4344 g3336_0 vdd 0 g4070_0 not1
X4345 g7414_0 vdd 0 g7425_0 not1
X4346 g5637_0 g7263_0 vdd 0 g7290_1 nand2
X4347 g985_0 vdd 0 g1235_1 not1
X4348 g7082_0 g7064_1 vdd 0 g7109_2 nand2
X4349 g6926_0 g6863_1 vdd 0 g6980_1 nand2
X4350 g2342_3 vdd 0 g3368_2 not1
X4351 g4539_7 vdd 0 g5637_1 not1
X4352 g2435_0 g2809_0 vdd 0 g3492_0 nand2
X4353 g7004_1 vdd 0 g7079_0 not1
X4354 g1936_0 g1575_0 vdd 0 g2322_0 or2
X4355 g7210_1 g7188_1 vdd 0 g7231_0 nand2
X4356 g6765_1 g6152_0 vdd 0 g6881_1 and2
X4357 g6925_1 g6846_0 vdd 0 g6967_1 nand2
X4358 g2141_2 vdd 0 g3285_0 not1
X4359 g10_2 g835_0 vdd 0 g1304_1 and2
X4360 g7158_0 vdd 0 g7196_1 not1
X4361 g3294_2 vdd 0 g4177_1 not1
X4362 g7002_1 g6961_1 vdd 0 g7038_2 nand2
X4363 g3803_6 vdd 0 g5083_2 not1
X4364 g141_1 g1468_4 vdd 0 g1907_1 and2
X4365 g3288_2 g4174_1 vdd 0 g4307_0 nand2
X4366 g4238_1 g4239_0 vdd 0 g4653_0 nand2
X4367 g2188_0 vdd 0 g3231_1 not1
X4368 g3126_0 g1226_0 vdd 0 g3895_1 nand2
X4369 g772_3 vdd 0 g1212_6 not1
X4370 g4598_11 g4582_14 g3928_5 g4568_10 vdd 0 g5360_1 and4
X4371 g418_3 vdd 0 g901_2 not1
X4372 g185_2 vdd 0 g560_1 not1
X4373 g5223_2 g5295_1 vdd 0 g5788_1 nand2
X4374 g3377_1 vdd 0 g4098_0 not1
X4375 g5716_1 vdd 0 g6052_1 not1
X4376 g3828_9 vdd 0 g5110_2 not1
X4377 g6793_0 vdd 0 g6887_0 not1
X4378 g1799_0 vdd 0 g2650_0 not1
X4379 g3147_0 vdd 0 g3915_0 not1
X4380 g1770_0 vdd 0 g2606_0 not1
X4381 g4498_2 g2870_1 vdd 0 g5328_0 and2
X4382 g683_2 vdd 0 g1070_1 not1
X4383 g3228_1 g1265_1 vdd 0 g4017_1 nand2
X4384 g2153_5 vdd 0 g3147_2 not1
X4385 g6590_1 g3675_1 g3654_3 vdd 0 x471_0 and3
X4386 x131_0 x132_1 vdd 0 g5156_1 or2
X4387 g3333_0 vdd 0 g4068_1 not1
X4388 g5104_2 vdd 0 g5297_0 not1
X4389 g2089_2 g4450_1 g4451_1 vdd 0 x491_1 or3
X4390 g2689_2 vdd 0 g3365_1 not1
X4391 g4443_0 g6597_3 vdd 0 g6695_0 and2
X4392 g2519_2 vdd 0 g2915_0 not1
X4393 g6502_0 g6382_0 vdd 0 g6614_0 nand2
X4394 g985_2 g3921_0 vdd 0 g4227_0 nand2
X4395 g6315_0 g6401_1 vdd 0 g7501_0 nand2
X4396 g4003_1 g3999_3 g3988_2 vdd 0 x121_1 and3
X4397 g4802_1 g3013_5 vdd 0 g5470_1 and2
X4398 g3784_6 vdd 0 g5068_2 not1
X4399 g1900_0 g1461_1 vdd 0 g2153_2 or2
X4400 g2215_3 vdd 0 g3135_2 not1
X4401 g1390_2 vdd 0 g1674_1 not1
X4402 g5610_1 vdd 0 g5993_1 not1
X4403 g5012_2 vdd 0 g5586_1 not1
X4404 g4062_1 g4270_1 vdd 0 g4850_12 nand2
X4405 g4463_0 g2853_1 vdd 0 g5316_0 and2
X4406 g2353_0 vdd 0 g2772_0 not1
X4407 g6787_1 vdd 0 g7515_0 not1
X4408 g1246_3 g1256_1 vdd 0 g1507_1 or2
X4409 g130_1 g1206_5 vdd 0 g1493_1 and2
X4410 g2615_0 g2955_1 vdd 0 g3538_1 nand2
X4411 g146_0 g1521_1 vdd 0 g1918_0 and2
X4412 g2330_0 g2111_2 vdd 0 g3061_1 and2
X4413 g470_1 vdd 0 g7492_0 not1
X4414 g640_3 vdd 0 g1021_1 not1
X4415 g5188_2 vdd 0 g5859_1 not1
X4416 g3897_1 g4219_1 vdd 0 g4485_5 nand2
X4417 g6666_0 g6624_0 vdd 0 g6725_0 nand2
X4418 g3030_1 g5490_1 vdd 0 g5843_1 or2
X4419 g3718_3 vdd 0 g5047_2 not1
X4420 g1045_2 vdd 0 g1311_0 not1
X4421 x401_1 x402_1 vdd 0 g6002_3 and2
X4422 g4560_3 vdd 0 g5655_1 not1
X4423 g2698_2 vdd 0 g3063_1 not1
X4424 g35_0 g1330_5 vdd 0 g1575_1 and2
X4425 g118_0 g1462_4 vdd 0 g1905_1 and2
X4426 g6356_0 g6188_1 vdd 0 g6438_1 nand2
X4427 g2743_1 vdd 0 g3085_1 not1
X4428 g958_2 g3896_0 vdd 0 g4218_0 nand2
X4429 g3123_1 g1225_0 vdd 0 g3893_0 nand2
X4430 g4973_0 g6825_0 vdd 0 g6880_1 nand2
X4431 g4309_0 g4310_0 vdd 0 g5128_2 nand2
X4432 g7296_1 g7276_1 vdd 0 g7321_1 nand2
X4433 g2368_2 vdd 0 g3094_1 not1
X4434 g5909_1 vdd 0 g6272_0 not1
X4435 g1871_0 g2634_1 vdd 0 g2766_1 nand2
X4436 g628_3 g1537_2 vdd 0 g1924_1 and2
X4437 g6670_0 g6558_1 vdd 0 g7510_0 or2
X4438 g7177_2 vdd 0 g7215_1 not1
X4439 g4183_2 g6298_1 vdd 0 g6397_1 nand2
X4440 g3120_2 vdd 0 g3892_1 not1
X4441 g5779_1 g5274_0 vdd 0 g5972_0 nor2
X4442 g6793_1 g5240_1 vdd 0 g6888_1 nand2
X4443 g6127_2 g6607_0 vdd 0 g6660_1 nand2
X4444 g4598_9 g4582_13 g3928_1 vdd 0 g5365_1 and3
X4445 g1632_1 vdd 0 g2495_1 not1
X4446 g195_0 vdd 0 g7472_1 not1
X4447 g6039_0 g6194_0 vdd 0 g6314_0 nand2
X4448 g3213_1 g1260_1 vdd 0 g4007_0 nand2
X4449 g2096_3 g4455_1 g6693_0 vdd 0 g6796_1 or3
X4450 g3162_2 vdd 0 g3925_1 not1
X4451 g5205_1 vdd 0 g5878_1 not1
X4452 g3207_2 g3987_1 vdd 0 g4244_1 nand2
X4453 g621_4 g2175_4 vdd 0 g3037_7 and2
X4454 g5688_1 vdd 0 g6034_1 not1
X4455 g1192_5 vdd 0 g1462_5 not1
X4456 g5664_2 vdd 0 g6012_1 not1
X4457 g95_1 g753_6 vdd 0 g1151_1 and2
X4458 g6942_1 g5248_1 vdd 0 g7018_0 and2
X4459 g6668_0 g6649_0 vdd 0 g6745_1 nand2
X4460 g2264_1 vdd 0 g3267_0 not1
X4461 g5147_2 vdd 0 g5767_1 not1
X4462 g937_2 g2838_1 vdd 0 g3507_1 nand2
X4463 g4519_5 g4508_3 g4491_5 vdd 0 x211_1 and3
X4464 g1057_0 g4067_0 vdd 0 g4272_1 nand2
X4465 g2284_0 vdd 0 g3441_2 not1
X4466 g582_1 g2215_0 vdd 0 g2867_0 and2
X4467 g982_1 g3919_0 vdd 0 g4226_0 nand2
X4468 g6284_1 g4178_1 vdd 0 g6488_1 nand2
X4469 g182_2 vdd 0 g7459_1 not1
X4470 g5554_2 vdd 0 g5958_1 not1
X4471 g7428_0 g7402_0 vdd 0 g7438_0 nand2
X4472 g5631_1 g7103_0 vdd 0 g7126_0 nand2
X4473 g3450_2 g4136_0 vdd 0 g4299_0 nand2
X4474 g2264_2 vdd 0 g3216_2 not1
X4475 g1954_1 g2793_1 vdd 0 g3479_1 nand2
X4476 g7292_0 g7268_0 vdd 0 g7309_0 nand2
X4477 g4026_1 vdd 0 g4750_2 not1
X4478 g4161_2 vdd 0 g5113_1 not1
X4479 g2292_1 g1795_2 vdd 0 g2941_0 and2
X4480 g6856_1 g6106_0 vdd 0 g6977_1 nand2
X4481 g4078_2 g4074_2 g5505_1 vdd 0 g6069_1 and3
X4482 g6023_2 g6151_0 g6510_1 vdd 0 x551_1 or3
X4483 g206_0 g6336_0 g6056_0 g5280_0 vdd 0 g6528_0 and4
X4484 g4240_0 g4241_0 vdd 0 g4657_0 nand2
X4485 g1716_0 vdd 0 g2659_0 not1
X4486 g3273_2 vdd 0 g4045_0 not1
X4487 g3003_1 g5462_1 g5463_0 g5464_1 vdd 0 g5835_1 or4
X4488 g4676_4 g4669_6 g2963_5 vdd 0 g5408_1 and3
X4489 g2013_5 g3644_2 vdd 0 x42_1 and2
X4490 g594_1 vdd 0 g961_1 not1
X4491 g2409_0 g2802_0 vdd 0 g3486_1 nand2
X4492 g6935_0 g6895_1 vdd 0 g7526_1 nand2
X4493 g6475_2 g6014_1 vdd 0 g6585_1 nand2
X4494 g5569_1 vdd 0 g5963_1 not1
X4495 g2163_2 vdd 0 g3339_1 not1
X4496 g982_2 vdd 0 g1234_0 not1
X4497 g4568_8 vdd 0 g5664_1 not1
X4498 g6377_2 g6016_3 g5370_6 vdd 0 g6535_1 and3
X4499 g1620_2 vdd 0 g2686_2 not1
X4500 g1092_3 g1100_1 vdd 0 g1399_1 or2
X4501 g943_2 g2842_1 vdd 0 g3509_1 nand2
X4502 g1596_0 vdd 0 g2412_0 not1
X4503 g153_0 g1484_0 vdd 0 g1912_0 and2
X4504 g2456_2 g1162_0 vdd 0 g2815_1 nand2
X4505 g2896_1 g5354_1 g5355_0 vdd 0 x321_0 or3
X4506 g4380_1 vdd 0 g5264_1 not1
X4507 g2334_0 g2115_2 vdd 0 g3060_0 and2
X4508 g1108_2 g1119_1 vdd 0 g1406_1 or2
X4509 g2362_2 g6387_1 vdd 0 g6447_0 nand2
X4510 g2383_0 g1136_1 vdd 0 g2785_1 nand2
X4511 g5191_2 g6718_1 vdd 0 g6814_1 nand2
X4512 g3186_2 g3979_1 vdd 0 g4237_1 nand2
X4513 g614_1 g1565_4 vdd 0 g1941_1 and2
X4514 g6373_1 g6372_1 vdd 0 g6478_2 nand2
X4515 g2159_1 vdd 0 g3333_2 not1
X4516 g7119_2 vdd 0 g7166_1 not1
X4517 g2127_5 vdd 0 g3279_2 not1
X4518 g5393_0 g5394_0 vdd 0 x332_0 or2
X4519 g3174_1 vdd 0 g3970_0 not1
X4520 g1948_0 vdd 0 g2747_1 not1
X4521 g1928_0 g1555_0 vdd 0 g2296_0 or2
X4522 g1894_0 g1455_0 vdd 0 g2119_2 or2
X4523 g5370_2 g5395_3 vdd 0 x442_1 and2
X4524 g913_1 g2822_1 vdd 0 g3499_1 nand2
X4525 g6_1 vdd 0 g494_1 not1
X4526 g7134_0 vdd 0 g7175_1 not1
X4527 g5894_0 g5994_0 vdd 0 g6168_1 nand2
X4528 x331_0 x332_1 vdd 0 g5824_1 or2
X4529 g3462_1 g4208_1 vdd 0 g4321_0 nand2
X4530 g3725_9 g2033_4 vdd 0 g4401_1 and2
X4531 g196_2 vdd 0 g620_1 not1
X4532 g413_4 vdd 0 g907_2 not1
X4533 g6421_1 vdd 0 g6517_0 not1
X4534 g2230_0 g4665_0 g4666_0 vdd 0 x181_0 or3
X4535 x51_0 x52_1 vdd 0 g4407_1 and2
X4536 g3512_0 g3513_0 vdd 0 g3938_0 nand2
X4537 g4850_2 g4834_1 g3037_1 vdd 0 g5486_1 and3
X4538 g5515_3 vdd 0 g6073_1 not1
X4539 g206_7 g5302_0 g4508_5 vdd 0 x391_0 and3
X4540 g4151_0 vdd 0 g4530_0 not1
X4541 g925_2 vdd 0 g1169_1 not1
X4542 g464_0 g1738_0 vdd 0 g1971_1 and2
X4543 g2221_1 g4622_0 g4623_0 g4624_0 vdd 0 g5183_1 or4
X4544 g3550_1 g3551_1 vdd 0 g4088_1 nand2
X4545 g4058_0 g4268_1 vdd 0 g4820_11 nand2
X4546 g7372_1 g7349_0 vdd 0 g7384_1 nand2
X4547 g159_1 g1446_3 vdd 0 g1896_0 and2
X4548 g519_3 g1691_3 vdd 0 g2480_2 nor2
X4549 g1024_1 vdd 0 g1266_1 not1
X4550 g7438_1 g7440_1 vdd 0 g7443_1 nand2
X4551 g4508_6 vdd 0 g5575_0 not1
X4552 g5128_1 vdd 0 g5705_0 not1
X4553 g2901_2 g5364_0 g5365_0 g6007_0 vdd 0 g6263_1 or4
X4554 g1727_2 vdd 0 g2668_0 not1
X4555 g6995_1 g6882_1 vdd 0 g7533_0 or2
X4556 g2615_1 vdd 0 g2956_1 not1
X4557 g4084_2 vdd 0 g4896_2 not1
X4558 g1832_3 g1612_3 vdd 0 g2225_1 and2
X4559 g895_0 g2788_1 vdd 0 g3476_1 nand2
X4560 g4687_2 g2969_3 g4676_2 vdd 0 g5411_0 and3
X4561 g7336_1 vdd 0 g7373_1 not1
X4562 g3579_6 g1961_2 vdd 0 g4328_1 and2
X4563 g4764_1 vdd 0 g5448_2 not1
X4564 g6942_0 vdd 0 g7033_0 not1
X4565 g1372_2 vdd 0 g1509_0 not1
X4566 g6195_0 g6047_0 vdd 0 g6360_0 nor2
X4567 g4884_2 vdd 0 g5502_2 not1
X4568 g3784_7 g3768_7 g2062_5 g3754_10 vdd 0 g4416_1 and4
X4569 g2175_3 vdd 0 g3243_2 not1
X4570 g4117_0 vdd 0 g4943_0 not1
X4571 g3784_11 g3768_12 g3746_4 vdd 0 x61_1 and3
X4572 g1366_1 vdd 0 g1421_1 not1
X4573 g1792_2 vdd 0 g2707_2 not1
X4574 g3417_0 g4128_0 vdd 0 g4292_0 nand2
X4575 g3090_0 vdd 0 g4140_1 not1
X4576 g2444_0 vdd 0 g3101_1 not1
X4577 g2647_0 g3346_0 vdd 0 g3567_0 nand2
X4578 g922_2 g2828_1 vdd 0 g3502_0 nand2
X4579 g2432_0 g2810_1 vdd 0 g3493_1 nand2
X4580 g3617_2 vdd 0 g5030_0 not1
X4581 g4760_3 vdd 0 g5434_2 not1
X4582 g2304_3 g1807_1 vdd 0 g2936_0 and2
X4583 g6274_2 g6640_0 vdd 0 g6667_0 nand2
X4584 g442_0 vdd 0 g712_0 not1
X4585 g6814_0 g6719_1 vdd 0 g6837_0 nand2
X4586 x71_1 x72_0 vdd 0 g4443_2 and2
X4587 g168_2 vdd 0 g456_0 not1
X4588 g5302_2 vdd 0 g6090_0 not1
X4589 g3435_1 g4204_0 vdd 0 g4317_0 nand2
X4590 g1912_1 g1496_0 vdd 0 g2200_2 or2
X4591 g1756_4 vdd 0 g2347_2 not1
X4592 g4011_1 g4247_1 vdd 0 g4687_4 nand2
X4593 g26_0 g1323_1 vdd 0 g1558_0 and2
X4594 g2163_3 vdd 0 g3201_0 not1
X4595 g3768_10 vdd 0 g5074_0 not1
X4596 g5758_2 vdd 0 g6140_0 not1
X4597 g5053_2 vdd 0 g5599_1 not1
X4598 g174_3 vdd 0 g486_1 not1
X4599 g7336_2 g7426_1 vdd 0 g7431_1 nand2
X4600 g1704_0 vdd 0 g2465_2 not1
X4601 g7234_0 vdd 0 g7265_1 not1
X4602 g485_0 g828_3 vdd 0 g1287_0 and2
X4603 g3479_0 g2794_1 vdd 0 g3683_3 nand2
X4604 g4213_1 g5142_1 vdd 0 g5236_1 nand2
X4605 g6590_6 g3675_5 vdd 0 g6685_1 and2
X4606 g5881_2 g6459_1 vdd 0 g6551_1 nand2
X4607 g4235_1 g3977_1 vdd 0 g4642_5 nand2
X4608 g2000_1 g4349_0 g4350_0 vdd 0 x141_0 or3
X4609 g7441_0 g7444_0 vdd 0 g7445_0 nand2
X4610 g2167_3 vdd 0 g3195_1 not1
X4611 g6696_0 g6579_0 vdd 0 g6771_1 or2
X4612 g6206_0 g6070_0 vdd 0 g6373_0 nor2
X4613 g7172_1 g7167_0 vdd 0 g7203_0 nand2
X4614 g5945_0 g5135_0 vdd 0 g6299_0 nand2
X4615 g3371_0 vdd 0 g4096_0 not1
X4616 g5655_0 vdd 0 g6113_1 not1
X4617 g3736_3 g2038_2 g3725_2 vdd 0 g4402_1 and3
X4618 g1691_2 vdd 0 g2507_2 not1
X4619 g1782_2 g1608_2 vdd 0 g2230_1 and2
X4620 g5816_2 g5395_1 vdd 0 g6150_1 and2
X4621 g116_1 g1289_3 vdd 0 g1528_1 and2
X4622 g6760_0 g1999_0 vdd 0 g6910_1 and2
X4623 g1942_0 vdd 0 g2759_1 not1
X4624 g5139_0 g5683_0 vdd 0 g5915_0 nand2
X4625 g1652_1 vdd 0 g2447_1 not1
X4626 g660_3 vdd 0 g1012_2 not1
X4627 g602_3 g1565_3 vdd 0 g1939_1 and2
X4628 g3883_5 vdd 0 g4973_2 not1
X4629 g6811_2 g5247_1 vdd 0 g6901_1 nand2
X4630 g2543_2 g2924_1 vdd 0 g3521_1 nand2
X4631 g2528_0 g2917_0 vdd 0 g3514_0 nand2
X4632 g48_1 g1275_2 vdd 0 g1516_1 and2
X4633 g4143_0 vdd 0 g5039_1 not1
X4634 g6817_1 g6731_1 vdd 0 g6850_2 nand2
X4635 g6220_2 g5965_1 vdd 0 g6410_0 nand2
X4636 g3526_0 g3527_0 vdd 0 g3968_0 nand2
X4637 g582_0 vdd 0 g967_0 not1
X4638 g7027_1 vdd 0 g7537_1 not1
X4639 g4611_5 vdd 0 g5628_1 not1
X4640 g137_1 g816_3 vdd 0 g1254_1 and2
X4641 g7147_1 g6105_1 vdd 0 g7188_1 nand2
X4642 g3702_2 vdd 0 g4386_2 not1
X4643 g6751_2 vdd 0 g6878_1 not1
X4644 g553_1 g1646_2 vdd 0 g2033_2 and2
X4645 g3601_2 g1971_5 vdd 0 g4339_1 and2
X4646 g3306_1 g1309_0 vdd 0 g4054_0 nand2
X4647 g73_0 g1144_1 vdd 0 g1436_1 and2
X4648 g1986_1 g4324_0 vdd 0 g5253_2 and2
X4649 g1862_1 g2421_0 vdd 0 g2763_1 nand2
X4650 g2591_2 g2947_1 vdd 0 g3530_0 nand2
X4651 g576_2 g1559_3 vdd 0 g1935_1 and2
X4652 g6700_1 g2752_2 vdd 0 g6824_1 and2
X4653 g45_1 g1344_5 vdd 0 g1585_1 and2
X4654 g5677_0 g6436_0 vdd 0 g6531_0 nand2
X4655 g3994_0 g3988_0 vdd 0 x112_1 and2
X4656 g6181_1 g6015_0 vdd 0 g6308_1 nand2
X4657 g777_1 vdd 0 g1192_5 not1
X4658 g5625_2 vdd 0 g6000_0 not1
X4659 g188_1 vdd 0 g570_5 not1
X4660 g1003_2 g1509_1 vdd 0 g1765_1 nand2
X4661 g3562_0 g3563_0 vdd 0 g4146_0 nand2
X4662 g1670_0 g6905_2 vdd 0 g7001_0 and2
X4663 g6748_2 g6303_1 vdd 0 g6873_1 nand2
X4664 g5065_1 vdd 0 g5602_1 not1
X4665 g1865_2 g2805_1 vdd 0 g3489_1 nand2
X4666 g3198_1 g3983_1 vdd 0 g4241_1 nand2
X4667 g519_5 g842_6 vdd 0 g1357_1 and2
X4668 g2235_3 vdd 0 g2957_1 not1
X4669 g169_0 vdd 0 g7483_0 not1
X4670 g7293_0 g7270_0 vdd 0 g7312_0 nand2
X4671 g5047_0 g7137_1 vdd 0 g7168_0 nand2
X4672 g5813_1 vdd 0 g6274_0 not1
X4673 g3285_1 g4175_0 vdd 0 g4308_1 nand2
X4674 g3285_2 vdd 0 g4174_1 not1
X4675 g126_0 g1440_4 vdd 0 g1893_1 and2
X4676 g4088_2 g4084_1 g4902_0 vdd 0 g5513_1 and3
X4677 g4498_4 g5302_6 g4508_1 vdd 0 x381_1 and3
X4678 g4113_3 g4943_1 g5539_1 vdd 0 g5856_1 and3
X4679 g4255_0 g4256_0 vdd 0 g4760_0 nand2
X4680 g4834_6 g3030_2 g4820_8 vdd 0 g5483_1 and3
X4681 g3943_1 g3938_2 g2223_1 vdd 0 g4623_1 and3
X4682 g6466_1 g6554_1 vdd 0 g6634_2 nand2
X4683 g561_3 vdd 0 g792_1 not1
X4684 g5370_4 g5395_6 vdd 0 x432_1 and2
X4685 g4117_2 g4113_1 g4967_1 vdd 0 g5552_1 and3
X4686 g7038_1 vdd 0 g7089_1 not1
X4687 g4395_2 g5170_3 vdd 0 g5783_1 and2
X4688 g1750_5 vdd 0 g2401_2 not1
X4689 g7281_0 g6115_0 vdd 0 g7331_1 nand2
X4690 g7080_0 g7045_0 vdd 0 g7093_1 nand2
X4691 g3691_0 vdd 0 g4377_0 not1
X4692 g3601_10 g1971_0 g3587_0 vdd 0 g4333_0 and3
X4693 g1076_2 vdd 0 g1381_1 not1
X4694 g6799_2 vdd 0 g6891_1 not1
X4695 g2029_0 g4401_0 g4402_0 g4403_0 vdd 0 g5202_0 or4
X4696 g6938_1 g6901_0 vdd 0 g7529_0 nand2
X4697 g2522_0 g2915_1 vdd 0 g3512_1 nand2
X4698 g4850_10 vdd 0 g5752_1 not1
X4699 g2441_2 g3099_0 vdd 0 g3562_1 nand2
X4700 g678_2 vdd 0 g695_0 not1
X4701 g3150_1 g1233_1 vdd 0 g3916_1 nand2
X4702 g1934_1 g1573_1 vdd 0 g2314_2 or2
X4703 g2668_2 g4082_1 vdd 0 g4277_1 nand2
X4704 g3183_0 g2940_1 vdd 0 g3977_0 nand2
X4705 g1390_0 g2749_0 vdd 0 g2792_0 nand2
X4706 g121_0 g1462_0 vdd 0 g1901_0 and2
X4707 g5068_1 g7099_0 vdd 0 g7124_0 nand2
X4708 g7206_1 g7174_1 vdd 0 g7219_2 nand2
X4709 g5062_2 g7217_1 vdd 0 g7253_0 nand2
X4710 g7085_1 g7015_0 vdd 0 g7545_1 or2
X4711 g5505_1 vdd 0 g6065_1 not1
X4712 g50_1 g1199_4 vdd 0 g1482_1 and2
X4713 g3968_1 g3947_2 g3943_2 g3938_3 vdd 0 g4619_1 and4
X4714 g1917_0 g1532_0 vdd 0 g2244_3 or2
X4715 g4791_8 g4784_5 g3008_2 vdd 0 g5463_1 and3
X4716 g6144_1 vdd 0 g6381_1 not1
X4717 g6951_2 vdd 0 g7021_1 not1
X4718 g6940_0 g6941_1 g6903_0 g6904_0 vdd 0 g7004_1 or4
X4719 g6423_1 g6402_0 vdd 0 g6558_0 and2
X4720 g952_1 vdd 0 g1224_1 not1
X4721 g5931_1 g5932_1 vdd 0 g6127_1 nand2
X4722 g5677_2 vdd 0 g6013_0 not1
X4723 g4648_3 g4642_3 vdd 0 x232_1 and2
X4724 g3279_1 g4048_1 vdd 0 g4263_1 nand2
X4725 g7222_2 g5589_1 vdd 0 g7274_1 nand2
X4726 x461_0 x462_0 vdd 0 g6514_1 and2
X4727 g1965_1 g4339_0 g4340_0 g4341_0 vdd 0 g5188_2 or4
X4728 g7327_0 g6114_1 vdd 0 g7359_1 nand2
X4729 x281_1 x282_1 vdd 0 g5477_1 and2
X4730 g1015_2 vdd 0 g1263_0 not1
X4731 g479_4 g1756_2 vdd 0 g1960_1 and2
X4732 g3401_1 g4110_1 vdd 0 g4290_0 nand2
X4733 g198_2 vdd 0 g628_5 not1
X4734 g7321_0 g5278_0 vdd 0 g7347_0 nand2
X4735 g2567_0 vdd 0 g2931_1 not1
X4736 g2371_1 g5859_0 vdd 0 g6099_1 nand2
X4737 g5050_0 vdd 0 g5276_1 not1
X4738 g2549_2 vdd 0 g2925_0 not1
X4739 g7423_1 g7431_0 vdd 0 g7436_0 nand2
X4740 g3694_0 g4368_2 g5266_0 vdd 0 g5777_0 and3
X4741 g7257_1 g6420_1 g6568_2 vdd 0 g7302_1 and3
X4742 g6820_1 g6737_1 vdd 0 g6859_2 nand2
X4743 g5095_0 vdd 0 g5294_0 not1
X4744 g4362_1 g4359_0 g4380_0 vdd 0 g5270_1 and3
X4745 g3601_4 g1971_2 vdd 0 g4342_1 and2
X4746 g10_0 g1295_1 vdd 0 g1534_0 and2
X4747 g457_1 g1731_3 vdd 0 g1978_1 and2
X4748 g2258_3 vdd 0 g3219_1 not1
X4749 g394_1 g400_1 vdd 0 g681_1 and2
X4750 x271_1 x272_0 vdd 0 g5471_1 and2
X4751 g6645_2 vdd 0 g6743_1 not1
X4752 g5880_0 g6101_0 vdd 0 g6247_0 nand2
X4753 g413_0 vdd 0 g937_0 not1
X4754 g4956_0 g5535_0 g6083_1 vdd 0 g6213_1 and3
X4755 g3797_3 g3736_4 vdd 0 g4427_1 and2
X4756 g1816_2 g1675_3 vdd 0 g2229_1 and2
X4757 g5214_2 vdd 0 g5885_1 not1
X4758 g2101_5 g3852_4 vdd 0 x82_1 and2
X4759 g1832_0 vdd 0 g2537_0 not1
X4760 g4519_7 g3907_1 vdd 0 g5333_0 and2
X4761 g1820_1 vdd 0 g2555_1 not1
X4762 g1744_3 vdd 0 g2380_1 not1
X4763 g532_0 g1704_2 vdd 0 g2049_1 and2
X4764 g3192_0 vdd 0 g3980_1 not1
X4765 g1844_2 vdd 0 g2734_1 not1
X4766 g2579_1 vdd 0 g2937_1 not1
X4767 g889_1 vdd 0 g1135_1 not1
X4768 g2062_7 vdd 0 g3114_2 not1
X4769 g418_4 g1652_5 vdd 0 g2029_3 and2
X4770 g1766_3 g1592_3 vdd 0 g2234_1 and2
X4771 g2638_0 g4043_0 vdd 0 g4259_0 nand2
X4772 g3407_0 vdd 0 g4112_1 not1
X4773 g4389_1 vdd 0 g5267_1 not1
X4774 g3004_3 g5468_0 g5469_1 vdd 0 g5936_1 nor3
X4775 g7011_0 g6979_0 vdd 0 g7060_2 nand2
X4776 g2300_3 vdd 0 g3453_2 not1
X4777 g1_3 vdd 0 g404_2 not1
X4778 g4154_2 g6000_1 vdd 0 g6174_1 nand2
X4779 g2874_3 g4508_2 vdd 0 g5331_1 and2
X4780 g86_0 g96_1 g112_0 g123_1 vdd 0 g391_2 and4
X4781 g79_0 g740_0 vdd 0 g1121_0 and2
X4782 g184_2 vdd 0 g418_0 not1
X4783 g2734_1 vdd 0 g3413_1 not1
X4784 g621_1 g2175_1 vdd 0 g3330_1 nor2
X4785 g4190_1 vdd 0 g5120_0 not1
X4786 g49_3 g6075_1 g6016_1 vdd 0 x431_1 and3
X4787 g6269_2 g6978_1 vdd 0 g7011_1 nand2
X4788 g93_1 g705_6 vdd 0 g1096_1 and2
X4789 g64_2 g1178_5 vdd 0 g1455_1 and2
X4790 g3891_0 g4216_0 vdd 0 g4456_0 nand2
X4791 g3321_0 g1314_0 vdd 0 g4064_0 nand2
X4792 g2495_2 g1173_1 vdd 0 g2837_0 nand2
X4793 g5746_1 vdd 0 g6055_0 not1
X4794 g3817_4 g3810_6 g2075_3 vdd 0 g4433_1 and3
X4795 g5920_2 vdd 0 g6187_1 not1
X4796 g2215_5 vdd 0 g3159_2 not1
X4797 g2292_0 vdd 0 g3183_1 not1
X4798 g70_0 g1138_3 vdd 0 g1432_0 and2
X4799 g1423_1 vdd 0 g1948_2 not1
X4800 g3441_2 vdd 0 g4134_1 not1
X4801 g6805_2 vdd 0 g6896_1 not1
X4802 g6475_2 vdd 0 g6584_1 not1
X4803 g602_5 g2141_5 vdd 0 g2885_4 and2
X4804 g3240_0 g6038_1 vdd 0 g6193_0 nand2
X4805 g2674_0 g3055_0 vdd 0 g3551_0 nand2
X4806 g6490_0 g6557_0 vdd 0 g6645_0 nand2
X4807 g4092_0 vdd 0 g4905_0 not1
X4808 g2115_1 vdd 0 g3383_2 not1
X4809 g3566_1 g3567_1 vdd 0 g4193_1 nand2
X4810 g4657_2 g4653_3 g4642_2 vdd 0 x241_0 and3
X4811 g1727_1 vdd 0 g2698_0 not1
X4812 g1589_0 g1364_0 vdd 0 g1844_3 or2
X4813 g1000_1 vdd 0 g1257_1 not1
X4814 g3349_1 vdd 0 g4082_0 not1
X4815 g901_0 g2814_0 vdd 0 g3495_0 nand2
X4816 g621_1 vdd 0 g1057_1 not1
X4817 g5431_1 g4760_2 g6041_0 vdd 0 g6195_1 and3
X4818 g6837_2 vdd 0 g6960_1 not1
X4819 g1978_7 g3587_13 vdd 0 x22_1 and2
X4820 g101_1 g727_6 vdd 0 g1114_1 and2
X4821 g5848_0 vdd 0 g6207_0 not1
X4822 g1646_0 vdd 0 g2456_1 not1
X4823 g7193_0 vdd 0 g7240_1 not1
X4824 g570_1 vdd 0 g994_1 not1
X4825 g5867_2 vdd 0 g6233_1 not1
X4826 g4802_4 vdd 0 g5722_2 not1
X4827 g5044_0 g7044_1 vdd 0 g7080_1 nand2
X4828 g6213_0 g6089_0 vdd 0 g6386_1 nor2
X4829 g1027_2 g4022_1 vdd 0 g4252_0 nand2
X4830 g3489_0 g2806_0 vdd 0 g3705_1 nand2
X4831 g5226_1 vdd 0 g5789_1 not1
X4832 g4676_9 vdd 0 g5691_2 not1
X4833 g6660_0 g6608_0 vdd 0 g6704_0 nand2
X4834 g1502_0 g799_1 vdd 0 g1738_1 and2
X4835 g5309_3 g5986_1 vdd 0 g6318_3 and2
X4836 g5643_0 vdd 0 g6107_1 not1
X4837 g5445_1 vdd 0 g6041_1 not1
X4838 g2049_5 g4421_1 g4422_1 g4423_1 vdd 0 g5208_2 or4
X4839 g2159_3 vdd 0 g3210_1 not1
X4840 g82_1 g760_5 vdd 0 g1159_1 and2
X4841 g2549_0 g2926_1 vdd 0 g3523_1 nand2
X4842 g6853_1 vdd 0 g6974_1 not1
X4843 g6543_1 vdd 0 g6663_1 not1
X4844 g1926_1 g1553_1 vdd 0 g2288_2 or2
X4845 g576_3 g2209_4 vdd 0 g2901_5 and2
X4846 g3797_0 g3736_0 g3725_0 g3718_0 vdd 0 g4395_1 and4
X4847 g1799_1 vdd 0 g2585_0 not1
X4848 g6240_0 vdd 0 g6418_0 not1
X4849 g4550_2 g4532_2 g2890_2 g4539_1 vdd 0 g5347_1 and4
X4850 g2359_1 g1130_0 vdd 0 g2775_1 nand2
X4851 g4560_2 vdd 0 g5671_1 not1
X4852 g5578_1 g6411_1 vdd 0 g6522_1 nand2
X4853 x221_1 x222_0 vdd 0 g5357_1 and2
X4854 g3106_2 vdd 0 g3717_1 not1
X4855 g1691_4 vdd 0 g2474_1 not1
X4856 g4456_6 g2849_3 vdd 0 g5313_1 and2
X4857 g1883_1 g3077_0 vdd 0 g3554_0 nand2
X4858 g2845_0 g3511_1 vdd 0 g3883_3 nand2
X4859 g2630_0 g2999_1 vdd 0 g3544_0 nand2
X4860 g4324_1 g6565_1 vdd 0 g6674_1 nand2
X4861 g6116_2 g7063_1 vdd 0 g7082_1 nand2
X4862 g3201_1 vdd 0 g3983_0 not1
X4863 g526_3 g1698_5 vdd 0 g2096_4 and2
X4864 g53_2 g1178_6 vdd 0 g1452_1 and2
X4865 g2483_2 vdd 0 g2830_0 not1
X4866 g1212_1 vdd 0 g1484_2 not1
X4867 g5707_1 vdd 0 g6130_0 not1
X4868 g859_0 g1124_1 vdd 0 g1375_0 nand2
X4869 g2314_1 vdd 0 g3398_0 not1
X4870 g2188_5 vdd 0 g3315_2 not1
X4871 g1679_1 vdd 0 g2677_2 not1
X4872 g1604_3 vdd 0 g2597_1 not1
X4873 g1957_2 vdd 0 g2751_1 not1
X4874 g1731_1 vdd 0 g2359_2 not1
X4875 g6799_0 g5242_1 vdd 0 g6892_1 nand2
X4876 g646_5 g1543_4 vdd 0 g1927_1 and2
X4877 g2740_0 vdd 0 g3084_0 not1
X4878 g3736_5 vdd 0 g5056_2 not1
X4879 g2531_2 vdd 0 g2919_1 not1
X4880 g2377_2 g1135_1 vdd 0 g2781_1 nand2
X4881 g7054_0 vdd 0 g7103_1 not1
X4882 g5131_0 g5705_1 vdd 0 g5931_0 nand2
X4883 g4802_8 g3013_3 g4791_6 vdd 0 g5466_1 and3
X4884 g3008_1 g5470_0 vdd 0 g5836_2 or2
X4885 g2719_1 vdd 0 g3081_0 not1
X4886 g174_1 vdd 0 g7453_1 not1
X4887 g7303_1 g5809_2 g792_2 vdd 0 g7351_1 and3
X4888 g206_14 g5302_5 g4519_9 vdd 0 g5991_1 and3
X4889 g1398_1 g712_3 vdd 0 g1608_3 and2
X4890 g2318_3 g1723_0 vdd 0 g3066_0 and2
X4891 g2644_1 vdd 0 g3046_1 not1
X4892 g2881_2 g5351_0 g5352_0 vdd 0 g5906_1 nor3
X4893 g2958_0 g5407_1 g5408_0 g5409_1 vdd 0 g5829_1 or4
X4894 g15_2 g835_3 vdd 0 g1302_1 and2
X4895 g4721_7 g2984_4 g4711_5 vdd 0 g5426_1 and3
X4896 g4278_0 g4279_0 vdd 0 g4908_1 nand2
X4897 g7341_0 g7335_1 vdd 0 g7366_0 nand2
X4898 g1042_1 g4057_0 vdd 0 g4267_0 nand2
X4899 g2288_0 vdd 0 g3186_0 not1
X4900 g6954_2 g5961_0 vdd 0 g7024_1 nand2
X4901 g2288_1 vdd 0 g3450_1 not1
X4902 g6637_0 g6469_0 vdd 0 g6737_0 nand2
X4903 g6481_1 vdd 0 g6605_1 not1
X4904 g2389_1 vdd 0 g2793_0 not1
X4905 g3096_1 g5865_1 vdd 0 g6100_1 nand2
X4906 g5616_2 g6169_1 vdd 0 g6328_1 nand2
X4907 g2769_0 g3468_0 vdd 0 g3587_8 nand2
X4908 g4711_6 g4742_2 g4721_8 vdd 0 x251_0 and3
X4909 g3665_6 g3654_4 g2013_1 g3644_5 vdd 0 g4355_1 and4
X4910 g6597_4 vdd 0 g6712_1 not1
X4911 g6326_0 g6166_0 vdd 0 g6402_1 nand2
X4912 g90_1 g716_2 vdd 0 g1099_1 and2
X4913 g4876_3 g5496_2 g6064_1 vdd 0 g6204_1 and3
X4914 g5434_0 g5431_0 g5448_2 vdd 0 g6048_0 and3
X4915 g2492_2 vdd 0 g2836_0 not1
X4916 g1941_1 g1580_0 vdd 0 g2342_0 or2
X4917 g672_0 vdd 0 g1033_1 not1
X4918 g3456_1 vdd 0 g4207_0 not1
X4919 g1770_2 vdd 0 g2624_2 not1
X4920 g1638_3 g545_7 vdd 0 g2510_2 nor2
X4921 g145_0 g1521_2 vdd 0 g1919_1 and2
X4922 g5098_1 g5787_1 vdd 0 g5981_1 nand2
X4923 g4940_1 g4117_1 g5538_0 vdd 0 g5855_1 and3
X4924 g973_2 g3906_0 vdd 0 g4223_1 nand2
X4925 g6924_1 g6844_1 vdd 0 g6964_2 nand2
X4926 g6255_0 g4160_0 vdd 0 g6464_0 nand2
X4927 g191_1 vdd 0 g7468_0 not1
X4928 g4991_0 vdd 0 g5244_0 not1
X4929 g3352_1 g4187_0 vdd 0 g4312_0 nand2
X4930 g3264_1 g4173_0 vdd 0 g4306_1 nand2
X4931 g6176_3 g6333_1 vdd 0 g6433_2 and2
X4932 g5661_2 vdd 0 g6011_1 not1
X4933 g1687_2 vdd 0 g2546_2 not1
X4934 g2147_0 vdd 0 g3123_1 not1
X4935 g7119_1 g6142_1 vdd 0 g7167_1 nand2
X4936 g5829_0 g6184_1 vdd 0 g6351_3 or2
X4937 g5778_1 g5273_0 vdd 0 g5971_1 nor2
X4938 g2540_2 vdd 0 g2922_1 not1
X4939 g4078_1 vdd 0 g4890_1 not1
X4940 g6345_0 g6532_0 vdd 0 g6588_1 and2
X4941 g970_1 g3904_1 vdd 0 g4222_1 nand2
X4942 g660_5 vdd 0 g1039_2 not1
X4943 g1057_2 vdd 0 g1315_1 not1
X4944 g1922_1 g1549_1 vdd 0 g2743_2 or2
X4945 g3873_5 g2101_0 vdd 0 g4455_1 and2
X4946 g182_0 vdd 0 g545_1 not1
X4947 g4463_7 g4485_1 g4474_7 g4456_1 vdd 0 g5309_1 and4
X4948 g7083_1 g7072_1 vdd 0 g7116_1 nand2
X4949 g5856_0 g5553_0 vdd 0 g6085_1 nor2
X4950 g3541_0 g2996_0 vdd 0 g4026_3 nand2
X4951 g6980_2 vdd 0 g7063_1 not1
X4952 g2462_2 g1164_1 vdd 0 g2819_1 nand2
X4953 g6176_0 g6334_0 vdd 0 g6430_0 and2
X4954 g4676_9 vdd 0 g5694_0 not1
X4955 g6023_0 g6150_0 g6508_0 vdd 0 x541_0 or3
X4956 g6124_1 vdd 0 g6364_1 not1
X4957 g6518_0 g6573_1 vdd 0 g6671_1 and2
X4958 g1877_0 g3047_0 vdd 0 g3546_1 nand2
X4959 g18_0 g1337_0 vdd 0 g1578_0 and2
X4960 g640_0 g2194_0 vdd 0 g3020_1 and2
X4961 g1624_1 vdd 0 g2695_0 not1
X4962 g2359_2 vdd 0 g2776_1 not1
X4963 g7209_0 g7186_0 vdd 0 g7228_1 nand2
X4964 g646_3 g2244_4 vdd 0 g2976_1 and2
X4965 g3754_12 g2049_4 vdd 0 g4414_0 and2
X4966 g6675_1 g6652_1 vdd 0 g6754_2 nand2
X4967 g1675_1 vdd 0 g2570_1 not1
X4968 g2023_3 g5768_0 vdd 0 g5955_0 or2
X4969 g3282_0 vdd 0 g4048_0 not1
X4970 g1240_3 g1252_1 vdd 0 g1503_1 or2
X4971 g6850_1 g5607_0 vdd 0 g6973_1 nand2
X4972 g7252_1 g7216_1 vdd 0 g7257_2 nand2
X4973 g6304_2 g6079_1 vdd 0 g6446_1 nand2
X4974 g5147_0 g5766_0 vdd 0 g5953_0 nand2
X4975 g473_2 vdd 0 g889_0 not1
X4976 g7200_0 g6138_0 vdd 0 g7249_0 nand2
X4977 g6442_0 vdd 0 g6609_1 not1
X4978 g4876_2 vdd 0 g5493_2 not1
X4979 g3956_3 g3950_5 vdd 0 x92_1 and2
X4980 g6867_0 g6133_1 vdd 0 g6986_1 nand2
X4981 g7219_2 vdd 0 g7271_0 not1
X4982 g4905_2 vdd 0 g5512_1 not1
X4983 g2704_2 g4107_1 vdd 0 g4288_1 nand2
X4984 g1632_4 vdd 0 g2432_2 not1
X4985 g2429_2 g2807_1 vdd 0 g3490_1 nand2
X4986 g5671_2 g7240_0 vdd 0 g7254_0 nand2
X4987 g5655_2 g7279_1 vdd 0 g7298_1 nand2
X4988 g5939_2 g4182_0 vdd 0 g6293_1 nand2
X4989 g1411_9 g1060_5 vdd 0 g1889_1 and2
X4990 g4669_0 g2959_1 vdd 0 g5407_0 and2
X4991 g4550_1 g2890_1 vdd 0 g5353_0 and2
X4992 g3828_0 g2081_1 vdd 0 g4440_0 and2
X4993 g479_1 vdd 0 g862_2 not1
X4994 g652_4 g2250_3 vdd 0 g3013_4 and2
X4995 g4474_6 vdd 0 g5625_2 not1
X4996 g1828_0 vdd 0 g2722_0 not1
X4997 g1086_1 g1096_0 vdd 0 g1395_0 or2
X4998 g3395_0 g3065_1 vdd 0 g4106_0 nand2
X4999 g6234_1 vdd 0 g6414_1 not1
X5000 g5982_1 g5790_0 vdd 0 g6153_1 nand2
X5001 g494_3 vdd 0 g777_2 not1
X5002 g4698_5 vdd 0 g5248_1 not1
X5003 g3694_2 vdd 0 g4365_2 not1
X5004 g1638_0 g545_0 vdd 0 g2081_0 and2
X5005 g4019_1 g4251_0 vdd 0 g4721_0 nand2
X5006 g6366_1 g5280_3 g5253_1 vdd 0 g6512_1 and3
X5007 g1853_1 vdd 0 g2404_0 not1
X5008 g1750_1 vdd 0 g2377_1 not1
X5009 g2674_1 vdd 0 g3054_0 not1
X5010 g5183_1 g5380_1 vdd 0 g5816_1 or2
X5011 g7065_1 vdd 0 g7112_1 not1
X5012 g158_1 g1446_4 vdd 0 g1897_1 and2
X5013 g2594_2 vdd 0 g2949_1 not1
X5014 g5334_0 g4598_7 vdd 0 g6008_1 and2
X5015 g4319_0 g4320_0 vdd 0 g5153_0 nand2
X5016 g538_3 g1710_0 vdd 0 g2045_1 and2
X5017 g6893_1 g6828_1 vdd 0 g7519_1 nand2
X5018 g3020_2 g5482_1 g5483_0 g5484_1 vdd 0 g5948_0 nor4
X5019 g488_1 vdd 0 g740_2 not1
X5020 g3216_0 vdd 0 g4010_0 not1
X5021 g1895_1 g1456_1 vdd 0 g2123_0 or2
X5022 g5776_1 g5271_0 vdd 0 g5969_0 nor2
X5023 g5752_2 g7166_1 vdd 0 g7172_1 nand2
X5024 g4539_10 g2885_3 vdd 0 g5351_1 and2
X5025 g6433_0 vdd 0 g6581_1 not1
X5026 g2304_0 vdd 0 g3462_0 not1
X5027 g5640_2 g6976_0 vdd 0 g7010_1 nand2
X5028 g4199_0 g5118_0 vdd 0 g5232_1 nand2
X5029 g1638_4 vdd 0 g2492_2 not1
X5030 g1913_0 g1497_0 vdd 0 g2203_2 or2
X5031 g170_2 vdd 0 g464_1 not1
X5032 g23_0 g1316_2 vdd 0 g1552_0 and2
X5033 g3069_0 g4926_1 vdd 0 x302_1 and2
X5034 g1070_2 vdd 0 g1377_1 not1
X5035 g179_2 vdd 0 g7456_1 not1
X5036 g9_0 g1212_0 vdd 0 g1497_1 and2
X5037 g4820_0 g3024_1 vdd 0 g5482_0 and2
X5038 g2576_1 g3972_0 vdd 0 g4233_0 nand2
X5039 g7363_1 g6054_0 vdd 0 g7388_0 nand2
X5040 g4939_0 g4935_2 g4931_3 vdd 0 x291_1 and3
X5041 g397_2 vdd 0 g7489_0 not1
X5042 g5795_0 vdd 0 g6163_0 not1
X5043 g6456_2 g5878_1 vdd 0 g6624_1 nand2
X5044 g4009_1 g4246_0 vdd 0 g4676_5 nand2
X5045 g3342_0 g3046_0 vdd 0 g4072_1 nand2
X5046 g3698_3 g3694_1 g4383_2 vdd 0 g5271_1 and3
X5047 g42_0 g1344_3 vdd 0 g1581_1 and2
X5048 g5936_2 vdd 0 g6291_1 not1
X5049 g3222_1 g1263_1 vdd 0 g4013_1 nand2
X5050 g2570_0 g2931_0 vdd 0 g3528_0 nand2
X5051 g7131_1 g5587_1 vdd 0 g7174_0 nand2
X5052 g2969_2 g4687_1 g4676_1 vdd 0 g5414_1 and3
X5053 g2276_0 g2159_0 vdd 0 g2945_0 and2
X5054 g567_0 g1275_1 vdd 0 g1519_0 and2
X5055 g7315_2 vdd 0 g7342_0 not1
X5056 g868_1 vdd 0 g1128_1 not1
X5057 g3058_1 g5519_1 g5520_0 g5521_1 vdd 0 g5848_3 or4
X5058 g7354_1 g7355_1 g7356_0 g7357_1 vdd 0 g7378_2 or4
X5059 g4687_5 vdd 0 g5700_0 not1
X5060 g2603_0 vdd 0 g2952_0 not1
X5061 g5824_0 vdd 0 g6182_1 not1
X5062 g5806_1 g5369_1 vdd 0 g6255_1 or2
X5063 g5997_1 g6173_1 vdd 0 g6330_1 nand2
X5064 g2534_2 vdd 0 g2920_1 not1
X5065 x361_0 x362_1 vdd 0 g5852_0 or2
X5066 g6821_1 g6742_0 vdd 0 g6864_1 nand2
X5067 g3601_12 vdd 0 g5036_2 not1
X5068 g1082_1 g1257_0 vdd 0 g1385_1 nand2
X5069 g2270_3 vdd 0 g3213_2 not1
X5070 g2209_3 vdd 0 g3138_2 not1
X5071 g5746_0 g7389_0 vdd 0 g7401_0 nand2
X5072 g4753_0 g4750_0 g4781_0 vdd 0 g5458_0 and3
X5073 g2890_0 vdd 0 g4161_1 not1
X5074 g2564_1 g2929_0 vdd 0 g3526_1 nand2
X5075 g1503_0 g799_0 vdd 0 g1744_2 and2
X5076 g5956_0 g6311_0 g6512_0 vdd 0 x561_0 or3
X5077 g3538_0 g3539_0 vdd 0 g4006_0 nand2
X5078 g4834_13 g3030_4 g4820_11 vdd 0 g5479_1 and3
X5079 g4820_12 vdd 0 g5743_2 not1
X5080 g3873_9 g3862_10 g2101_4 g3852_9 vdd 0 g4452_0 and4
X5081 g7123_1 g7092_1 vdd 0 g7134_2 nand2
X5082 g5974_2 g5253_4 vdd 0 g6311_1 and2
X5083 g1086_5 g1097_1 vdd 0 g1396_1 or2
X5084 g2765_0 g2766_1 vdd 0 g3297_0 nand2
X5085 g780_1 vdd 0 g1323_6 not1
X5086 g3754_5 vdd 0 g5080_1 not1
X5087 g6247_2 vdd 0 g6459_1 not1
X5088 g3901_1 g4221_0 vdd 0 g4498_3 nand2
X5089 g3180_2 vdd 0 g3974_1 not1
X5090 g4072_0 g4276_0 vdd 0 g4884_0 nand2
X5091 g6430_2 vdd 0 g6580_0 not1
X5092 g874_0 g2776_0 vdd 0 g3471_1 nand2
X5093 g628_1 g2182_2 vdd 0 g2984_1 and2
X5094 g3839_2 g6911_3 vdd 0 g6997_1 and2
X5095 g1006_0 g4008_1 vdd 0 g4245_0 nand2
X5096 g916_1 g2824_1 vdd 0 g3500_1 nand2
X5097 g1901_1 g1474_1 vdd 0 g2641_1 or2
X5098 g1907_0 g1480_1 vdd 0 g2175_5 or2
X5099 g4721_10 vdd 0 g5563_0 not1
X5100 g519_6 vdd 0 g949_2 not1
X5101 g202_2 vdd 0 g652_7 not1
X5102 g3414_2 vdd 0 g4128_1 not1
X5103 g4994_0 g6896_1 vdd 0 g6936_0 nand2
X5104 g5211_0 g6728_0 vdd 0 g6816_1 nand2
X5105 g2740_1 g3083_1 vdd 0 g3559_1 nand2
X5106 g3243_1 vdd 0 g4037_1 not1
X5107 g3386_2 vdd 0 g4101_1 not1
X5108 g6422_0 vdd 0 g6518_1 not1
X5109 g2028_1 g4398_1 g4399_1 g4400_1 vdd 0 g5166_1 or4
X5110 g940_0 g2840_0 vdd 0 g3508_1 nand2
X5111 g1490_0 g1219_0 vdd 0 g1877_1 or2
X5112 g6312_0 g6911_1 vdd 0 g6994_1 and2
X5113 g1921_0 g1536_0 vdd 0 g2270_1 or2
X5114 g2752_0 g5828_1 vdd 0 g6023_1 or2
X5115 g2594_0 g2950_1 vdd 0 g3533_1 nand2
X5116 g57_0 g1269_3 vdd 0 g1513_1 and2
X5117 g2853_1 g5323_0 vdd 0 g5900_1 nor2
X5118 g3204_1 vdd 0 g3984_1 not1
X5119 g7260_1 g6158_2 g6568_4 vdd 0 g7301_1 and3
X5120 g5554_1 g6998_1 vdd 0 g7014_1 nand2
X5121 g608_5 vdd 0 g979_2 not1
X5122 g4_2 g3_2 vdd 0 g442_3 nand2
X5123 g3665_5 g3654_2 g2013_4 vdd 0 g4357_0 and3
X5124 g199_2 vdd 0 g7475_1 not1
X5125 g1_0 vdd 0 g7447_1 not1
X5126 g5229_1 g5297_1 vdd 0 g5792_1 nand2
X5127 g148_1 g1468_3 vdd 0 g1910_1 and2
X5128 g51_0 g1199_0 vdd 0 g1481_0 and2
X5129 g4519_0 g4498_1 vdd 0 x392_1 and2
X5130 g7306_1 g6433_1 g561_1 vdd 0 g7352_1 and3
X5131 g423_2 vdd 0 g925_1 not1
X5132 g1923_0 g1550_1 vdd 0 g2276_3 or2
X5133 g7153_0 vdd 0 g7191_1 not1
X5134 g6515_0 g7033_3 vdd 0 g7085_1 and2
X5135 g1931_1 g1558_1 vdd 0 g2308_3 or2
X5136 x161_0 x162_0 vdd 0 g5178_0 or2
X5137 g166_0 g407_0 vdd 0 g7495_0 nand2
X5138 g4196_1 vdd 0 g5118_1 not1
X5139 g1178_3 vdd 0 g1440_2 not1
X5140 g1493_0 g1222_1 vdd 0 g1723_2 or2
X5141 g6805_1 g5245_0 vdd 0 g6897_1 nand2
X5142 g6677_3 g7381_1 vdd 0 g7395_1 and2
X5143 g3768_14 g2055_5 vdd 0 g4424_1 and2
X5144 g1528_0 g1303_0 vdd 0 g1799_3 or2
X5145 g1042_0 vdd 0 g1310_0 not1
X5146 g5664_0 g7385_1 vdd 0 g7398_1 nand2
X5147 g4154_1 vdd 0 g4531_1 not1
X5148 g526_2 g842_5 vdd 0 g1358_1 and2
X5149 g160_1 g1484_4 vdd 0 g1915_1 and2
X5150 g3601_3 g1971_6 g3587_6 vdd 0 g4337_0 and3
X5151 g892_1 g2786_0 vdd 0 g3475_0 nand2
X5152 g4611_1 vdd 0 g5640_0 not1
X5153 g2725_1 vdd 0 g3410_1 not1
X5154 g7417_1 vdd 0 g7426_0 not1
X5155 g6384_1 g6383_1 vdd 0 g6502_2 nand2
X5156 g6230_2 vdd 0 g6451_1 not1
X5157 g5047_2 vdd 0 g5598_1 not1
X5158 g2182_5 vdd 0 g3234_2 not1
X5159 g5471_2 vdd 0 g6051_1 not1
X5160 g3306_1 vdd 0 g4055_0 not1
X5161 g3407_1 g3070_0 vdd 0 g4111_0 nand2
X5162 g2055_2 g4426_1 vdd 0 g5174_0 or2
X5163 g4139_1 g4301_1 vdd 0 g5003_1 nand2
X5164 g6765_2 g6153_1 vdd 0 g6882_0 and2
X5165 g6495_1 g6498_0 vdd 0 g6651_0 nand2
X5166 g4619_2 g4625_1 vdd 0 g5370_1 and2
X5167 g1628_1 vdd 0 g2522_2 not1
X5168 g6147_2 vdd 0 g6382_1 not1
X5169 g5223_0 vdd 0 g5787_1 not1
X5170 g4050_0 g4264_0 vdd 0 g4784_3 nand2
X5171 g4260_0 g4261_0 vdd 0 g4771_0 nand2
X5172 g2531_2 g2920_0 vdd 0 g3517_1 nand2
X5173 g816_4 vdd 0 g1246_1 not1
X5174 g7170_0 g7157_1 vdd 0 g7193_1 nand2
X5175 g5972_1 g5971_0 vdd 0 g6240_1 nand2
X5176 g3862_8 vdd 0 g4982_1 not1
X5177 g694_1 vdd 0 g7498_0 not1
X5178 g5009_2 g6960_1 vdd 0 g7002_0 nand2
X5179 g6859_1 g6470_1 vdd 0 g6979_1 nand2
X5180 g3312_2 g1311_1 vdd 0 g4058_1 nand2
X5181 g6565_0 vdd 0 g6677_1 not1
X5182 g6002_1 vdd 0 g6333_0 not1
X5183 g4234_1 g3975_0 vdd 0 g4639_2 nand2
X5184 g1596_2 vdd 0 g2609_2 not1
X5185 g1927_0 g1554_1 vdd 0 g2292_2 or2
X5186 g7001_1 g6910_1 vdd 0 g7030_2 or2
X5187 g2489_2 g1171_1 vdd 0 g2833_1 nand2
X5188 g634_4 vdd 0 g1024_2 not1
X5189 g2474_2 g1168_1 vdd 0 g2827_1 nand2
X5190 g5003_0 g3561_1 vdd 0 g5582_1 nand2
X5191 g608_4 g1565_4 vdd 0 g1940_1 and2
X5192 g3210_1 vdd 0 g3987_0 not1
X5193 g2695_1 vdd 0 g3367_1 not1
X5194 g1971_4 g4344_1 vdd 0 g5160_2 or2
X5195 g5089_2 g7185_1 vdd 0 g7209_1 nand2
X5196 g3324_2 vdd 0 g4067_1 not1
X5197 g683_5 g428_7 vdd 0 g1073_1 nor2
X5198 g5566_2 g7025_1 vdd 0 g7078_1 nand2
X5199 g4893_2 vdd 0 g5505_2 not1
X5200 g5871_2 g3109_0 vdd 0 g6244_1 nand2
X5201 g672_2 g1543_1 vdd 0 g1931_1 and2
X5202 g206_12 g6318_2 g6026_3 vdd 0 x451_0 and3
X5203 g6847_2 vdd 0 g6970_1 not1
X5204 g1978_6 vdd 0 g3096_2 not1
X5205 g949_0 vdd 0 g1177_1 not1
X5206 g970_0 vdd 0 g1230_1 not1
X5207 g1710_1 vdd 0 g2462_1 not1
X5208 g487_0 g821_3 vdd 0 g1284_1 and2
X5209 g39_1 g1323_5 vdd 0 g1555_1 and2
X5210 g3924_1 g4229_0 vdd 0 g4582_8 nand2
X5211 g4802_7 vdd 0 g5710_0 not1
X5212 g4732_8 g4721_9 g2989_2 vdd 0 g5429_0 and3
X5213 g4288_0 g4108_0 vdd 0 g4935_1 nand2
X5214 g103_1 g753_2 vdd 0 g1153_1 and2
X5215 g457_3 vdd 0 g874_2 not1
X5216 g3114_1 g5885_0 vdd 0 g6102_1 nand2
X5217 g192_2 vdd 0 g594_4 not1
X5218 g1744_5 vdd 0 g2392_2 not1
X5219 g7177_2 g5276_0 vdd 0 g7216_0 nand2
X5220 g4869_1 vdd 0 g5731_0 not1
X5221 g1404_0 g721_0 vdd 0 g1624_0 and2
X5222 g5774_0 g5269_0 vdd 0 g5967_1 nor2
X5223 g2498_0 vdd 0 g2840_1 not1
X5224 g1409_0 g734_1 vdd 0 g1652_0 and2
X5225 x521_0 x522_0 vdd 0 g6948_1 or2
X5226 g3637_5 vdd 0 g4991_2 not1
X5227 g6964_1 g5597_1 vdd 0 g7045_1 nand2
X5228 g1935_1 g1574_1 vdd 0 g2318_1 or2
X5229 g134_0 g76_1 g142_0 g154_0 vdd 0 g400_2 and4
X5230 g203_1 vdd 0 g660_4 not1
X5231 g2510_1 vdd 0 g2847_1 not1
X5232 g2453_2 g1161_1 vdd 0 g2813_1 nand2
X5233 g6722_0 g5596_0 vdd 0 g6844_1 nand2
X5234 g5619_1 vdd 0 g5996_0 not1
X5235 g6124_0 g6605_0 vdd 0 g6659_0 nand2
X5236 g5846_0 g5513_0 vdd 0 g6071_1 nor2
X5237 g3377_1 g4097_0 vdd 0 g4280_0 nand2
X5238 g100_1 g727_1 vdd 0 g1115_0 and2
X5239 g446_2 vdd 0 g812_0 not1
X5240 g6784_1 vdd 0 g7514_1 not1
X5241 g3999_1 g3988_1 g2233_0 g3994_3 vdd 0 g4667_0 and4
X5242 g457_2 g1731_4 vdd 0 g2013_3 and2
X5243 g186_0 vdd 0 g7463_1 not1
X5244 g4474_5 g2859_6 vdd 0 g5321_1 and2
X5245 g207_0 g455_1 vdd 0 g690_0 and2
X5246 g5649_1 g7265_1 vdd 0 g7291_0 nand2
X5247 g588_3 vdd 0 g964_1 not1
X5248 g2374_2 g1134_1 vdd 0 g2779_1 nand2
X5249 g85_0 g760_0 vdd 0 g1155_0 and2
X5250 g4164_0 g6467_0 vdd 0 g6555_1 nand2
X5251 x11_1 x12_0 vdd 0 g4324_2 and2
X5252 g2049_2 g4424_0 g4425_1 vdd 0 g5214_1 nor3
X5253 x451_1 x452_1 vdd 0 g6507_1 and2
X5254 g7109_1 vdd 0 g7156_0 not1
X5255 g3103_0 vdd 0 g3716_0 not1
X5256 g2395_0 vdd 0 g2796_0 not1
X5257 g594_2 vdd 0 g997_1 not1
X5258 g3333_1 g3045_0 vdd 0 g4069_1 nand2
X5259 g2188_2 vdd 0 g3246_2 not1
X5260 g5710_1 g7112_1 vdd 0 g7129_0 nand2
X5261 g898_2 vdd 0 g1160_1 not1
X5262 g5572_2 g6407_1 vdd 0 g6520_1 nand2
X5263 g7228_2 g5606_0 vdd 0 g7278_0 nand2
X5264 g56_0 g1350_0 vdd 0 g1590_1 and2
X5265 g5843_0 vdd 0 g6300_0 not1
X5266 g6488_0 g6556_0 vdd 0 g6642_1 nand2
X5267 g3444_0 g4134_0 vdd 0 g4297_1 nand2
X5268 g3361_1 vdd 0 g4189_1 not1
X5269 g2963_1 g5415_1 g5416_1 vdd 0 g5923_1 or3
X5270 g1375_1 g1376_1 vdd 0 g1411_4 nand2
X5271 g628_4 vdd 0 g1051_2 not1
X5272 g2418_0 vdd 0 g2804_0 not1
X5273 g1930_0 g1557_0 vdd 0 g2304_2 or2
X5274 g1620_1 vdd 0 g2534_1 not1
X5275 g6525_0 g6419_0 vdd 0 g6564_0 nand2
X5276 g1015_0 g4014_1 vdd 0 g4248_0 nand2
X5277 g105_1 g753_3 vdd 0 g1150_0 and2
X5278 g6299_1 g6397_0 vdd 0 g6495_2 nand2
X5279 g1586_0 g1361_1 vdd 0 g1832_2 or2
X5280 g5926_0 vdd 0 g6191_0 not1
X5281 g3630_0 g3617_6 vdd 0 g4345_1 and2
X5282 g1514_0 g1284_0 vdd 0 g1774_1 or2
X5283 g6523_0 g6415_0 vdd 0 g6562_0 nand2
X5284 g2695_2 g3366_0 vdd 0 g3572_1 nand2
X5285 g97_1 g727_3 vdd 0 g1118_0 and2
X5286 g5454_0 vdd 0 g6044_0 not1
X5287 g2401_0 g2797_1 vdd 0 g3482_0 nand2
X5288 g1965_3 g4342_1 g4343_0 vdd 0 g5194_0 nor3
X5289 g501_1 vdd 0 g821_1 not1
X5290 g2977_1 g5425_1 g5426_0 vdd 0 x521_1 or3
X5291 g5912_1 g6862_0 vdd 0 g6926_1 nand2
X5292 g3291_1 vdd 0 g4176_0 not1
X5293 g3736_6 g2038_5 g3725_5 vdd 0 g4405_1 and3
X5294 g1323_6 vdd 0 g1543_5 not1
X5295 g7007_0 g6971_0 vdd 0 g7048_0 nand2
X5296 g3138_0 g1230_0 vdd 0 g3903_0 nand2
X5297 g2841_0 g3509_0 vdd 0 g3862_6 nand2
X5298 g1664_0 g1411_6 vdd 0 g1998_0 and2
X5299 g4294_1 g4295_0 vdd 0 g4953_2 nand2
X5300 g2322_3 vdd 0 g3423_2 not1
X5301 g910_2 vdd 0 g1164_1 not1
X5302 g2874_0 g5333_1 g5991_0 vdd 0 g6220_0 or3
X5303 g4030_3 vdd 0 g4753_2 not1
X5304 g2522_1 vdd 0 g2916_0 not1
X5305 g5719_2 vdd 0 g6133_0 not1
X5306 g5761_0 vdd 0 g6079_0 not1
X5307 g2831_1 g3504_0 vdd 0 g3817_6 nand2
X5308 g65_1 g1185_2 vdd 0 g1459_1 and2
X5309 g7403_0 g7395_0 vdd 0 g7414_1 or2
X5310 g2347_0 g1126_1 vdd 0 g2767_1 nand2
X5311 g5697_2 g4025_1 vdd 0 g6037_0 nand2
X5312 g5761_2 g6445_1 vdd 0 g6542_1 nand2
X5313 g6760_3 vdd 0 g6905_3 not1
X5314 g1893_0 g1454_1 vdd 0 g2115_3 or2
X5315 g6121_0 vdd 0 g6344_1 not1
X5316 g1750_4 vdd 0 g2350_2 not1
X5317 g1832_1 vdd 0 g2719_1 not1
X5318 g7225_2 vdd 0 g7275_1 not1
X5319 g2368_1 g6389_1 vdd 0 g6448_1 nand2
X5320 g3183_2 vdd 0 g3976_1 not1
X5321 g98_1 g727_5 vdd 0 g1117_1 and2
X5322 g68_0 g67_0 vdd 0 g388_1 and2
X5323 g6203_0 g6067_0 vdd 0 g6370_0 nor2
X5324 g2731_1 vdd 0 g3412_0 not1
X5325 g6655_1 g6585_1 vdd 0 g6697_0 nand2
X5326 g5341_3 vdd 0 g6001_1 not1
X5327 g7180_1 g5277_1 vdd 0 g7218_0 nand2
X5328 g5802_0 vdd 0 g6175_1 not1
X5329 g1868_2 vdd 0 g2240_0 not1
X5330 g6205_0 g6069_1 vdd 0 g6372_0 nor2
X5331 g5334_2 vdd 0 g6109_1 not1
X5332 g111_0 g1462_3 vdd 0 g1902_1 and2
X5333 g3552_0 g3553_1 vdd 0 g4092_1 nand2
X5334 g961_2 g3898_0 vdd 0 g4219_0 nand2
X5335 g919_2 vdd 0 g1167_1 not1
X5336 g4143_2 g5040_1 vdd 0 g5201_1 nand2
X5337 g545_6 vdd 0 g934_2 not1
X5338 g4164_1 vdd 0 g5114_1 not1
X5339 g2638_2 vdd 0 g3002_1 not1
X5340 g7130_0 g7115_0 vdd 0 g7161_0 nand2
X5341 g614_0 vdd 0 g976_0 not1
X5342 g1795_3 vdd 0 g2582_0 not1
X5343 g4756_3 vdd 0 g5431_2 not1
X5344 g207_4 g173_3 vdd 0 g500_1 and2
X5345 g4023_0 g4253_0 vdd 0 g4742_1 nand2
X5346 g1518_1 g1288_1 vdd 0 g1871_1 or2
X5347 g727_6 vdd 0 g1102_3 not1
X5348 g1501_1 g799_5 vdd 0 g1731_6 and2
X5349 g3267_2 g4172_1 vdd 0 g4305_0 nand2
X5350 g1428_0 g1382_1 vdd 0 g1670_3 nand2
X5351 g163_0 g1484_1 vdd 0 g1911_0 and2
X5352 g4232_0 g3971_1 vdd 0 g4630_1 nand2
X5353 g1513_0 g1283_0 vdd 0 g1770_1 or2
X5354 g4850_8 g4834_5 g3037_6 g4820_10 vdd 0 g5480_1 and4
X5355 g4946_0 g4949_3 g6080_0 vdd 0 g6210_1 and3
X5356 g1848_3 vdd 0 g2731_2 not1
X5357 g4315_1 g4316_0 vdd 0 g5147_2 nand2
X5358 g652_3 g2250_2 vdd 0 g3327_1 nor2
X5359 g1932_1 g1571_0 vdd 0 g2740_2 or2
X5360 g2250_5 vdd 0 g3222_2 not1
X5361 g5707_0 g6983_0 vdd 0 g7012_0 nand2
X5362 g6847_1 g5602_0 vdd 0 g6971_1 nand2
X5363 g5107_1 g2847_0 vdd 0 g5298_0 nand2
X5364 g5897_1 vdd 0 g6169_0 not1
X5365 g5110_0 vdd 0 g5301_0 not1
X5366 g821_4 vdd 0 g1269_5 not1
X5367 g4151_1 g2879_1 vdd 0 g4529_1 nand2
X5368 g3554_1 g3078_0 vdd 0 g4113_2 nand2
X5369 g7057_0 g6107_1 vdd 0 g7106_1 nand2
X5370 g6808_0 g5246_0 vdd 0 g6899_1 nand2
X5371 g135_0 g816_0 vdd 0 g1256_0 and2
X5372 g1508_0 g1385_0 vdd 0 g1762_1 nand2
X5373 g464_2 g1738_3 vdd 0 g2008_1 and2
X5374 g2779_0 g3472_0 vdd 0 g3637_3 nand2
X5375 g3441_1 g4135_1 vdd 0 g4298_1 nand2
X5376 g2630_1 vdd 0 g3000_1 not1
X5377 g4210_2 g5143_1 vdd 0 g5237_1 nand2
X5378 g206_9 vdd 0 g678_2 not1
X5379 g3579_5 vdd 0 g5033_2 not1
X5380 g7391_2 vdd 0 g7405_1 not1
X5381 g1587_1 g1362_1 vdd 0 g1836_1 or2
X5382 g1990_2 vdd 0 g2778_1 not1
X5383 g928_2 g2832_0 vdd 0 g3504_1 nand2
X5384 g3380_2 g4100_1 vdd 0 g4283_1 nand2
X5385 g206_1 vdd 0 g561_0 not1
X5386 g2423_0 vdd 0 g2805_0 not1
X5387 g5056_1 vdd 0 g5600_0 not1
X5388 g5_0 vdd 0 g439_1 not1
X5389 g4979_1 vdd 0 g5240_1 not1
X5390 g197_1 vdd 0 g621_3 not1
X5391 g2045_2 g4414_1 g4415_1 vdd 0 x201_1 or3
X5392 g1880_1 g3052_1 vdd 0 g3549_0 nand2
X5393 g5743_0 g7387_0 vdd 0 g7400_0 nand2
X5394 g6751_0 g1990_0 vdd 0 g6879_0 and2
X5395 g6327_0 g6168_0 vdd 0 g6421_0 nand2
X5396 g6096_2 vdd 0 g6389_0 not1
X5397 g6754_1 g6413_0 g6677_0 vdd 0 g6904_1 and3
X5398 g545_2 vdd 0 g919_1 not1
X5399 g4884_2 vdd 0 g5499_1 not1
X5400 g107_1 g106_0 g109_1 g110_1 vdd 0 g397_0 and4
X5401 g2716_1 vdd 0 g3080_1 not1
X5402 g70_2 g1144_5 vdd 0 g1437_1 and2
X5403 g5508_1 vdd 0 g6066_1 not1
X5404 g5214_0 g4150_0 vdd 0 g5886_1 nand2
X5405 g5968_1 g5967_0 vdd 0 g6234_0 nand2
X5406 g2338_1 vdd 0 g3374_1 not1
X5407 g2811_0 g3494_0 vdd 0 g3718_5 nand2
X5408 g6247_1 g6250_1 vdd 0 g6460_0 nand2
X5409 g4834_2 g4812_3 g3030_5 g4820_5 vdd 0 g5476_1 and4
X5410 g38_0 g1316_6 vdd 0 g1551_1 and2
X5411 g2677_1 g3054_1 vdd 0 g3550_1 nand2
X5412 g6784_0 g6787_0 g6778_0 vdd 0 g6902_1 and3
X5413 g5646_1 vdd 0 g6108_0 not1
X5414 g2555_1 g2928_1 vdd 0 g3525_1 nand2
X5415 g4767_0 g5440_0 g6044_1 vdd 0 g6198_1 and3
X5416 g423_1 g1658_1 vdd 0 g2028_0 and2
X5417 g6096_1 g3094_1 vdd 0 g6390_1 nand2
X5418 g716_3 vdd 0 g1092_2 not1
X5419 g7054_1 g6104_1 vdd 0 g7104_0 nand2
X5420 g5917_0 g6033_0 vdd 0 g6186_0 nand2
X5421 x141_1 x142_0 vdd 0 g5163_1 or2
X5422 g602_2 g2141_3 vdd 0 g2853_2 and2
X5423 g3380_0 vdd 0 g4099_1 not1
X5424 g3456_0 g4206_0 vdd 0 g4319_1 nand2
X5425 g1638_5 vdd 0 g2471_2 not1
X5426 g2833_0 g3505_1 vdd 0 g3828_6 nand2
X5427 g3644_7 vdd 0 g4994_2 not1
X5428 g3845_5 g3873_8 vdd 0 x72_1 and2
X5429 g3243_0 g3001_0 vdd 0 g4038_0 nand2
X5430 g6816_1 g6729_0 vdd 0 g6847_0 nand2
X5431 g6237_1 g3717_0 vdd 0 g6417_0 nand2
X5432 g6322_1 g6026_4 g5287_5 g5258_4 vdd 0 g6506_1 and4
X5433 g6214_0 g5963_0 vdd 0 g6406_1 nand2
X5434 g3432_2 g4205_1 vdd 0 g4318_1 nand2
X5435 g1892_0 g1453_0 vdd 0 g2111_1 or2
X5436 g2839_1 g3508_0 vdd 0 g3852_6 nand2
X5437 g1945_1 vdd 0 g2760_0 not1
X5438 g6478_1 vdd 0 g6586_0 not1
X5439 g7287_2 vdd 0 g7334_1 not1
X5440 g2468_2 g1166_1 vdd 0 g2823_1 nand2
X5441 g91_0 g705_0 vdd 0 g1098_0 and2
X5442 x351_1 x352_1 vdd 0 g5839_3 or2
X5443 g4967_2 vdd 0 g5538_1 not1
X5444 g167_2 g1275_5 vdd 0 g1517_1 and2
X5445 g388_0 g410_0 vdd 0 g694_0 and2
X5446 g5053_0 g6845_0 vdd 0 g6925_0 nand2
X5447 g532_3 g1704_3 vdd 0 g2092_0 and2
X5448 g201_0 vdd 0 g646_2 not1
X5449 g1624_3 vdd 0 g2528_1 not1
X5450 g5929_1 g5930_0 vdd 0 g6124_2 nand2
X5451 g3845_3 vdd 0 g4976_0 not1
X5452 g3797_5 g3736_9 g3725_10 vdd 0 g4403_1 and3
X5453 g582_5 g1559_4 vdd 0 g1936_1 and2
X5454 g4550_0 vdd 0 g5631_0 not1
X5455 g1859_0 g2422_0 vdd 0 g2764_0 nand2
X5456 g5939_1 vdd 0 g6292_1 not1
X5457 g3276_1 g4045_1 vdd 0 g4260_1 nand2
X5458 g3110_2 vdd 0 g4149_1 not1
X5459 g4568_7 g2901_0 vdd 0 g5361_0 and2
X5460 g1874_1 vdd 0 g2634_0 not1
X5461 g5680_1 vdd 0 g6014_0 not1
X5462 g4711_7 g4704_0 g2980_1 vdd 0 g5422_1 and3
X5463 g2019_1 g4346_2 vdd 0 g5258_3 and2
X5464 g5915_1 g5916_0 vdd 0 g6121_1 nand2
X5465 g404_2 vdd 0 g7491_1 not1
X5466 g6491_1 vdd 0 g6648_1 not1
X5467 g1795_3 vdd 0 g2644_2 not1
X5468 g3617_1 g3601_11 g1978_2 g3587_3 vdd 0 g4338_1 and4
X5469 g4926_2 g4920_4 g3066_1 vdd 0 g5526_1 and3
X5470 g3288_2 vdd 0 g4175_1 not1
X5471 g197_0 vdd 0 g7485_0 not1
X5472 g6771_0 g4742_0 g4732_6 vdd 0 g6918_1 and3
X5473 g5593_1 g6418_1 vdd 0 g6525_1 nand2
X5474 g5000_2 vdd 0 g5247_0 not1
X5475 g44_1 g1344_1 vdd 0 g1584_1 and2
X5476 g2525_2 g2918_0 vdd 0 g3515_1 nand2
X5477 g2330_3 vdd 0 g3429_2 not1
X5478 g3530_1 g3531_1 vdd 0 g3988_5 nand2
X5479 g2756_1 g5581_1 vdd 0 g5857_0 nand2
X5480 g1076_1 g1133_1 vdd 0 g1382_0 nand2
X5481 g7161_2 vdd 0 g7198_0 not1
X5482 g2075_2 g4440_1 g4441_0 vdd 0 g5226_2 or3
X5483 g1403_1 g721_3 vdd 0 g1620_3 and2
X5484 g3355_1 g4186_1 vdd 0 g4311_0 nand2
X5485 g6964_0 vdd 0 g7044_1 not1
X5486 g2689_0 g3364_0 vdd 0 g3570_0 nand2
X5487 g2707_0 g4112_0 vdd 0 g4291_0 nand2
X5488 g6771_2 vdd 0 g6921_0 not1
X5489 g3810_2 g2071_1 vdd 0 g4432_1 and2
X5490 g3617_10 g3601_8 g1978_4 g3587_11 vdd 0 g4334_1 and4
X5491 g2641_2 g4068_1 vdd 0 g4273_1 nand2
X5492 g2111_3 vdd 0 g3355_2 not1
X5493 g3153_2 g1234_1 vdd 0 g3918_1 nand2
X5494 g6468_0 g6555_0 vdd 0 g6637_1 nand2
X5495 g5557_2 vdd 0 g5959_1 not1
X5496 g30_2 g835_4 vdd 0 g1306_1 and2
X5497 g4508_4 g4491_6 g2874_4 g4498_5 vdd 0 g5326_1 and4
X5498 g5716_0 g7267_1 vdd 0 g7292_1 nand2
X5499 g6715_0 g5243_0 vdd 0 g6828_1 nand2
X5500 g5953_1 g5954_0 vdd 0 g6147_1 nand2
X5501 g62_2 g1199_3 vdd 0 g1480_0 and2
X5502 g7171_1 g7165_1 vdd 0 g7200_1 nand2
X5503 g195_1 vdd 0 g614_5 not1
X5504 g1723_3 vdd 0 g2662_2 not1
X5505 g2362_2 vdd 0 g3089_1 not1
X5506 g6765_0 g4323_0 vdd 0 g6884_0 and2
X5507 g6340_0 g6056_1 g5280_1 g5253_0 vdd 0 g6513_0 and4
X5508 g4784_1 g3004_0 vdd 0 g5462_0 and2
X5509 x231_0 x232_0 vdd 0 g5388_0 and2
X5510 g5743_1 vdd 0 g6054_1 not1
X5511 g2276_2 vdd 0 g3438_2 not1
X5512 g2859_4 g4474_4 g4463_5 vdd 0 g5320_1 and3
X5513 g880_2 vdd 0 g1132_0 not1
X5514 g1918_1 g1533_1 vdd 0 g2250_4 or2
X5515 g6934_0 g6892_0 vdd 0 g7525_0 nand2
X5516 g501_5 vdd 0 g828_1 not1
X5517 g5170_0 vdd 0 g5780_1 not1
X5518 g6712_0 vdd 0 g6825_1 not1
X5519 g979_1 vdd 0 g1233_0 not1
X5520 g1698_1 vdd 0 g2504_0 not1
X5521 g5749_1 vdd 0 g6141_1 not1
X5522 g1000_1 g1384_0 vdd 0 g1508_1 nand2
X5523 g2821_1 g3499_0 vdd 0 g3768_9 nand2
X5524 g2612_2 g2956_1 vdd 0 g3539_1 nand2
X5525 g602_4 vdd 0 g958_1 not1
X5526 g3803_6 g3784_12 vdd 0 g4428_1 and2
X5527 g5326_0 g5327_1 vdd 0 x312_0 or2
X5528 g1774_0 vdd 0 g2600_0 not1
X5529 g6819_0 g6735_1 vdd 0 g6856_0 nand2
X5530 g501_3 vdd 0 g842_4 not1
X5531 g538_2 vdd 0 g910_1 not1
X5532 g576_1 g2209_2 vdd 0 g2870_3 and2
X5533 g6754_0 g5156_0 g6829_0 vdd 0 g6941_0 and3
X5534 g3352_0 vdd 0 g4186_0 not1
X5535 g2471_0 vdd 0 g2826_1 not1
X5536 g5728_1 g7269_0 vdd 0 g7293_1 nand2
X5537 g4242_1 g3985_1 vdd 0 g4660_1 nand2
X5538 g3309_0 vdd 0 g4057_1 not1
X5539 g457_6 g821_5 vdd 0 g1282_1 and2
X5540 g7327_2 vdd 0 g7358_1 not1
X5541 g2250_1 g652_0 vdd 0 g2969_2 and2
X5542 g892_1 vdd 0 g1136_0 not1
X5543 g4013_0 g4248_1 vdd 0 g4698_1 nand2
X5544 g3189_0 g3978_1 vdd 0 g4236_1 nand2
X5545 g6642_2 g6287_0 vdd 0 g6742_1 nand2
X5546 g77_0 g740_4 vdd 0 g1123_1 and2
X5547 g7324_1 g5279_0 vdd 0 g7349_1 nand2
X5548 g4687_6 g2969_1 vdd 0 g5415_0 and2
X5549 g2582_1 vdd 0 g2940_1 not1
X5550 g4254_1 g4038_1 vdd 0 g4756_2 nand2
X5551 g1066_2 vdd 0 g1390_1 not1
X5552 g2582_2 g3976_1 vdd 0 g4235_0 nand2
X5553 g5795_2 g6164_1 vdd 0 g6322_2 or2
X5554 g4988_2 vdd 0 g5243_1 not1
X5555 g6867_2 vdd 0 g6985_1 not1
X5556 g1828_3 g1687_3 vdd 0 g2226_1 and2
X5557 g2383_1 vdd 0 g2786_1 not1
X5558 g1675_0 vdd 0 g2671_1 not1
X5559 g5107_0 vdd 0 g5299_0 not1
X5560 g1908_0 g1481_1 vdd 0 g2182_3 or2
X5561 g2380_1 g1429_0 vdd 0 g2783_0 nand2
X5562 g4498_8 vdd 0 g5572_1 not1
X5563 g2447_2 vdd 0 g3102_0 not1
X5564 g3746_7 g2045_3 vdd 0 g4410_1 and2
X5565 g2438_2 vdd 0 g3099_1 not1
X5566 g3810_1 vdd 0 g5098_0 not1
X5567 g5945_1 vdd 0 g6298_0 not1
X5568 g4456_2 vdd 0 g5613_1 not1
X5569 g7134_1 g5592_1 vdd 0 g7176_1 nand2
X5570 g3893_1 g4217_0 vdd 0 g4463_4 nand2
X5571 g2334_1 vdd 0 g3380_1 not1
X5572 g5125_1 vdd 0 g5704_1 not1
X5573 g3195_2 vdd 0 g3981_1 not1
X5574 g5156_3 vdd 0 g5770_3 not1
X5575 g13_0 g785_0 vdd 0 g1220_0 and2
X5576 g5236_1 g5237_0 vdd 0 g5761_1 nand2
X5577 g937_1 vdd 0 g1173_0 not1
X5578 g5881_0 vdd 0 g6250_1 not1
X5579 g2656_2 g3347_0 vdd 0 g3568_1 nand2
X5580 g3171_2 vdd 0 g4160_1 not1
X5581 g666_0 vdd 0 g1036_0 not1
X5582 g2081_2 g3828_1 g3817_2 vdd 0 g4439_1 and3
X5583 g5388_1 g6657_1 vdd 0 g6699_1 nand2
X5584 g2516_1 vdd 0 g2914_1 not1
X5585 g2225_0 g4626_0 g4627_1 vdd 0 x171_0 or3
X5586 g3520_1 g3521_1 vdd 0 g3956_4 nand2
X5587 g6161_1 vdd 0 g6312_1 not1
X5588 g976_2 vdd 0 g1232_1 not1
X5589 g3768_5 g2055_0 g3754_8 vdd 0 g4415_0 and3
X5590 g4669_2 vdd 0 g5688_0 not1
X5591 g6590_4 g3675_4 g3654_5 g3665_8 vdd 0 g6683_1 and4
X5592 g3004_1 g5465_0 g5466_0 g5467_0 vdd 0 g5933_1 or4
X5593 g2489_0 vdd 0 g2834_1 not1
X5594 g6266_2 vdd 0 g6469_1 not1
X5595 g1369_2 vdd 0 g1429_1 not1
X5596 g3371_1 g4095_1 vdd 0 g4278_1 nand2
X5597 g183_0 vdd 0 g7460_1 not1
X5598 g464_5 vdd 0 g892_2 not1
X5599 g1848_0 g1628_0 vdd 0 g2221_0 and2
X5600 g5330_0 g5989_0 vdd 0 x412_0 or2
X5601 g6531_1 g6437_0 vdd 0 g6583_0 nand2
X5602 g2573_1 vdd 0 g2933_1 not1
X5603 g2783_1 g3474_0 vdd 0 g3654_0 nand2
X5604 g3718_6 g2029_1 vdd 0 g4398_0 and2
X5605 g5652_1 g7191_0 vdd 0 g7212_0 nand2
X5606 g683_4 g428_5 vdd 0 g1060_4 and2
X5607 g1719_1 vdd 0 g2704_1 not1
X5608 g3349_1 g3051_0 vdd 0 g4083_0 nand2
X5609 g925_0 g2830_1 vdd 0 g3503_1 nand2
X5610 g7004_2 g7425_1 vdd 0 g7432_0 nand2
X5611 g1330_6 vdd 0 g1559_5 not1
X5612 g2133_0 g594_7 vdd 0 g2859_0 and2
X5613 g2203_1 vdd 0 g3141_0 not1
X5614 g5923_0 vdd 0 g6189_0 not1
X5615 g842_3 vdd 0 g1344_2 not1
X5616 g5493_1 g4880_3 g6063_0 vdd 0 g6203_1 and3
X5617 g1652_3 vdd 0 g2453_1 not1
X5618 g7012_1 g6984_1 vdd 0 g7065_2 nand2
X5619 g4463_6 g2853_3 vdd 0 g5319_1 and2
X5620 g3090_2 g1852_1 vdd 0 g4141_1 nand2
X5621 g3414_2 g4129_1 vdd 0 g4293_1 nand2
X5622 g479_5 g828_6 vdd 0 g1286_1 and2
X5623 g3459_0 g4209_0 vdd 0 g4322_1 nand2
X5624 g3490_0 g3491_0 vdd 0 g3709_0 nand2
X5625 g6588_0 g6533_0 vdd 0 g6657_0 or2
X5626 g6628_2 g5890_0 vdd 0 g6731_0 nand2
X5627 g5780_2 g5275_1 vdd 0 g6158_2 and2
X5628 g4210_2 vdd 0 g5142_0 not1
X5629 g3988_3 g2231_0 vdd 0 g4665_1 and2
X5630 g143_1 g1521_5 vdd 0 g1921_1 and2
X5631 g7404_0 g7397_1 vdd 0 g7417_2 or2
X5632 g5622_2 vdd 0 g5998_1 not1
X5633 g5813_0 g6008_0 vdd 0 g6266_0 or2
X5634 g4778_0 vdd 0 g5443_0 not1
X5635 g6273_0 g6394_0 vdd 0 g6471_0 nand2
X5636 g2677_1 vdd 0 g3055_1 not1
X5637 g4113_0 vdd 0 g4940_0 not1
X5638 g1774_2 g1600_0 vdd 0 g2232_0 and2
X5639 g4635_2 g4630_3 g2938_1 vdd 0 g5386_0 and3
X5640 g2662_0 vdd 0 g3049_0 not1
X5641 g2716_2 g3079_1 vdd 0 g3555_0 nand2
X5642 g1430_1 g1150_1 vdd 0 g1880_2 or2
X5643 x301_0 x302_0 vdd 0 g5528_0 and2
X5644 g6880_0 g6826_0 vdd 0 g7518_0 nand2
X5645 g4869_4 g4850_9 vdd 0 g5492_0 and2
X5646 g1372_2 g1259_1 vdd 0 g1510_0 nand2
X5647 g5857_1 g5582_1 vdd 0 g6093_1 nand2
X5648 g1766_2 vdd 0 g2618_1 not1
X5649 g3231_2 vdd 0 g4020_1 not1
X5650 g3462_2 vdd 0 g4209_1 not1
X5651 g6499_0 g6381_0 vdd 0 g6612_0 nand2
X5652 g1679_0 vdd 0 g2558_2 not1
X5653 g1033_2 g4051_0 vdd 0 g4264_1 nand2
X5654 g5101_2 g5789_1 vdd 0 g5982_0 nand2
X5655 g4611_3 g4550_4 vdd 0 g5369_0 and2
X5656 g683_3 vdd 0 g1076_2 not1
X5657 g6634_0 g6262_0 vdd 0 g6735_0 nand2
X5658 g6158_0 vdd 0 g6420_0 not1
X5659 g6590_3 g3675_3 g3665_7 vdd 0 g6684_0 and3
X5660 g4485_4 g6573_2 vdd 0 g6673_1 and2
X5661 g2141_4 vdd 0 g3126_1 not1
X5662 g5725_2 g7198_1 vdd 0 g7214_1 nand2
X5663 g6502_2 vdd 0 g6613_1 not1
X5664 g4953_0 vdd 0 g5543_0 not1
X5665 g6511_0 g6310_1 vdd 0 x552_1 or2
X5666 g6665_1 g6622_1 vdd 0 g6722_2 nand2
X5667 g5734_2 vdd 0 g6137_1 not1
X5668 g4960_3 vdd 0 g5535_2 not1
X5669 g7315_2 g5251_0 vdd 0 g7343_0 nand2
X5670 g151_1 g1468_0 vdd 0 g1906_0 and2
X5671 g2406_1 g2751_0 vdd 0 g2800_0 nand2
X5672 g507_2 vdd 0 g785_4 not1
X5673 g5036_1 vdd 0 g5589_1 not1
X5674 g1240_2 g1250_0 vdd 0 g1501_1 or2
X5675 g7433_0 vdd 0 g7442_0 not1
X5676 g2429_1 vdd 0 g2808_1 not1
X5677 g6037_1 g6193_1 vdd 0 g6359_1 nand2
X5678 g4732_4 g4721_4 g2989_4 g4711_3 vdd 0 g5427_0 and4
X5679 g7214_0 g7199_1 vdd 0 g7245_2 nand2
X5680 g5557_2 g7019_1 vdd 0 g7075_1 nand2
X5681 g1811_0 vdd 0 g2653_0 not1
X5682 g7242_1 g6052_0 vdd 0 g7268_1 nand2
X5683 g880_0 g1131_0 vdd 0 g1379_0 nand2
X5684 g6478_0 g6344_0 vdd 0 g6587_0 nand2
X5685 g2748_1 g2792_1 vdd 0 g3478_0 nand2
X5686 g3135_0 vdd 0 g3902_0 not1
X5687 g6513_1 g6514_1 vdd 0 x562_1 or2
X5688 g2350_0 g1127_1 vdd 0 g2769_1 nand2
X5689 g19_0 g1337_3 vdd 0 g1579_1 and2
X5690 g5691_2 g6189_1 vdd 0 g6357_1 nand2
X5691 g3156_2 vdd 0 g3921_1 not1
X5692 g2881_0 g5348_1 g5349_0 g5350_0 vdd 0 g5903_0 or4
X5693 g3637_4 g2001_2 vdd 0 g4349_1 and2
X5694 g6288_2 vdd 0 g6489_1 not1
X5695 g457_0 g1731_2 vdd 0 g2371_1 nor2
X5696 g131_1 g1206_1 vdd 0 g1492_1 and2
X5697 g2008_2 g3654_8 vdd 0 g4356_1 and2
X5698 g5136_0 g5684_0 vdd 0 g5916_1 nand2
X5699 g3574_1 g3575_0 vdd 0 g4213_2 nand2
X5700 g1199_6 vdd 0 g1468_5 not1
X5701 g5593_0 vdd 0 g5973_1 not1
X5702 g2656_0 vdd 0 g3348_0 not1
X5703 g7096_0 vdd 0 g7139_1 not1
X5704 g6328_0 g6170_1 vdd 0 g6403_1 nand2
X5705 g672_5 g2270_4 vdd 0 g2958_1 and2
X5706 g6796_2 vdd 0 g6889_1 not1
X5707 g856_0 g1125_0 vdd 0 g1376_1 nand2
X5708 g5691_0 vdd 0 g6035_1 not1
X5709 g7076_1 g7022_1 vdd 0 g7542_1 nand2
X5710 g6948_2 vdd 0 g7019_1 not1
X5711 g3709_2 vdd 0 g4374_2 not1
X5712 g7366_1 vdd 0 g7389_1 not1
X5713 g196_1 vdd 0 g7473_1 not1
X5714 g2409_1 vdd 0 g2801_0 not1
X5715 g5855_0 g5552_0 vdd 0 g6084_1 nor2
X5716 x381_0 x382_1 vdd 0 g5986_2 and2
X5717 g3736_8 vdd 0 g5044_2 not1
X5718 g4667_1 g4668_1 vdd 0 x182_1 or2
X5719 g4943_2 g4940_2 g4970_2 vdd 0 g5553_1 and3
X5720 g3466_0 g6878_0 vdd 0 g6930_1 and2
X5721 g4732_0 g4711_0 vdd 0 x512_0 and2
X5722 g6552_0 g6462_0 vdd 0 g6628_1 nand2
X5723 g5560_2 vdd 0 g5960_1 not1
X5724 g5167_2 vdd 0 g5875_1 not1
X5725 g3534_0 g3535_1 vdd 0 g3999_0 nand2
X5726 g4802_0 g3013_2 g4791_0 vdd 0 g5469_0 and3
X5727 g2241_0 vdd 0 g3407_2 not1
X5728 g6778_2 vdd 0 g7516_0 not1
X5729 g2519_2 g2916_1 vdd 0 g3513_1 nand2
X5730 g6748_2 vdd 0 g6872_0 not1
X5731 g1054_0 vdd 0 g1314_1 not1
X5732 g32_0 g1330_0 vdd 0 g1572_0 and2
X5733 g470_0 vdd 0 g767_3 not1
X5734 g922_2 vdd 0 g1168_0 not1
X5735 g4183_0 vdd 0 g5135_1 not1
X5736 g5030_1 g7091_1 vdd 0 g7123_0 nand2
X5737 g5050_1 g7215_0 vdd 0 g7252_0 nand2
X5738 g6423_6 g6403_1 vdd 0 g6559_0 and2
X5739 g628_0 g2182_1 vdd 0 g3030_0 and2
X5740 g177_1 vdd 0 g7484_0 not1
X5741 g7401_1 g7390_0 vdd 0 g7409_0 nand2
X5742 g127_0 g1440_1 vdd 0 g1892_1 and2
X5743 g2504_2 g1176_0 vdd 0 g2843_1 nand2
X5744 g646_4 vdd 0 g1018_2 not1
X5745 g780_2 vdd 0 g1316_3 not1
X5746 g5077_2 g7346_0 vdd 0 g7371_1 nand2
X5747 g5912_2 vdd 0 g6277_1 not1
X5748 g2418_2 g2803_1 vdd 0 g3487_1 nand2
X5749 g1395_1 g699_2 vdd 0 g1596_1 and2
X5750 g6346_3 g5370_8 vdd 0 g6534_1 and2
X5751 g3252_2 vdd 0 g4041_1 not1
X5752 g3817_1 vdd 0 g5104_1 not1
X5753 g566_0 g1559_1 vdd 0 g1932_0 and2
X5754 g2507_0 vdd 0 g2846_0 not1
X5755 g2701_1 g4105_0 vdd 0 g4287_1 nand2
X5756 g2194_3 vdd 0 g3255_0 not1
X5757 g967_1 vdd 0 g1229_0 not1
X5758 g4377_2 vdd 0 g5263_1 not1
X5759 g4964_0 vdd 0 g5546_0 not1
X5760 g3873_4 vdd 0 g4985_0 not1
X5761 g4869_2 g4834_4 g4850_7 vdd 0 g5487_1 and3
X5762 g5977_1 g5258_2 vdd 0 g6307_0 and2
X5763 g1316_4 vdd 0 g1537_3 not1
X5764 g2680_1 g3057_0 vdd 0 g3553_1 nand2
X5765 g6447_1 g6388_0 vdd 0 g6543_2 nand2
X5766 g488_4 vdd 0 g805_4 not1
X5767 g2432_1 vdd 0 g2809_1 not1
X5768 g500_0 vdd 0 g683_6 not1
X5769 g2326_0 vdd 0 g3420_1 not1
X5770 g3219_0 g1262_1 vdd 0 g4011_0 nand2
X5771 g5637_2 vdd 0 g6009_1 not1
X5772 g5737_1 vdd 0 g6138_1 not1
X5773 g1108_0 g1123_0 vdd 0 g1410_0 or2
X5774 g2426_0 g2808_1 vdd 0 g3491_1 nand2
X5775 g3156_1 g1235_1 vdd 0 g3920_0 nand2
X5776 g3398_1 vdd 0 g4107_0 not1
X5777 g5197_1 vdd 0 g5870_1 not1
X5778 g1664_4 g1411_8 vdd 0 g1986_3 and2
X5779 g4157_2 vdd 0 g4618_1 not1
X5780 g66_0 g1178_2 vdd 0 g1453_1 and2
X5781 g5799_0 g5309_0 vdd 0 g6164_0 and2
X5782 g4485_2 g4474_1 g4463_2 vdd 0 g5318_0 and3
X5783 g1939_0 g1578_1 vdd 0 g2334_2 or2
X5784 g3297_2 vdd 0 g4049_1 not1
X5785 g2980_3 g5428_0 g5429_1 g6917_0 vdd 0 g6951_1 or4
X5786 g5033_0 g7175_0 vdd 0 g7207_1 nand2
X5787 g4141_0 g4302_0 vdd 0 g5006_1 nand2
X5788 g6155_0 vdd 0 g6413_1 not1
X5789 g6212_1 g6088_1 vdd 0 g6385_1 nor2
X5790 g21_1 vdd 0 g387_1 not1
X5791 g4199_2 vdd 0 g5119_1 not1
X5792 g2477_2 g6243_0 vdd 0 g6391_0 nand2
X5793 x111_0 x112_0 vdd 0 g4662_0 and2
X5794 g1632_0 vdd 0 g2459_1 not1
X5795 g5009_1 vdd 0 g5585_0 not1
X5796 g5334_3 vdd 0 g6116_1 not1
X5797 g428_6 vdd 0 g859_2 not1
X5798 g2725_2 g3411_1 vdd 0 g3575_1 nand2
X5799 g3368_1 g4096_1 vdd 0 g4279_1 nand2
X5800 g4299_1 g4300_1 vdd 0 g4964_2 nand2
X5801 g1506_1 g812_2 vdd 0 g1856_2 and2
X5802 g6109_1 vdd 0 g6393_1 not1
X5803 g52_1 g1178_1 vdd 0 g1456_0 and2
X5804 g5309_2 vdd 0 g5985_0 not1
X5805 g457_5 vdd 0 g895_1 not1
X5806 g1664_3 g1411_2 vdd 0 g1994_0 and2
X5807 g3478_1 g6905_2 vdd 0 g7000_1 and2
X5808 g6551_0 g6460_1 vdd 0 g6625_2 nand2
X5809 g6738_1 g6277_0 vdd 0 g6863_1 nand2
X5810 g7077_0 g7024_0 vdd 0 g7543_0 nand2
X5811 g1070_0 g1129_0 vdd 0 g1378_0 nand2
X5812 g5700_1 vdd 0 g6040_1 not1
X5813 g7237_1 vdd 0 g7279_0 not1
X5814 g6864_2 g6130_1 vdd 0 g6984_0 nand2
X5815 g75_1 g760_3 vdd 0 g1156_1 and2
X5816 g2813_0 g3495_1 vdd 0 g3725_7 nand2
X5817 g2704_1 vdd 0 g3067_0 not1
X5818 g1400_0 g712_1 vdd 0 g1859_1 and2
X5819 g582_2 g2215_1 vdd 0 g2897_1 and2
X5820 g5861_1 vdd 0 g6229_0 not1
X5821 g6856_2 vdd 0 g6976_1 not1
X5822 g7254_1 g7241_0 vdd 0 g7281_2 nand2
X5823 g4196_2 g5119_0 vdd 0 g5233_1 nand2
X5824 g3907_5 g5992_1 vdd 0 g6223_2 or2
X5825 g2963_4 g5417_1 vdd 0 g5926_2 nor2
X5826 g1691_6 vdd 0 g2423_2 not1
X5827 g5674_0 vdd 0 g6115_1 not1
X5828 g2096_0 g3862_7 vdd 0 g4453_0 and2
X5829 g2849_2 g5316_1 g5317_0 g5318_1 vdd 0 g5891_0 or4
X5830 g1608_0 vdd 0 g2415_1 not1
X5831 g6765_3 g6154_1 vdd 0 g6883_1 and2
X5832 g4582_6 vdd 0 g5674_2 not1
X5833 g4296_1 g4133_1 vdd 0 g4956_3 nand2
X5834 g2147_5 vdd 0 g3150_2 not1
X5835 g3358_1 vdd 0 g4188_1 not1
X5836 g7065_0 g6131_0 vdd 0 g7113_0 nand2
X5837 g666_2 vdd 0 g1009_2 not1
X5838 x501_0 x502_1 vdd 0 g6802_0 or2
X5839 g4991_1 g6894_0 vdd 0 g6935_1 nand2
X5840 g6597_5 g3883_4 vdd 0 g6694_1 and2
X5841 g5847_0 g5514_1 vdd 0 g6072_1 nor2
X5842 g7396_1 g6687_3 vdd 0 g7404_1 and2
X5843 g2603_2 g2951_1 vdd 0 g3534_1 nand2
X5844 g946_2 vdd 0 g1176_1 not1
X5845 g3630_6 g3601_9 g3617_12 vdd 0 g4341_1 and3
X5846 g47_0 g1269_2 vdd 0 g1514_1 and2
X5847 x481_1 x482_1 vdd 0 g6691_0 and2
X5848 g3528_1 g3529_1 vdd 0 g3969_1 nand2
X5849 g5848_2 g6209_0 vdd 0 g6377_1 or2
X5850 g3255_2 vdd 0 g4042_1 not1
X5851 g3601_15 vdd 0 g5018_2 not1
X5852 g3315_0 vdd 0 g4061_1 not1
X5853 g1507_0 g812_1 vdd 0 g1853_2 and2
X5854 g3249_2 g4039_1 vdd 0 g4255_1 nand2
X5855 g3899_0 g4220_0 vdd 0 g4491_0 nand2
X5856 g400_0 vdd 0 g7488_0 not1
X5857 g5897_0 g5995_0 vdd 0 g6170_0 nand2
X5858 g3784_3 g3768_1 g2062_3 vdd 0 g4425_0 and3
X5859 g3417_2 vdd 0 g4129_0 not1
X5860 g4982_2 g6889_0 vdd 0 g6933_0 nand2
X5861 g6090_1 vdd 0 g6316_1 not1
X5862 g6517_1 g6573_4 vdd 0 g6670_1 and2
X5863 g1397_0 g699_0 vdd 0 g1604_0 and2
X5864 g3736_7 g2038_0 vdd 0 g4406_1 and2
X5865 g3013_1 vdd 0 g4179_1 not1
X5866 g705_2 vdd 0 g1086_4 not1
X5867 g955_0 vdd 0 g1225_1 not1
X5868 g149_0 g1468_1 vdd 0 g1909_0 and2
X5869 g1942_1 g6663_0 vdd 0 g6675_0 nand2
X5870 g1612_1 vdd 0 g2540_1 not1
X5871 g4698_3 g7033_3 vdd 0 g7088_1 and2
X5872 g2023_1 g6905_3 vdd 0 g6993_1 and2
X5873 g4259_1 g4044_1 vdd 0 g4767_3 nand2
X5874 g4711_9 vdd 0 g5560_2 not1
X5875 g494_4 vdd 0 g705_6 not1
X5876 g207_3 g174_2 vdd 0 g512_4 nand2
X5877 g3024_5 g5488_1 g5489_1 vdd 0 g5945_2 nor3
X5878 g785_3 vdd 0 g1206_0 not1
X5879 g1584_1 g1359_1 vdd 0 g1824_2 or2
X5880 g3037_2 g4820_2 vdd 0 x282_0 and2
X5881 g6438_0 vdd 0 g6515_1 not1
X5882 g439_2 vdd 0 g7497_0 not1
X5883 g588_2 g1565_0 vdd 0 g1937_0 and2
X5884 g2558_1 vdd 0 g2928_0 not1
X5885 g4274_0 g4275_0 vdd 0 g4880_1 nand2
X5886 g646_0 vdd 0 g1042_2 not1
X5887 g772_1 vdd 0 g1199_2 not1
X5888 g2398_1 vdd 0 g2797_1 not1
X5889 g3383_1 vdd 0 g4100_0 not1
X5890 g3746_5 vdd 0 g5089_1 not1
X5891 g5220_1 g5294_1 vdd 0 g5786_1 nand2
X5892 g1592_2 vdd 0 g2615_2 not1
X5893 g5068_0 vdd 0 g5603_0 not1
X5894 g138_0 g805_2 vdd 0 g1253_1 and2
X5895 g4760_1 g4756_0 g5445_0 vdd 0 g6047_1 and3
X5896 g2175_2 vdd 0 g3237_2 not1
X5897 x151_1 x152_1 vdd 0 g5170_2 or2
X5898 g5942_1 vdd 0 g6297_1 not1
X5899 g576_0 vdd 0 g991_2 not1
X5900 g6002_2 g206_13 vdd 0 g6334_1 nand2
X5901 g2945_1 g4648_2 vdd 0 x242_0 and2
X5902 g2296_2 vdd 0 g3204_2 not1
X5903 g3768_15 g2055_6 g3754_13 vdd 0 g4419_1 and3
X5904 g767_4 vdd 0 g1366_2 not1
X5905 g3426_1 vdd 0 g4202_1 not1
X5906 g1960_0 g4328_0 g4329_1 vdd 0 x131_1 or3
X5907 g1924_0 g1551_0 vdd 0 g2280_1 or2
X5908 g2567_2 g2932_0 vdd 0 g3529_0 nand2
X5909 g6332_0 g6423_4 vdd 0 g6579_1 and2
X5910 g3177_2 g2935_1 vdd 0 g3973_1 nand2
X5911 g4550_7 vdd 0 g5643_1 not1
X5912 g2480_0 g5879_0 vdd 0 g6101_1 nand2
X5913 g2447_0 g3101_0 vdd 0 g3564_0 nand2
X5914 g3713_0 vdd 0 g4389_0 not1
X5915 g5802_2 g6180_1 vdd 0 g6340_1 or2
X5916 g7291_1 g7266_1 vdd 0 g7306_2 nand2
X5917 g5903_2 vdd 0 g6258_1 not1
X5918 g780_3 vdd 0 g1330_5 not1
X5919 g7109_0 g6119_0 vdd 0 g7157_1 nand2
X5920 g2045_0 g4418_0 g4419_0 g4420_0 vdd 0 g5217_0 nor4
X5921 g994_0 vdd 0 g1238_1 not1
X5922 g3318_0 vdd 0 g4063_1 not1
X5923 g3459_2 vdd 0 g4208_0 not1
X5924 g1012_1 vdd 0 g1262_1 not1
X5925 g4582_2 g2907_1 g4568_2 vdd 0 g5362_0 and3
X5926 g7212_1 g7192_0 vdd 0 g7237_2 nand2
X5927 g3746_1 vdd 0 g5071_2 not1
X5928 g1770_3 g1596_3 vdd 0 g2233_1 and2
X5929 g5217_2 g6730_1 vdd 0 g6817_0 nand2
X5930 g2004_2 g4356_0 g4357_1 g6683_0 vdd 0 g6805_0 or4
X5931 g1938_0 g1577_0 vdd 0 g2330_1 or2
X5932 g3150_0 vdd 0 g3917_1 not1
X5933 g5440_2 g5437_1 g5454_2 vdd 0 g6050_1 and3
X5934 g5923_2 g6035_1 vdd 0 g6190_1 nand2
X5935 g183_2 vdd 0 g553_5 not1
X5936 g3429_0 g4202_0 vdd 0 g4315_0 nand2
X5937 g1033_1 vdd 0 g1307_0 not1
X5938 g7048_1 g5603_1 vdd 0 g7100_0 nand2
X5939 g7384_0 vdd 0 g7396_0 not1
X5940 g4287_1 g4106_1 vdd 0 g4931_2 nand2
X5941 g5065_2 g6970_1 vdd 0 g7007_1 nand2
X5942 g4034_2 vdd 0 g4781_2 not1
X5943 g3204_1 g2946_0 vdd 0 g3985_0 nand2
X5944 g4519_6 g4508_8 g3907_2 g4498_6 vdd 0 g5330_1 and4
X5945 g1848_1 vdd 0 g2519_1 not1
X5946 g6939_1 vdd 0 g7530_1 not1
X5947 g7324_2 vdd 0 g7348_1 not1
X5948 g1531_1 g1306_0 vdd 0 g1811_3 or2
X5949 g6491_2 g6494_1 vdd 0 g6649_1 nand2
X5950 g3938_4 g2222_1 vdd 0 g4622_1 and2
X5951 g7010_0 g6977_0 vdd 0 g7057_1 nand2
X5952 g6259_1 vdd 0 g6465_1 not1
X5953 g1407_0 g734_0 vdd 0 g1638_1 and2
X5954 g124_0 g1440_0 vdd 0 g1895_0 and2
X5955 g2119_0 vdd 0 g3361_0 not1
X5956 g6951_0 g5960_0 vdd 0 g7022_0 nand2
X5957 g5622_0 g3913_0 vdd 0 g5997_0 nand2
X5958 g862_1 g2768_1 vdd 0 g3467_1 nand2
X5959 g3918_0 g4226_1 vdd 0 g4550_6 nand2
X5960 g2540_0 g2921_1 vdd 0 g3518_1 nand2
X5961 g828_4 vdd 0 g1275_4 not1
X5962 g2984_3 g4721_6 vdd 0 g5428_1 and2
X5963 g5194_2 vdd 0 g5865_1 not1
X5964 g5080_2 vdd 0 g5279_1 not1
X5965 g1836_2 vdd 0 g2728_2 not1
X5966 g1073_2 g4138_1 vdd 0 g4301_1 nand2
X5967 g428_9 g683_1 vdd 0 g1066_0 and2
X5968 g191_0 vdd 0 g588_0 not1
X5969 g805_1 vdd 0 g1240_0 not1
X5970 g1786_0 vdd 0 g2516_1 not1
X5971 g3423_1 vdd 0 g4131_0 not1
X5972 g2465_2 vdd 0 g2822_0 not1
X5973 g423_3 g1658_3 vdd 0 g2070_1 and2
X5974 g7153_1 g6112_1 vdd 0 g7192_1 nand2
X5975 g6198_0 g6050_1 vdd 0 g6363_0 nor2
X5976 g1782_1 vdd 0 g2627_2 not1
X5977 g113_0 g1289_1 vdd 0 g1531_0 and2
X5978 g6543_1 g2759_0 vdd 0 g6652_0 nand2
X5979 x431_0 x432_1 vdd 0 g6309_1 and2
X5980 g4088_0 vdd 0 g4899_0 not1
X5981 g50_2 g1192_6 vdd 0 g1477_1 and2
X5982 g1628_2 vdd 0 g2692_2 not1
X5983 g3237_2 g1268_1 vdd 0 g4023_1 nand2
X5984 g4611_4 g4550_5 g4539_3 vdd 0 g5350_1 and3
X5985 g488_2 vdd 0 g760_2 not1
X5986 g1086_3 g1098_1 vdd 0 g1397_1 or2
X5987 g1646_1 vdd 0 g2489_1 not1
X5988 g553_2 g1646_3 vdd 0 g2075_1 and2
X5989 g3129_2 vdd 0 g3898_1 not1
X5990 g7424_0 g7432_1 vdd 0 g7437_1 nand2
X5991 g6197_0 g6049_0 vdd 0 g6362_0 nor2
X5992 g4908_0 g3059_0 vdd 0 g5519_0 and2
X5993 g2019_0 vdd 0 g2789_1 not1
X5994 g5809_1 vdd 0 g6176_2 not1
X5995 g1092_1 g1101_1 vdd 0 g1400_1 or2
X5996 g5572_1 vdd 0 g5964_1 not1
X5997 x191_1 x192_1 vdd 0 g5191_0 or2
X5998 g49_4 g6075_3 g6016_5 g5370_9 vdd 0 g6350_1 and4
X5999 g559_1 g849_5 vdd 0 g1364_1 and2
X6000 g7299_0 g7300_1 g7301_0 g7302_0 vdd 0 g7336_0 or4
X6001 g4834_8 vdd 0 g5740_0 not1
X6002 g3225_2 vdd 0 g4016_0 not1
X6003 g7318_1 g5252_0 vdd 0 g7345_1 nand2
X6004 g4021_1 g4252_1 vdd 0 g4732_5 nand2
X6005 g6361_1 g6360_1 vdd 0 g6481_2 nand2
X6006 g187_0 vdd 0 g7464_0 not1
X6007 g5887_2 g6461_1 vdd 0 g6552_1 nand2
X6008 g6931_0 g6886_1 vdd 0 g7522_1 nand2
X6009 g6109_2 g7107_1 vdd 0 g7128_1 nand2
X6010 g4365_0 g3698_0 g5265_0 vdd 0 g5776_0 and3
X6011 g144_0 g1521_0 vdd 0 g1920_0 and2
X6012 g5755_0 vdd 0 g6143_1 not1
X6013 g1824_1 vdd 0 g2549_1 not1
X6014 g6550_1 g6452_1 vdd 0 g6618_2 nand2
X6015 g6300_2 vdd 0 g6498_1 not1
X6016 g5200_1 g5201_1 vdd 0 g5593_2 nand2
X6017 g5770_0 g6674_1 vdd 0 g6751_2 and2
X6018 g2450_0 vdd 0 g2812_1 not1
X6019 g2234_1 g3994_1 vdd 0 x122_1 and2
X6020 g2731_1 g3413_0 vdd 0 g3577_1 nand2
X6021 g1039_1 vdd 0 g1309_1 not1
X6022 g634_3 g1537_1 vdd 0 g1925_0 and2
X6023 g7371_0 g7347_1 vdd 0 g7383_1 nand2
X6024 g7141_2 vdd 0 g7183_1 not1
X6025 g5083_1 vdd 0 g5607_1 not1
X6026 g660_0 g2258_2 vdd 0 g3008_0 and2
X6027 g3578_0 g6823_0 vdd 0 g6874_1 and2
X6028 g1240_1 g1253_0 vdd 0 g1504_0 or2
X6029 g4056_0 g4267_1 vdd 0 g4812_2 nand2
X6030 g6722_2 vdd 0 g6843_1 not1
X6031 g4850_3 g4834_9 g3037_3 vdd 0 g5489_0 and3
X6032 g7234_2 g6010_0 vdd 0 g7266_0 nand2
X6033 g7126_1 g7104_1 vdd 0 g7147_2 nand2
X6034 g5437_2 g4771_3 g6043_1 vdd 0 g6197_1 and3
X6035 g3873_6 g3852_7 vdd 0 x482_0 and2
X6036 g6453_2 g5874_0 vdd 0 g6622_0 nand2
X6037 g5092_1 g7277_0 vdd 0 g7297_1 nand2
X6038 g4550_9 g2890_4 g4539_9 vdd 0 g5352_1 and3
X6039 g6818_0 g6733_1 vdd 0 g6853_2 nand2
X6040 g1990_3 g5769_1 vdd 0 g5956_1 or2
X6041 g1710_5 vdd 0 g2435_2 not1
X6042 g180_2 vdd 0 g7457_1 not1
X6043 g3450_2 vdd 0 g4137_1 not1
X6044 g772_0 vdd 0 g1295_2 not1
X6045 g3330_0 g6292_0 vdd 0 g6396_0 nand2
X6046 g5178_2 g6695_1 vdd 0 g6765_4 or2
X6047 g203_0 vdd 0 g7479_0 not1
X6048 g5836_0 g5491_1 vdd 0 g6284_0 or2
X6049 g1856_0 vdd 0 g2405_0 not1
X6050 g29_0 g1344_0 vdd 0 g1582_0 and2
X6051 g3342_2 vdd 0 g4073_1 not1
X6052 g3956_2 g3950_4 g2227_1 vdd 0 g4627_1 and3
X6053 g4368_0 g4365_1 g4386_0 vdd 0 g5272_0 and3
X6054 g1778_0 vdd 0 g2594_1 not1
X6055 g194_2 vdd 0 g608_2 not1
X6056 g172_0 vdd 0 g479_2 not1
X6057 g512_3 g428_4 vdd 0 g747_2 and2
X6058 g4676_3 g2963_2 vdd 0 g5410_1 and2
X6059 g2668_2 vdd 0 g3051_1 not1
X6060 g904_0 g2816_0 vdd 0 g3496_1 nand2
X6061 g871_1 g1377_0 vdd 0 g1422_1 nand2
X6062 g1073_0 vdd 0 g1386_0 not1
X6063 g439_2 vdd 0 g7494_0 not1
X6064 g2377_0 vdd 0 g2782_1 not1
X6065 g7443_0 vdd 0 g7551_0 not1
X6066 g2692_2 g3367_0 vdd 0 g3573_1 nand2
X6067 g4456_4 vdd 0 g5610_2 not1
X6068 g1957_1 g2799_1 vdd 0 g3484_1 nand2
X6069 g5080_0 g7348_0 vdd 0 g7372_0 nand2
X6070 g2585_2 vdd 0 g2946_1 not1
X6071 g464_3 g821_2 vdd 0 g1283_1 and2
X6072 g2194_2 vdd 0 g3312_1 not1
X6073 g2528_2 vdd 0 g2918_1 not1
X6074 g5546_2 vdd 0 g6082_1 not1
X6075 g7150_0 vdd 0 g7189_1 not1
X6076 g1511_0 g1281_0 vdd 0 g1868_0 or2
X6077 g6546_2 vdd 0 g6664_0 not1
X6078 g5144_1 vdd 0 g5766_1 not1
X6079 g760_4 vdd 0 g1144_4 not1
X6080 g2573_2 g3970_1 vdd 0 g4232_1 nand2
X6081 g488_3 vdd 0 g816_4 not1
X6082 g2347_1 vdd 0 g2768_1 not1
X6083 g6933_1 g6890_1 vdd 0 g7524_1 nand2
X6084 g3258_0 vdd 0 g4170_1 not1
X6085 g997_0 g3937_1 vdd 0 g4231_1 nand2
X6086 g6677_2 vdd 0 g6829_2 not1
X6087 g173_1 vdd 0 g485_1 not1
X6088 g3514_1 g3515_1 vdd 0 g3943_3 nand2
X6089 g7200_2 vdd 0 g7248_1 not1
X6090 g6251_2 vdd 0 g6461_0 not1
X6091 g12_1 vdd 0 g450_1 not1
X6092 g868_0 g2774_0 vdd 0 g3470_1 nand2
X6093 g5202_1 g6621_1 vdd 0 g6665_0 nand2
X6094 g5722_1 vdd 0 g6134_1 not1
X6095 g4474_2 g2859_3 g4463_3 vdd 0 g5317_1 and3
X6096 g2353_2 g1421_0 vdd 0 g2771_0 nand2
X6097 g2897_3 g5358_1 g5359_0 vdd 0 x421_1 or3
X6098 g5480_1 g5481_0 vdd 0 x372_1 or2
X6099 g2459_2 vdd 0 g2818_0 not1
X6100 g988_2 g3923_1 vdd 0 g4228_1 nand2
X6101 g4988_0 g6827_1 vdd 0 g6893_0 nand2
X6102 g519_1 vdd 0 g922_0 not1
X6103 g862_0 vdd 0 g1126_1 not1
X6104 g1102_0 g1116_0 vdd 0 g1403_0 or2
X6105 g72_1 g1138_2 vdd 0 g1433_1 and2
X6106 g1738_2 vdd 0 g2395_2 not1
X6107 g7000_0 g6909_1 vdd 0 g7027_2 or2
X6108 g2866_0 g5324_0 g5325_1 vdd 0 x311_0 or3
X6109 g4303_1 g4304_1 vdd 0 g5125_2 nand2
X6110 g1824_3 vdd 0 g2713_2 not1
X6111 g5957_1 g6911_0 vdd 0 g6996_1 and2
X6112 g4463_1 vdd 0 g5616_0 not1
X6113 g3480_0 g3481_0 vdd 0 g3687_1 nand2
X6114 g561_2 g7420_1 vdd 0 g7427_0 and2
X6115 g2412_1 vdd 0 g2802_1 not1
X6116 x341_1 x342_1 vdd 0 g5830_1 or2
X6117 g1664_5 vdd 0 g2362_2 not1
X6118 g3852_5 g3845_6 g2092_3 vdd 0 g4447_1 and3
X6119 g1612_2 vdd 0 g2680_2 not1
X6120 g526_0 vdd 0 g946_2 not1
X6121 g6654_0 g6582_0 vdd 0 g6705_1 or2
X6122 g161_0 g1484_5 vdd 0 g1914_0 and2
X6123 g2308_0 vdd 0 g3459_2 not1
X6124 g3368_0 vdd 0 g4095_0 not1
X6125 g5619_1 g6171_0 vdd 0 g6329_0 nand2
X6126 g6520_0 g6408_0 vdd 0 g7507_1 nand2
X6127 g55_0 g1350_3 vdd 0 g1589_1 and2
X6128 g3264_2 vdd 0 g4172_1 not1
X6129 g5188_1 g3095_0 vdd 0 g5860_1 nand2
X6130 g6808_2 vdd 0 g6898_1 not1
X6131 g2761_0 g2762_1 vdd 0 g3103_2 nand2
X6132 g2318_3 vdd 0 g3395_2 not1
X6133 g2510_0 g5299_1 vdd 0 g5793_1 nand2
X6134 g3687_0 vdd 0 g4362_2 not1
X6135 g1664_1 vdd 0 g2368_0 not1
X6136 g5980_1 g5786_0 vdd 0 g6152_1 nand2
X6137 g2147_3 vdd 0 g3294_0 not1
X6138 g2707_2 vdd 0 g3070_1 not1
X6139 g582_4 vdd 0 g988_1 not1
X6140 g2710_2 g2346_1 vdd 0 g3078_1 nand2
X6141 g2737_2 vdd 0 g3083_1 not1
X6142 g6637_2 vdd 0 g6736_0 not1
X6143 g2038_3 vdd 0 g3110_0 not1
X6144 g5532_0 g4960_1 g6082_0 vdd 0 g6212_0 and3
X6145 g3120_1 g1224_1 vdd 0 g3891_1 nand2
X6146 g6757_1 g5770_1 g6829_3 vdd 0 g6940_1 and3
X6147 g1914_1 g1498_1 vdd 0 g2209_5 or2
X6148 g7303_2 g6581_1 g561_4 vdd 0 g7353_1 and3
X6149 g1492_0 g1221_0 vdd 0 g1719_2 or2
X6150 g2270_2 vdd 0 g3264_0 not1
X6151 g1024_0 g4020_1 vdd 0 g4251_1 nand2
X6152 g5174_1 g4428_0 vdd 0 g5881_1 or2
X6153 g4704_6 g4732_9 vdd 0 x252_1 and2
X6154 g6987_1 vdd 0 g7071_1 not1
X6155 g3797_2 vdd 0 g5041_0 not1
X6156 g6340_2 g6056_4 vdd 0 g6529_1 and2
X6157 g5356_0 g5357_0 vdd 0 x322_1 or2
X6158 g1369_2 g2784_0 vdd 0 g3474_1 nand2
X6159 g5166_0 g5783_0 vdd 0 g5974_1 or2
X6160 g4791_1 g3008_3 vdd 0 g5465_1 and2
X6161 g5891_1 g5993_0 vdd 0 g6166_1 nand2
X6162 g5041_2 vdd 0 g5596_1 not1
X6163 g3768_4 g3746_2 g2055_5 g3754_7 vdd 0 g4412_1 and4
X6164 g3429_2 vdd 0 g4203_0 not1
X6165 g6281_0 g4049_0 vdd 0 g6441_1 nand2
X6166 g1786_1 g3071_0 vdd 0 g3907_3 and2
X6167 g3709_3 g3705_2 g4389_2 vdd 0 g5273_1 and3
X6168 g5628_2 vdd 0 g6103_1 not1
X6169 g4452_1 g6691_1 vdd 0 x492_1 or2
X6170 g6541_1 g6441_1 vdd 0 g6604_1 nand2
X6171 g7391_2 g6011_0 vdd 0 g7406_0 nand2
X6172 g5722_0 g7114_1 vdd 0 g7130_1 nand2
X6173 x101_0 x102_1 vdd 0 g4629_0 and2
X6174 g3873_1 g3862_4 g3845_0 vdd 0 x81_0 and3
X6175 g2513_0 g4530_1 vdd 0 g5181_1 nand2
X6176 g5003_2 vdd 0 g5581_1 not1
X6177 g3398_2 g3067_1 vdd 0 g4108_1 nand2
X6178 g6942_4 g6398_1 vdd 0 g7015_1 and2
X6179 g4775_2 vdd 0 g5451_2 not1
X6180 x21_0 x22_0 vdd 0 g4331_0 and2
X6181 g7086_0 g7016_0 vdd 0 g7546_0 or2
X6182 g206_10 g5302_4 g4508_9 g4519_8 vdd 0 g5990_1 and4
X6183 g652_6 g1543_2 vdd 0 g1928_1 and2
X6184 g1240_5 g805_5 vdd 0 g1500_1 or2
X6185 g157_1 g1446_2 vdd 0 g1898_1 and2
X6186 g1883_1 vdd 0 g2346_0 not1
X6187 g5136_1 vdd 0 g5683_1 not1
X6188 g2107_2 vdd 0 g3349_2 not1
X6189 g1738_5 vdd 0 g2383_2 not1
X6190 x211_0 x212_1 vdd 0 g5327_1 and2
X6191 g1433_0 g1153_0 vdd 0 g1683_1 or2
X6192 g2153_0 vdd 0 g3120_0 not1
X6193 g2767_0 g3467_1 vdd 0 g3579_4 nand2
X6194 g5071_0 g7183_0 vdd 0 g7208_0 nand2
X6195 g4619_2 g5184_0 vdd 0 g5380_0 and2
X6196 g1_1 vdd 0 g7446_0 not1
X6197 g5613_2 vdd 0 g5994_1 not1
X6198 g1438_1 g1158_1 vdd 0 g1704_5 or2
X6199 g1786_2 g3071_2 vdd 0 g3928_6 and2
X6200 g2308_1 vdd 0 g3174_2 not1
X6201 g6671_1 g6559_1 vdd 0 g7511_1 or2
X6202 g5059_2 g7139_1 vdd 0 g7169_1 nand2
X6203 g192_0 vdd 0 g7469_0 not1
X6204 g6386_0 g6385_0 vdd 0 g6499_2 nand2
X6205 g6230_0 g6233_1 vdd 0 g6452_0 nand2
X6206 g5027_1 g6962_1 vdd 0 g7003_0 nand2
X6207 g1899_1 g1460_1 vdd 0 g2147_1 or2
X6208 g2171_3 vdd 0 g3342_1 not1
X6209 g5122_1 g5704_1 vdd 0 g5930_1 nand2
X6210 g2133_4 vdd 0 g3168_0 not1
X6211 g2537_1 vdd 0 g2921_0 not1
X6212 g3542_0 g3543_0 vdd 0 g4030_2 nand2
X6213 g4026_2 g4753_1 g5444_0 vdd 0 g5834_1 and3
X6214 g1411_7 g1060_3 vdd 0 g1888_0 and2
X6215 g3132_0 vdd 0 g3900_0 not1
X6216 g7144_0 vdd 0 g7185_0 not1
X6217 g7068_0 vdd 0 g7114_1 not1
X6218 g2989_3 g4711_1 vdd 0 x262_1 and2
X6219 g507_1 vdd 0 g835_1 not1
X6220 g3852_3 vdd 0 g4979_2 not1
X6221 g3447_1 vdd 0 g4136_1 not1
X6222 g5000_0 g6900_1 vdd 0 g6938_1 nand2
X6223 g2501_0 vdd 0 g2842_1 not1
X6224 g3246_1 vdd 0 g4039_1 not1
X6225 g7422_0 g7413_0 vdd 0 g7428_1 or2
X6226 g6745_2 vdd 0 g6870_1 not1
X6227 g2483_2 g1169_0 vdd 0 g2829_1 nand2
X6228 g3327_2 g6487_1 vdd 0 g6556_1 nand2
X6229 g1600_2 vdd 0 g2603_1 not1
X6230 g5381_3 vdd 0 g6015_1 not1
X6231 g1844_3 vdd 0 g2525_1 not1
X6232 g3691_2 vdd 0 g4380_2 not1
X6233 g6217_1 vdd 0 g6407_0 not1
X6234 g6374_1 g5848_1 vdd 0 g6533_1 and2
X6235 g2837_1 g3507_0 vdd 0 g3845_4 nand2
X6236 g1009_1 vdd 0 g1261_1 not1
X6237 g5563_1 g7023_1 vdd 0 g7077_1 nand2
X6238 g1836_3 vdd 0 g2561_2 not1
X6239 g7030_1 vdd 0 g7539_0 not1
X6240 g7161_1 g6135_1 vdd 0 g7199_0 nand2
X6241 g3532_0 g3533_0 vdd 0 g3994_2 nand2
X6242 g6990_1 g6141_0 vdd 0 g7074_1 nand2
X6243 g2686_0 g3365_0 vdd 0 g3571_0 nand2
X6244 g3273_1 g4046_0 vdd 0 g4261_1 nand2
X6245 g6423_5 vdd 0 g6573_5 not1
X6246 g7340_0 g7333_1 vdd 0 g7363_0 nand2
X6247 g7318_1 vdd 0 g7344_0 not1
X6248 g5451_0 vdd 0 g6043_0 not1
X6249 g4931_1 g4920_3 g3068_0 g4926_0 vdd 0 g5527_1 and4
X6250 g5041_1 g6843_1 vdd 0 g6924_0 nand2
X6251 g3210_2 g3986_1 vdd 0 g4243_1 nand2
X6252 g532_1 g842_0 vdd 0 g1359_0 and2
X6253 g5232_0 g5233_0 vdd 0 g5677_1 nand2
X6254 g3071_1 vdd 0 g4157_2 not1
X6255 g200_1 vdd 0 g640_4 not1
X6256 g4532_6 vdd 0 g5634_2 not1
X6257 g175_0 g1275_0 vdd 0 g1518_0 and2
X6258 g3784_9 g3768_8 g2062_7 vdd 0 g4422_0 and3
X6259 g2534_2 g2919_0 vdd 0 g3516_1 nand2
X6260 g7295_1 g7274_0 vdd 0 g7318_2 nand2
X6261 x181_1 x182_0 vdd 0 g5185_2 or2
X6262 g488_5 vdd 0 g772_4 not1
X6263 g6997_1 g6884_1 vdd 0 g7535_0 or2
X6264 g201_1 vdd 0 g7477_0 not1
X6265 g3037_4 vdd 0 g4183_1 not1
X6266 g87_1 g696_1 vdd 0 g7500_1 and2
X6267 g4820_6 vdd 0 g5746_2 not1
X6268 g2365_1 g5583_1 vdd 0 g5858_0 nand2
X6269 g7284_1 g6139_1 vdd 0 g7333_1 nand2
X6270 g1581_0 g1356_1 vdd 0 g1883_2 or2
X6271 g5728_2 vdd 0 g6053_1 not1
X6272 g3522_1 g3523_1 vdd 0 g3961_3 nand2
X6273 g901_1 vdd 0 g1161_0 not1
X6274 g5418_0 g6771_4 vdd 0 g6920_0 and2
X6275 g2597_0 g2949_0 vdd 0 g3532_1 nand2
X6276 g428_8 vdd 0 g883_2 not1
X6277 g2734_2 g3412_1 vdd 0 g3576_1 nand2
X6278 g3559_0 g3560_0 vdd 0 g4124_0 nand2
X6279 g64_0 g1185_4 vdd 0 g1460_1 and2
X6280 g16_2 g835_2 vdd 0 g1305_1 and2
X6281 g7158_1 g6132_1 vdd 0 g7197_1 nand2
X6282 g180_1 vdd 0 g538_5 not1
X6283 g7048_2 vdd 0 g7099_1 not1
X6284 g2088_1 g4446_1 g4447_0 vdd 0 x161_1 or3
X6285 g3817_10 g2075_5 vdd 0 g4438_1 and2
X6286 g6351_2 g5287_2 g5258_1 vdd 0 g6505_0 and3
X6287 g6712_2 g5238_1 vdd 0 g6826_1 nand2
X6288 g3315_2 g1312_1 vdd 0 g4060_1 nand2
X6289 g6471_2 vdd 0 g6640_1 not1
X6290 g895_2 vdd 0 g1137_1 not1
X6291 g4374_0 g4371_0 g4392_0 vdd 0 g5274_1 and3
X6292 g4970_1 vdd 0 g5539_0 not1
X6293 g6546_2 g2760_1 vdd 0 g6653_1 nand2
X6294 g206_4 g6336_3 g6056_3 vdd 0 x461_1 and3
X6295 g5018_1 g7271_1 vdd 0 g7294_1 nand2
X6296 g5830_2 g6920_1 vdd 0 g6942_5 or2
X6297 g1891_1 g1452_0 vdd 0 g2107_3 or2
X6298 g7208_1 g7184_1 vdd 0 g7225_0 nand2
X6299 g3725_8 g2033_3 vdd 0 g4404_1 and2
X6300 g5951_1 g5952_1 vdd 0 g6144_2 nand2
X6301 g128_0 g1440_5 vdd 0 g1891_0 and2
X6302 g1951_2 g1674_1 vdd 0 g2748_1 nand2
X6303 g1003_2 vdd 0 g1259_0 not1
X6304 g2389_0 g2750_1 vdd 0 g2794_0 nand2
X6305 g2044_0 g4410_1 g4411_1 vdd 0 x151_0 or3
X6306 g1933_0 g1572_1 vdd 0 g2737_0 or2
X6307 g988_2 vdd 0 g1236_1 not1
X6308 g2662_1 g3050_1 vdd 0 g3548_1 nand2
X6309 g2270_5 vdd 0 g3300_1 not1
X6310 g3922_1 g4228_0 vdd 0 g4568_9 nand2
X6311 g3817_5 g3839_0 g3828_4 g3810_0 vdd 0 g4429_0 and4
X6312 g1399_0 g712_2 vdd 0 g1862_0 and2
X6313 g2635_0 vdd 0 g3001_1 not1
X6314 g4280_1 g4281_1 vdd 0 g4913_1 nand2
X6315 g5515_2 g5852_2 vdd 0 g6209_1 and2
X6316 g184_0 vdd 0 g559_0 not1
X6317 g3389_0 g4101_0 vdd 0 g4284_1 nand2
X6318 g4669_1 vdd 0 g5685_1 not1
X6319 g4820_1 g4812_2 g3024_3 vdd 0 g5475_1 and3
X6320 g12_0 vdd 0 g428_3 not1
X6321 g5719_2 g6985_1 vdd 0 g7013_1 nand2
X6322 g4869_6 g4834_10 g4820_4 g4850_4 vdd 0 g5481_1 and4
X6323 g5652_2 vdd 0 g6112_1 not1
X6324 g2280_3 g2163_3 vdd 0 g2944_1 and2
X6325 g5208_0 vdd 0 g5879_1 not1
X6326 g2203_3 vdd 0 g3276_0 not1
X6327 g13_1 g1212_5 vdd 0 g1496_1 and2
X6328 g2835_0 g3506_1 vdd 0 g3839_3 nand2
X6329 g4938_0 g4917_1 g4913_2 g4908_3 vdd 0 g5515_1 and4
X6330 g4167_2 vdd 0 g4749_1 not1
X6331 g3225_2 g1264_1 vdd 0 g4015_1 nand2
X6332 g1731_0 vdd 0 g2386_1 not1
X6333 g7412_0 g6833_0 vdd 0 g7422_1 and2
X6334 g2728_1 vdd 0 g3411_0 not1
X6335 g614_2 vdd 0 g952_2 not1
X6336 g205_2 vdd 0 g672_4 not1
X6337 g5098_2 vdd 0 g5295_1 not1
X6338 g3536_1 g3537_0 vdd 0 g4003_2 nand2
X6339 g6204_0 g6068_1 vdd 0 g6371_1 nor2
X6340 g6996_0 g6883_0 vdd 0 g7534_0 or2
X6341 g5575_2 vdd 0 g5965_0 not1
X6342 g2264_0 vdd 0 g3303_2 not1
X6343 g3258_2 g4171_1 vdd 0 g4304_0 nand2
X6344 g479_3 g1756_1 vdd 0 g2000_1 and2
X6345 g7116_2 vdd 0 g7164_1 not1
X6346 g1108_4 g1122_1 vdd 0 g1409_1 or2
X6347 g3252_1 g4042_0 vdd 0 g4258_1 nand2
X6348 g4539_0 vdd 0 g5649_0 not1
X6349 g4529_0 g5181_0 vdd 0 g5302_1 nand2
X6350 g916_2 vdd 0 g1166_0 not1
X6351 g5610_0 g6165_0 vdd 0 g6326_1 nand2
X6352 g634_2 g2188_3 vdd 0 g3024_4 and2
X6353 g1512_1 g1282_0 vdd 0 g1766_1 or2
X6354 g6811_1 vdd 0 g6900_1 not1
X6355 g6484_2 vdd 0 g6607_1 not1
X6356 g6656_1 g6587_1 vdd 0 g6698_1 nand2
X6357 g5104_0 g5791_1 vdd 0 g5983_0 nand2
X6358 g6453_0 vdd 0 g6621_0 not1
X6359 g446_1 vdd 0 g799_2 not1
X6360 g1422_0 g1378_1 vdd 0 g1664_2 nand2
X6361 g2492_1 g1172_1 vdd 0 g2835_1 nand2
X6362 g186_1 vdd 0 g566_1 not1
X6363 x411_0 x412_1 vdd 0 g6214_2 or2
X6364 g949_1 g2846_1 vdd 0 g3511_1 nand2
X6365 g6237_0 vdd 0 g6416_1 not1
X6366 g3383_0 g4099_0 vdd 0 g4282_0 nand2
X6367 g139_0 g805_3 vdd 0 g1252_0 and2
X6368 g1986_2 vdd 0 g2777_1 not1
X6369 g3141_1 g1231_0 vdd 0 g3905_1 nand2
X6370 g80_0 g740_5 vdd 0 g1120_1 and2
X6371 g2737_1 g3084_1 vdd 0 g3560_1 nand2
X6372 g5749_2 g7073_1 vdd 0 g7084_1 nand2
X6373 g2624_1 g2997_0 vdd 0 g3542_1 nand2
X6374 g5163_0 g6686_1 vdd 0 g6760_1 or2
X6375 g4791_7 vdd 0 g5716_2 not1
X6376 g1940_0 g1579_0 vdd 0 g2338_2 or2
X6377 g4317_1 g4318_0 vdd 0 g5144_2 nand2
X6378 g6850_0 vdd 0 g6972_0 not1
X6379 g3665_0 vdd 0 g5000_2 not1
X6380 g1516_0 g1286_0 vdd 0 g1782_0 or2
X6381 g2627_0 vdd 0 g2999_0 not1
X6382 g7410_0 g7406_1 vdd 0 g7420_0 nand2
X6383 g6771_3 g4742_3 g4721_1 vdd 0 x511_0 and3
X6384 g570_2 vdd 0 g973_0 not1
X6385 g6802_2 vdd 0 g6894_1 not1
X6386 g6093_2 g3089_0 vdd 0 g6388_1 nand2
X6387 g3587_9 g3579_1 g1965_0 vdd 0 g4329_0 and3
X6388 g7057_2 vdd 0 g7105_0 not1
X6389 g6980_0 g6395_0 vdd 0 g7064_0 nand2
X6390 g6967_1 g5600_1 vdd 0 g7047_1 nand2
X6391 g7060_0 vdd 0 g7107_0 not1
X6392 g2209_1 vdd 0 g3162_1 not1
X6393 g3270_1 vdd 0 g4043_1 not1
X6394 g1756_3 vdd 0 g2374_1 not1
X6395 g3492_1 g3493_1 vdd 0 g3713_2 nand2
X6396 g2250_7 vdd 0 g3261_2 not1
X6397 g72_0 g1144_2 vdd 0 g1438_0 and2
X6398 g5875_2 vdd 0 g6245_0 not1
X6399 g2075_0 g4442_0 vdd 0 g5229_0 nor2
X6400 g3324_1 g1315_0 vdd 0 g4066_0 nand2
X6401 g7407_1 vdd 0 g7411_0 not1
X6402 g6661_1 g6612_1 vdd 0 g6710_0 nand2
X6403 x471_1 x472_1 vdd 0 g6682_1 and2
X6404 g1919_0 g1534_1 vdd 0 g2258_4 or2
X6405 g2901_4 g5366_1 g5367_1 vdd 0 g5909_2 nor3
X6406 g1240_4 g1251_1 vdd 0 g1502_1 or2
X6407 g2423_1 g2027_1 vdd 0 g2806_1 nand2
X6408 g1436_0 g1156_1 vdd 0 g1691_1 or2
X6409 g856_1 vdd 0 g1124_1 not1
X6410 g1608_1 vdd 0 g2591_0 not1
X6411 g6642_2 vdd 0 g6741_1 not1
X6412 g4146_1 g5039_1 vdd 0 g5200_0 nand2
X6413 g3654_6 vdd 0 g4997_1 not1
X6414 g777_0 vdd 0 g1178_4 not1
X6415 g5569_0 g6405_0 vdd 0 g6519_1 nand2
X6416 g4648_4 g4642_4 g2943_1 vdd 0 g5392_0 and3
X6417 g1494_1 g1223_0 vdd 0 g1727_3 or2
X6418 g4611_2 g4550_3 g4539_2 g4532_4 vdd 0 g5341_2 and4
X6419 g3784_4 g3768_2 g2062_4 g3754_4 vdd 0 g4420_1 and4
X6420 g1762_2 g1258_0 vdd 0 g2239_0 and2
X6421 g2543_0 vdd 0 g2923_1 not1
X6422 g1402_1 g721_2 vdd 0 g1616_2 and2
X6423 g2123_2 vdd 0 g3371_2 not1
X6424 g5211_2 vdd 0 g5884_1 not1
X6425 g74_0 g108_0 g152_0 g164_0 vdd 0 g394_0 and4
X6426 g5360_0 g6006_0 vdd 0 x422_1 or2
X6427 g5917_2 vdd 0 g6185_1 not1
X6428 g4582_15 g2907_4 g4568_12 vdd 0 g5359_1 and3
X6429 g2401_1 vdd 0 g2798_1 not1
X6430 g2609_1 g2953_1 vdd 0 g3536_0 nand2
X6431 g4582_1 vdd 0 g5658_1 not1
X6432 g2133_2 vdd 0 g3129_2 not1
X6433 g6304_1 vdd 0 g6445_0 not1
X6434 g5018_2 vdd 0 g5588_1 not1
X6435 g464_4 vdd 0 g868_2 not1
X6436 g2101_2 g6694_0 vdd 0 g6799_1 or2
X6437 g1505_1 g812_3 vdd 0 g1756_5 and2
X6438 g931_0 g2834_1 vdd 0 g3505_0 nand2
X6439 g4676_7 g4698_2 g4687_9 g4669_4 vdd 0 g5404_2 and4
X6440 g2621_2 vdd 0 g2997_1 not1
X6441 g122_1 g1206_4 vdd 0 g1491_0 and2
X6442 g4582_11 g4560_7 g2907_6 g4568_13 vdd 0 g5356_1 and4
X6443 g3994_4 g3988_4 g2232_1 vdd 0 g4666_1 and3
X6444 g1051_0 g4063_1 vdd 0 g4270_0 nand2
X6445 g3162_0 g1237_0 vdd 0 g3924_1 nand2
X6446 g4066_1 g4272_1 vdd 0 g4869_5 nand2
X6447 g6562_1 g6564_1 g6703_1 g6704_1 vdd 0 g6784_2 and4
X6448 g2647_2 vdd 0 g3345_1 not1
X6449 g6346_0 g5370_3 g5395_4 vdd 0 g6510_1 and3
X6450 g3644_4 g3637_1 g2004_1 vdd 0 g4350_1 and3
X6451 g5671_2 vdd 0 g6120_1 not1
X6452 x61_0 x62_1 vdd 0 g4413_1 and2
X6453 g2392_1 g2796_1 vdd 0 g3481_1 nand2
X6454 g7038_0 g5586_1 vdd 0 g7090_1 nand2
X6455 g5977_0 g6536_0 g6537_0 g6538_0 vdd 0 g6590_2 or4
X6456 g1903_1 g1476_1 vdd 0 g2163_1 or2
X6457 g7245_1 vdd 0 g7269_1 not1
X6458 g6288_1 g5134_1 vdd 0 g6490_1 nand2
X6459 g4721_5 g4704_3 g2984_2 g4711_4 vdd 0 g5423_1 and4
X6460 g2314_1 g1719_3 vdd 0 g3068_1 and2
X6461 g5059_1 vdd 0 g5601_1 not1
X6462 g2292_3 vdd 0 g3447_2 not1
X6463 g6330_0 vdd 0 g6404_0 not1
X6464 g1588_0 g1363_0 vdd 0 g1840_1 or2
X6465 g2823_0 g3500_0 vdd 0 g3784_0 nand2
X6466 x551_0 x552_0 vdd 0 g7504_0 or2
X6467 g5725_0 vdd 0 g6135_0 not1
X6468 g2713_0 vdd 0 g3079_1 not1
X6469 g952_0 g3892_0 vdd 0 g4216_1 nand2
X6470 g5861_2 g6449_1 vdd 0 g6549_1 nand2
X6471 g34_1 g1330_3 vdd 0 g1573_0 and2
X6472 g413_3 g1632_5 vdd 0 g2044_1 and2
X6473 g117_0 g1289_2 vdd 0 g1527_1 and2
X6474 g6278_2 vdd 0 g6436_1 not1
X6475 g7093_2 g5598_0 vdd 0 g7138_0 nand2
X6476 g136_1 g816_3 vdd 0 g1255_0 and2
X6477 g7433_1 g7399_0 vdd 0 g7441_1 nand2
X6478 g4193_2 g5120_1 vdd 0 g5234_0 nand2
X6479 g6796_0 g5241_1 vdd 0 g6890_0 nand2
X6480 g206_5 g6318_0 g6026_1 vdd 0 g6540_1 and3
X6481 g4834_3 g3030_6 vdd 0 g5488_0 and2
X6482 g1246_0 g1254_0 vdd 0 g1505_0 or2
X6483 g2111_0 vdd 0 g3404_0 not1
X6484 g5202_2 vdd 0 g5874_1 not1
X6485 g4985_2 vdd 0 g5242_1 not1
X6486 g2618_2 g2240_1 vdd 0 g2996_1 nand2
X6487 g2123_3 vdd 0 g3358_2 not1
X6488 g6_0 vdd 0 g488_0 not1
X6489 g198_0 vdd 0 g7474_1 not1
X6490 g5806_0 vdd 0 g6259_2 not1
X6491 g652_2 vdd 0 g1015_1 not1
X6492 g4880_2 g4876_1 g5499_0 vdd 0 g6067_1 and3
X6493 g6121_2 g6586_1 vdd 0 g6656_0 nand2
X6494 g7436_1 vdd 0 g7549_1 not1
X6495 g2441_0 vdd 0 g3100_0 not1
X6496 g1865_0 vdd 0 g2027_0 not1
X6497 g3797_2 vdd 0 g5053_1 not1
X6498 g3300_0 g1307_1 vdd 0 g4050_1 nand2
X6499 g5404_1 g5418_1 vdd 0 g6026_5 and2
X6500 g7366_2 g6055_1 vdd 0 g7390_1 nand2
X6501 g6377_3 g6016_4 g5370_7 g5395_8 vdd 0 g6511_1 and4
X6502 g5688_2 g6187_0 vdd 0 g6356_1 nand2
X6503 g4791_10 g3008_4 vdd 0 g5468_1 and2
X6504 g1394_1 g699_5 vdd 0 g1592_1 and2
X6505 g1051_2 vdd 0 g1313_0 not1
X6506 g3168_1 g1239_1 vdd 0 g3936_1 nand2
X6507 g5024_2 g7344_1 vdd 0 g7370_1 nand2
X6508 g1995_1 vdd 0 g3090_1 not1
X6509 g5334_4 g4582_4 g4568_3 g4598_4 vdd 0 g6006_1 and4
X6510 g33_1 g1337_4 vdd 0 g1576_1 and2
X6511 g190_1 vdd 0 g582_3 not1
X6512 g5563_2 vdd 0 g5961_1 not1
X6513 g747_4 g1888_1 vdd 0 g2365_2 nor2
X6514 g767_0 g1744_1 vdd 0 g2004_0 and2
X6515 g5549_0 vdd 0 g6083_0 not1
X6516 g877_1 vdd 0 g1131_1 not1
X6517 g672_3 vdd 0 g1006_2 not1
X6518 g2790_0 g2789_1 vdd 0 g3465_0 nand2
X6519 g7124_1 g7100_1 vdd 0 g7141_1 nand2
X6520 g1079_1 g2747_1 vdd 0 g2791_1 nand2
X6521 g6618_0 g5870_0 vdd 0 g6721_1 nand2
X6522 g2775_1 g3471_0 vdd 0 g3630_1 nand2
X6523 g3654_1 g3637_0 g2008_0 g3644_3 vdd 0 g4351_1 and4
X6524 g120_0 g1462_2 vdd 0 g1903_0 and2
X6525 g6116_0 vdd 0 g6395_1 not1
X6526 g4784_4 vdd 0 g5725_1 not1
X6527 g3947_1 g3938_1 g2224_0 g3943_0 vdd 0 g4624_1 and4
X6528 g1406_0 g734_2 vdd 0 g1632_3 and2
X6529 g3291_0 g4177_0 vdd 0 g4310_1 nand2
X6530 g3219_2 vdd 0 g4012_1 not1
X6531 g6269_0 vdd 0 g6470_1 not1
X6532 g3803_0 vdd 0 g5065_1 not1
X6533 g6162_0 vdd 0 g6313_0 not1
X6534 g6993_0 g6877_0 vdd 0 g7531_1 or2
X6535 g4243_1 g4244_0 vdd 0 g4661_1 nand2
X6536 g5827_1 g6658_1 vdd 0 g6700_2 and2
X6537 g2880_0 g5345_1 g5346_0 g5347_0 vdd 0 g5802_1 or4
X6538 g1986_0 g5156_2 vdd 0 g5769_0 and2
X6539 g594_3 g2133_7 vdd 0 g2890_3 and2
X6540 g2342_3 g2123_1 vdd 0 g3058_0 and2
X6541 g3339_1 vdd 0 g4071_1 not1
X6542 g6628_0 vdd 0 g6730_1 not1
X6543 g184_1 vdd 0 g7461_1 not1
X6544 g62_1 g1192_1 vdd 0 g1475_0 and2
X6545 g796_0 vdd 0 g1372_1 not1
X6546 g173_2 vdd 0 g7452_0 not1
X6547 g2107_1 vdd 0 g3389_1 not1
X6548 g200_2 vdd 0 g7476_1 not1
X6549 g1411_5 vdd 0 g1945_2 not1
X6550 g7350_0 g7351_0 g7352_0 g7353_0 vdd 0 g7375_0 or4
X6551 g1086_1 g1085_0 vdd 0 g1393_0 or2
X6552 g3234_0 vdd 0 g4022_0 not1
X6553 g2579_1 g3974_0 vdd 0 g4234_0 nand2
X6554 g171_0 vdd 0 g7450_0 not1
X6555 g3810_3 vdd 0 g5095_2 not1
X6556 g4781_1 vdd 0 g5444_1 not1
X6557 g5110_1 g3890_0 vdd 0 g5300_1 nand2
X6558 g4628_1 g4629_1 vdd 0 x172_1 or2
X6559 g178_1 vdd 0 g526_4 not1
X6560 g5646_1 g7189_0 vdd 0 g7211_0 nand2
X6561 g3928_2 vdd 0 g5115_0 not1
X6562 g1102_1 g1117_0 vdd 0 g1404_1 or2
X6563 g7421_0 g7427_1 vdd 0 g7433_2 or2
X6564 g442_2 vdd 0 g721_4 not1
X6565 g570_3 g2203_4 vdd 0 g2907_5 and2
X6566 g4386_1 vdd 0 g5266_1 not1
X6567 g1030_2 vdd 0 g1268_1 not1
X6568 g6308_0 g6875_1 vdd 0 g6929_0 and2
X6569 g1379_1 g1380_0 vdd 0 g1423_2 nand2
X6570 g3096_2 vdd 0 g4142_0 not1
X6571 g5515_0 g5522_2 vdd 0 g6075_2 and2
X6572 g4233_1 g3973_0 vdd 0 g4635_3 nand2
X6573 g1909_1 g1482_1 vdd 0 g2188_4 or2
X6574 g9_1 g785_3 vdd 0 g1221_1 and2
X6575 g532_5 vdd 0 g913_2 not1
X6576 g3683_0 g4362_2 g5264_0 vdd 0 g5775_1 and3
X6577 g88_1 g716_0 vdd 0 g1101_0 and2
X6578 g6358_0 g6192_1 vdd 0 g6439_0 nand2
X6579 g4973_1 vdd 0 g5238_0 not1
X6580 g2235_1 g5185_1 vdd 0 g5828_1 and2
X6581 g544_1 g849_3 vdd 0 g1361_0 and2
X6582 g2934_0 g5385_0 g5386_1 g5387_1 vdd 0 g5820_2 or4
X6583 g3555_1 g3556_1 vdd 0 g4117_3 nand2
X6584 g2284_2 g2167_1 vdd 0 g2943_0 and2
X6585 g4917_0 g4908_2 g3061_0 g4913_2 vdd 0 g5521_0 and4
X6586 g5062_0 vdd 0 g5277_1 not1
X6587 g4771_1 g4767_1 g5451_1 vdd 0 g6049_1 and3
X6588 g5153_2 g5764_1 vdd 0 g5951_0 nand2
X6589 g4976_2 g6885_1 vdd 0 g6931_1 nand2
X6590 g5906_2 g6734_1 vdd 0 g6819_1 nand2
X6591 g24_0 g1323_1 vdd 0 g1556_0 and2
X6592 g5981_0 g5788_0 vdd 0 g6161_0 nand2
X6593 g4949_0 g4124_1 g5540_1 vdd 0 g6086_0 and3
X6594 g4880_0 vdd 0 g5496_0 not1
X6595 g6244_0 g6391_1 vdd 0 g6453_1 nand2
X6596 g1366_0 g2772_1 vdd 0 g3469_0 nand2
X6597 g1652_4 vdd 0 g2486_2 not1
X6598 g4582_7 g2907_0 vdd 0 g5366_0 and2
X6599 g886_0 vdd 0 g1134_0 not1
X6600 g2653_2 g3348_1 vdd 0 g3569_0 nand2
X6601 g4015_0 g4249_1 vdd 0 g4704_1 nand2
X6602 g6266_1 g6736_1 vdd 0 g6820_0 nand2
X6603 g4179_2 vdd 0 g5134_0 not1
X6604 g3231_0 g1266_1 vdd 0 g4019_0 nand2
X6605 g1704_1 vdd 0 g2501_2 not1
X6606 g2609_1 vdd 0 g2954_0 not1
X6607 g7312_1 g6199_0 g6833_1 vdd 0 g7354_0 and3
X6608 g2680_0 vdd 0 g3056_1 not1
X6609 g1723_1 vdd 0 g2701_2 not1
X6610 g7375_2 vdd 0 g7399_1 not1
X6611 g6499_2 vdd 0 g6611_1 not1
X6612 g2171_2 vdd 0 g3189_2 not1
X6613 g1491_1 g1220_1 vdd 0 g1716_2 or2
X6614 g6509_0 g6309_1 vdd 0 x542_0 or2
X6615 g3423_1 g4130_0 vdd 0 g4294_1 nand2
X6616 g4660_0 g4639_1 g4635_1 g4630_2 vdd 0 g5381_0 and4
X6617 g3576_1 g3577_0 vdd 0 g4210_0 nand2
X6618 g6506_0 g6507_0 vdd 0 x532_0 or2
X6619 g2350_2 vdd 0 g2770_1 not1
X6620 g428_9 g683_0 vdd 0 g1079_0 nor2
X6621 g2781_0 g3473_1 vdd 0 g3644_0 nand2
X6622 g3261_0 g4170_1 vdd 0 g4303_0 nand2
X6623 g5694_1 g6191_1 vdd 0 g6358_1 nand2
X6624 g2570_2 vdd 0 g2932_1 not1
X6625 g2785_0 g3475_1 vdd 0 g3665_3 nand2
X6626 g4662_2 g6589_1 vdd 0 g6658_0 nand2
X6627 g7253_1 g7218_1 vdd 0 g7260_2 nand2
X6628 g6240_2 g5973_1 vdd 0 g6419_1 nand2
X6629 g3117_0 g5301_1 vdd 0 g5794_1 nand2
X6630 g4111_1 g4291_1 vdd 0 g4939_1 nand2
X6631 g11_2 g835_6 vdd 0 g1303_1 and2
X6632 g931_2 vdd 0 g1171_1 not1
X6633 g5086_0 vdd 0 g5608_0 not1
X6634 g5713_2 g7196_0 vdd 0 g7213_0 nand2
X6635 g1774_3 vdd 0 g2621_0 not1
X6636 g2659_2 g2312_1 vdd 0 g3048_0 nand2
X6637 g973_1 vdd 0 g1231_1 not1
X6638 g5858_1 g5584_0 vdd 0 g6096_2 nand2
X6639 g2308_2 g1811_2 vdd 0 g2934_1 and2
X6640 g6590_6 vdd 0 g6715_2 not1
X6641 g4820_13 g4812_7 vdd 0 x272_1 and2
X6642 g3482_1 g3483_1 vdd 0 g3691_2 nand2
X6643 g1824_0 g1683_3 vdd 0 g2227_1 and2
X6644 g2558_1 g2927_1 vdd 0 g3524_1 nand2
X6645 g206_3 g5302_3 vdd 0 g5992_0 and2
X6646 g1906_1 g1479_0 vdd 0 g2635_1 or2
X6647 g6274_1 vdd 0 g6474_0 not1
X6648 g176_2 vdd 0 g518_1 not1
X6649 g6207_1 g6073_0 vdd 0 g6345_1 nand2
X6650 g4863_5 g4802_5 g4791_2 g4784_6 vdd 0 g5459_2 and4
X6651 g3705_3 vdd 0 g4371_2 not1
X6652 g3839_5 vdd 0 g4323_1 not1
X6653 g1915_0 g1499_1 vdd 0 g2215_4 or2
X6654 g976_1 g3915_1 vdd 0 g4224_1 nand2
X6655 g4532_1 vdd 0 g5646_2 not1
X6656 g3784_1 g2062_1 vdd 0 g4426_0 and2
X6657 g2513_1 vdd 0 g2879_0 not1
X6658 g5900_2 vdd 0 g6171_1 not1
X6659 g170_2 vdd 0 g7449_1 not1
X6660 g6175_0 g6001_0 vdd 0 g6335_0 nand2
X6661 g780_0 vdd 0 g1337_1 not1
X6662 g753_0 vdd 0 g1138_1 not1
X6663 g175_1 vdd 0 g517_0 not1
X6664 g2438_0 g3100_1 vdd 0 g3563_1 nand2
X6665 g4979_0 g6887_1 vdd 0 g6932_1 nand2
X6666 g6781_1 vdd 0 g6875_0 not1
X6667 g3420_1 vdd 0 g4130_1 not1
X6668 g206_11 g6318_1 g6026_2 g5287_4 vdd 0 g6538_1 and4
X6669 g3103_1 g6414_1 vdd 0 g6523_1 nand2
X6670 g3803_4 g3784_10 g3768_11 vdd 0 x51_1 and3
X6671 g114_1 g1289_5 vdd 0 g1530_1 and2
X6672 g678_0 g6316_0 vdd 0 g6401_0 nand2
X6673 g4074_0 g4890_0 g6066_0 vdd 0 g6206_1 and3
X6674 g1012_0 g4012_0 vdd 0 g4247_0 nand2
X6675 g4121_2 vdd 0 g4967_0 not1
X6676 g1408_1 g734_4 vdd 0 g1646_4 and2
X6677 g3255_1 g4041_0 vdd 0 g4257_1 nand2
X6678 g1530_1 g1305_0 vdd 0 g1807_3 or2
X6679 g849_6 vdd 0 g1350_5 not1
X6680 g5685_0 vdd 0 g6033_1 not1
X6681 g3784_8 vdd 0 g5086_1 not1
X6682 g2444_2 g3102_1 vdd 0 g3565_1 nand2
X6683 g3852_0 g3883_2 g3862_2 vdd 0 x71_0 and3
X6684 g1583_0 g1358_0 vdd 0 g1820_2 or2
X6685 g2250_1 g652_1 vdd 0 g3240_2 nor2
X6686 g4034_2 vdd 0 g4778_2 not1
X6687 g3327_0 vdd 0 g4178_0 not1
X6688 g3392_1 vdd 0 g4103_0 not1
X6689 g2606_2 vdd 0 g2953_1 not1
X6690 g7437_0 vdd 0 g7550_0 not1
X6691 g7150_2 g6108_1 vdd 0 g7190_1 nand2
X6692 g6090_2 g695_1 vdd 0 g6315_1 nand2
X6693 g594_6 g1565_5 vdd 0 g1938_1 and2
X6694 g2555_2 vdd 0 g2927_1 not1
X6695 g5900_0 g5996_1 vdd 0 g6172_0 nand2
X6696 g4412_1 g4413_0 vdd 0 x152_0 or2
X6697 g6928_1 g6873_0 vdd 0 g6990_0 nand2
X6698 g5071_2 vdd 0 g5604_1 not1
X6699 g4351_1 g4352_1 vdd 0 x142_1 or2
X6700 g1069_0 g2239_1 vdd 0 g2752_1 or2
X6701 g4676_10 g2963_4 vdd 0 g5413_1 and2
X6702 g4257_0 g4258_0 vdd 0 g4764_0 nand2
X6703 g5226_0 g5296_1 vdd 0 g5790_1 nand2
X6704 g6757_2 g6155_2 g6677_4 vdd 0 g6903_1 and3
X6705 g2537_2 g2922_0 vdd 0 g3519_1 nand2
X6706 g156_0 g1446_1 vdd 0 g1899_0 and2
X6707 g6263_2 vdd 0 g6467_1 not1
X6708 g3713_1 vdd 0 g4392_2 not1
X6709 g3177_1 vdd 0 g3972_1 not1
X6710 g1778_3 vdd 0 g2630_2 not1
X6711 g946_1 g2844_1 vdd 0 g3510_1 nand2
X6712 g5077_2 vdd 0 g5278_1 not1
X6713 g3570_1 g3571_1 vdd 0 g4199_1 nand2
X6714 g4330_1 g4331_1 vdd 0 x132_1 or2
X6715 g7256_0 g7251_0 vdd 0 g7287_0 nand2
X6716 g6226_1 vdd 0 g6449_0 not1
X6717 g3587_1 vdd 0 g5021_0 not1
X6718 g2209_0 vdd 0 g3273_0 not1
X6719 g2175_0 vdd 0 g3324_0 not1
X6720 g1520_0 g828_2 vdd 0 g1792_0 or2
X6721 g51_1 g1192_2 vdd 0 g1476_1 and2
X6722 g538_1 g842_2 vdd 0 g1360_1 and2
X6723 g4491_4 vdd 0 g5569_2 not1
X6724 g3401_0 vdd 0 g4109_0 not1
X6725 g5012_0 g7089_1 vdd 0 g7122_1 nand2
X6726 g5083_0 g6972_1 vdd 0 g7008_1 nand2
X6727 g7013_0 g6986_1 vdd 0 g7068_2 nand2
X6728 g553_3 vdd 0 g931_1 not1
X6729 g5843_2 g5492_1 vdd 0 g6294_2 or2
X6730 g3725_3 g3718_4 g2033_1 vdd 0 g4399_0 and3
X6731 x531_0 x532_1 vdd 0 g7502_0 or2
X6732 g5529_1 g4946_1 g5543_2 vdd 0 g6087_1 and3
X6733 g442_1 vdd 0 g699_4 not1
X6734 g3318_2 g1313_1 vdd 0 g4062_0 nand2
X6735 g3126_2 vdd 0 g3896_1 not1
X6736 g4395_0 g4407_0 vdd 0 g5280_2 and2
X6737 g2787_1 g3476_0 vdd 0 g3675_2 nand2
X6738 g5631_2 vdd 0 g6104_0 not1
X6739 g4236_0 g4237_0 vdd 0 g4648_1 nand2
X6740 g6439_1 vdd 0 g6516_0 not1
X6741 g997_2 vdd 0 g1239_1 not1
X6742 g2692_1 vdd 0 g3366_1 not1
X6743 g2008_4 g4358_0 g6684_1 vdd 0 g6808_1 or3
X6744 g5999_1 g6174_0 vdd 0 g6317_1 nand2
X6745 g1036_2 vdd 0 g1308_1 not1
X6746 g1925_1 g1552_1 vdd 0 g2284_3 or2
X6747 g3198_2 vdd 0 g3982_1 not1
X6748 g5933_2 g6741_0 vdd 0 g6821_0 nand2
X6749 g519_0 g1691_0 vdd 0 g2062_0 and2
X6750 g1021_0 vdd 0 g1265_0 not1
X6751 g6314_1 g7033_1 vdd 0 g7087_1 and2
X6752 g4157_0 g2914_0 vdd 0 g4617_0 nand2
X6753 g3630_3 g3601_0 g3587_4 g3617_3 vdd 0 g4335_1 and4
X6754 g5674_2 g7330_1 vdd 0 g7339_1 nand2
X6755 g1786_5 vdd 0 g2513_2 not1
X6756 g5634_1 vdd 0 g6105_0 not1
X6757 g4273_0 g4069_0 vdd 0 g4876_0 nand2
X6758 g4775_1 vdd 0 g5454_1 not1
X6759 g4767_2 vdd 0 g5437_0 not1
X6760 g3916_0 g4225_1 vdd 0 g4539_8 nand2
X6761 g1803_2 vdd 0 g2647_1 not1
X6762 g3189_1 vdd 0 g3979_1 not1
X6763 g7009_1 g6975_1 vdd 0 g7054_2 nand2
X6764 g4834_8 vdd 0 g5758_0 not1
X6765 g3905_0 g4223_0 vdd 0 g4519_1 nand2
X6766 g532_3 vdd 0 g943_1 not1
X6767 g3147_1 g1232_0 vdd 0 g3914_1 nand2
X6768 g1815_1 vdd 0 g1954_2 not1
X6769 g958_2 vdd 0 g1226_1 not1
X6770 g3228_2 vdd 0 g4018_1 not1
X6771 g7219_0 g5588_0 vdd 0 g7272_1 nand2
X6772 g928_0 vdd 0 g1170_1 not1
X6773 g2471_1 g1167_1 vdd 0 g2825_0 nand2
X6774 g6568_1 g7383_0 vdd 0 g7397_0 and2
X6775 g6604_0 g6610_1 g6710_1 g6711_0 vdd 0 g6787_2 and4
X6776 g125_1 g1440_3 vdd 0 g1894_1 and2
X6777 g691_1 g450_2 vdd 0 g1069_1 and2
X6778 g5903_1 g6732_1 vdd 0 g6818_1 nand2
X6779 g889_2 g2782_1 vdd 0 g3473_1 nand2
X6780 g7051_2 vdd 0 g7101_1 not1
X6781 g5160_0 vdd 0 g5867_0 not1
X6782 g588_1 g2127_0 vdd 0 g2896_0 and2
X6783 g2304_1 vdd 0 g3177_2 not1
X6784 g567_2 g1559_2 vdd 0 g1933_1 and2
X6785 g4964_1 vdd 0 g5549_2 not1
X6786 g6765_5 vdd 0 g6911_4 not1
X6787 g7378_0 g7439_0 vdd 0 g7440_1 nand2
X6788 g5661_1 g7405_0 vdd 0 g7410_1 nand2
X6789 g2435_2 vdd 0 g2810_0 not1
X6790 g1504_1 g799_4 vdd 0 g1750_3 and2
X6791 g5174_2 vdd 0 g5887_1 not1
X6792 g6597_1 g3883_1 g3862_1 vdd 0 x481_0 and3
X6793 g6093_0 vdd 0 g6387_0 not1
X6794 g3438_1 vdd 0 g4132_0 not1
X6795 g5131_2 vdd 0 g5706_1 not1
X6796 g5033_1 vdd 0 g5592_0 not1
X6797 g6208_0 g6074_1 vdd 0 g6374_0 and2
X6798 g2296_3 g1799_2 vdd 0 g2939_1 and2
X6799 g4893_1 vdd 0 g5508_2 not1
X6800 g6840_0 vdd 0 g6962_0 not1
X6801 g5866_1 g6100_0 vdd 0 g6230_1 nand2
X6802 g6448_0 g6390_0 vdd 0 g6546_1 nand2
X6803 g6423_2 g6404_1 vdd 0 g6560_0 and2
X6804 g3392_2 g3063_0 vdd 0 g4104_0 nand2
X6805 g2153_4 vdd 0 g3291_2 not1
X6806 g84_1 g760_6 vdd 0 g1157_1 and2
X6807 g634_5 vdd 0 g1048_2 not1
X6808 g3817_1 vdd 0 g5101_2 not1
X6809 g2244_1 vdd 0 g3225_0 not1
X6810 g3447_0 g4137_0 vdd 0 g4300_1 nand2
X6811 g3617_0 g1978_0 vdd 0 g4344_0 and2
X6812 g6211_0 g6087_0 vdd 0 g6384_0 nor2
X6813 g608_1 g2147_2 vdd 0 g2849_1 and2
X6814 g2338_3 vdd 0 g3435_2 not1
X6815 g5006_2 g3093_1 vdd 0 g5584_1 nand2
X6816 g423_0 vdd 0 g898_0 not1
X6817 g6085_0 g6084_0 vdd 0 g6304_0 nand2
X6818 g7309_1 g6609_0 g6705_2 vdd 0 g7357_0 and3
X6819 g3630_2 g3617_8 g3601_5 vdd 0 x11_0 and3
X6820 g5834_0 g5458_1 vdd 0 g6046_0 nor2
X6821 g2959_2 g5410_0 g5411_1 g5412_0 vdd 0 g5917_1 or4
X6822 g3862_9 g3845_1 g2096_2 g3852_8 vdd 0 g4448_1 and4
X6823 g3420_2 g4131_1 vdd 0 g4295_1 nand2
X6824 g6377_0 g6016_2 g5370_5 g5395_7 vdd 0 g6509_1 and4
X6825 g4508_10 g2874_1 g4498_9 vdd 0 g5329_1 and3
X6826 g3303_2 vdd 0 g4053_1 not1
X6827 g3485_0 g3486_0 vdd 0 g3698_1 nand2
X6828 g6864_0 vdd 0 g6983_1 not1
X6829 g767_1 g1744_4 vdd 0 g1965_4 and2
X6830 g53_0 g1185_3 vdd 0 g1457_0 and2
X6831 g6234_2 g3716_1 vdd 0 g6415_1 nand2
X6832 g2314_3 vdd 0 g3417_2 not1
X6833 g7030_1 vdd 0 g7540_0 not1
X6834 g2984_0 g5430_0 g6918_0 vdd 0 g6954_0 or3
X6835 g4869_0 vdd 0 g5749_0 not1
X6836 g3969_0 g3965_0 g3961_0 vdd 0 x91_0 and3
X6837 g570_0 g1559_0 vdd 0 g1934_0 and2
X6838 g7003_1 g6963_0 vdd 0 g7041_0 nand2
X6839 g25_1 g1323_4 vdd 0 g1557_1 and2
X6840 g6144_0 g6611_0 vdd 0 g6661_0 nand2
X6841 g2450_1 g1160_1 vdd 0 g2811_1 nand2
X6842 g4124_2 g5529_2 g6081_1 vdd 0 g6211_1 and3
X6843 g1387_0 vdd 0 g1852_0 not1
X6844 g205_0 vdd 0 g7481_1 not1
X6845 g4474_8 g2859_2 vdd 0 g5323_1 and2
X6846 g588_4 vdd 0 g985_2 not1
X6847 g7255_1 g7249_1 vdd 0 g7284_2 nand2
X6848 g1820_0 vdd 0 g2716_0 not1
X6849 g3546_1 g3048_1 vdd 0 g4074_1 nand2
X6850 g943_0 vdd 0 g1175_0 not1
X6851 g5886_0 g6102_0 vdd 0 g6251_1 nand2
X6852 g3192_2 g3981_0 vdd 0 g4239_1 nand2
X6853 g1048_0 g4061_1 vdd 0 g4269_0 nand2
X6854 g6293_0 g6396_1 vdd 0 g6491_1 nand2
X6855 g3630_4 vdd 0 g5009_1 not1
X6856 g54_2 vdd 0 g487_1 not1
X6857 g4985_1 g6891_1 vdd 0 g6934_1 nand2
X6858 g5948_2 g6872_1 vdd 0 g6928_1 nand2
X6859 g3817_9 g2075_4 vdd 0 g4435_1 and2
X6860 g2115_3 vdd 0 g3352_2 not1
X6861 g6618_1 vdd 0 g6720_1 not1
X6862 g1604_2 vdd 0 g2418_1 not1
X6863 g3135_1 g1229_1 vdd 0 g3901_0 nand2
X6864 g6471_1 g6474_1 vdd 0 g6641_1 nand2
X6865 g5860_1 g6099_0 vdd 0 g6226_0 nand2
X6866 g1880_0 vdd 0 g2313_1 not1
X6867 g3601_6 g3579_3 g1971_3 g3587_10 vdd 0 g4330_0 and4
X6868 g5906_0 vdd 0 g6262_1 not1
X6869 g30_1 g1295_4 vdd 0 g1536_1 and2
X6870 g6725_2 g5599_0 vdd 0 g6846_1 nand2
X6871 g4084_0 g4899_2 g5512_1 vdd 0 g5847_1 and3
X6872 g4297_1 g4298_0 vdd 0 g4960_0 nand2
X6873 g46_0 g1350_1 vdd 0 g1588_1 and2
X6874 g2815_0 g3496_1 vdd 0 g3736_2 nand2
X6875 g2849_0 g5319_1 g5320_0 vdd 0 g5894_2 nor3
X6876 g3267_1 vdd 0 g4173_1 not1
X6877 g2635_2 g4037_0 vdd 0 g4254_1 nand2
X6878 g3110_1 g6245_1 vdd 0 g6392_1 nand2
X6879 g6771_5 g4742_5 g4721_3 g4732_3 vdd 0 g6917_1 and4
X6880 g3725_10 vdd 0 g5050_2 not1
X6881 g1856_1 g2404_1 vdd 0 g2761_1 nand2
X6882 g747_0 g1886_0 vdd 0 g1990_1 or2
X6883 g620_0 g1537_0 vdd 0 g1922_0 and2
X6884 g2322_1 vdd 0 g3392_0 not1
X6885 g2600_1 g2952_1 vdd 0 g3535_1 nand2
X6886 g1102_5 g1118_1 vdd 0 g1405_1 or2
X6887 g3201_2 g3982_0 vdd 0 g4240_1 nand2
X6888 g5700_2 g4749_0 vdd 0 g6039_1 nand2
X6889 g3845_2 g2089_0 vdd 0 g4446_0 and2
X6890 g92_0 g705_3 vdd 0 g1097_0 and2
X6891 g6366_2 g5280_5 vdd 0 g6526_1 and2
X6892 g4311_1 g4312_1 vdd 0 g5139_2 nand2
X6893 g1432_1 g1152_1 vdd 0 g1679_3 or2
X6894 g7360_0 g6012_1 vdd 0 g7386_1 nand2
X6895 g3587_7 vdd 0 g5024_0 not1
X6896 x371_1 x372_0 vdd 0 g5942_2 or2
X6897 g6597_6 g3883_6 g3873_7 vdd 0 g6693_1 and3
X6898 g796_2 g450_3 vdd 0 g1258_1 and2
X6899 g2081_6 vdd 0 g3117_2 not1
X6900 g3020_0 g5478_0 g5479_0 vdd 0 x371_0 or3
X6901 g2459_0 g1163_1 vdd 0 g2817_0 nand2
X6902 g2276_1 vdd 0 g3207_1 not1
X6903 g6300_1 g6650_1 vdd 0 g6669_0 nand2
X6904 g5208_1 g3113_1 vdd 0 g5880_1 nand2
X6905 g594_5 g2133_3 vdd 0 g3171_0 nor2
X6906 g178_0 vdd 0 g7455_1 not1
X6907 g5177_1 g5784_1 vdd 0 g5977_2 or2
X6908 g4750_1 g4030_0 g5443_1 vdd 0 g5833_0 and3
X6909 g2296_1 vdd 0 g3456_2 not1
X6910 g2713_1 g3080_1 vdd 0 g3556_0 nand2
X6911 g752_1 g1890_1 vdd 0 g2023_3 or2
X6912 g2477_2 vdd 0 g3109_1 not1
X6913 g2415_0 vdd 0 g2803_0 not1
X6914 g5423_0 g5424_1 vdd 0 x342_1 or2
X6915 g538_3 g1710_3 vdd 0 g2089_1 and2
X6916 g660_1 g1543_0 vdd 0 g1929_0 and2
X6917 g2244_0 vdd 0 g3252_0 not1
X6918 g6251_2 g6254_0 vdd 0 g6462_1 nand2
X6919 g2671_2 vdd 0 g3052_0 not1
X6920 g5658_2 vdd 0 g6114_1 not1
X6921 g2597_2 vdd 0 g2950_1 not1
X6922 g7081_0 g7047_0 vdd 0 g7096_1 nand2
X6923 g5459_0 g5839_0 vdd 0 g6202_0 and2
X6924 g1021_2 g4018_0 vdd 0 g4250_1 nand2
X6925 g2486_1 g1170_1 vdd 0 g2831_0 nand2
X6926 g1904_0 g1477_0 vdd 0 g2167_2 or2
X6927 g6672_1 g6560_1 vdd 0 g7512_1 or2
X6928 g1704_4 vdd 0 g2426_2 not1
X6929 g835_5 vdd 0 g1289_4 not1
X6930 g428_10 vdd 0 g880_2 not1
X6931 g666_4 g2264_5 vdd 0 g2959_3 and2
X6932 g2356_2 vdd 0 g2774_1 not1
X6933 x491_0 x492_0 vdd 0 g6790_0 or2
X6934 g7290_0 g7264_0 vdd 0 g7303_0 nand2
X6935 g3435_0 vdd 0 g4205_0 not1
X6936 g3683_1 vdd 0 g4359_1 not1
X6937 g4305_1 g4306_1 vdd 0 g5122_2 nand2
X6938 g570_4 g2203_5 vdd 0 g2874_2 and2
X6939 g7087_1 g7017_1 vdd 0 g7547_1 or2
X6940 g4802_6 g4784_0 g3013_0 g4791_3 vdd 0 g5464_0 and4
X6941 g1527_0 g1302_0 vdd 0 g1795_1 or2
X6942 g206_8 g6336_1 g6056_2 vdd 0 g6530_1 and3
X6943 g4784_2 vdd 0 g5713_1 not1
X6944 g4416_0 g4417_0 vdd 0 x202_0 or2
X6945 g6837_1 g5585_1 vdd 0 g6961_1 nand2
X6946 g6259_1 g5113_0 vdd 0 g6466_0 nand2
X6947 g1719_2 vdd 0 g2665_0 not1
X6948 g2710_2 vdd 0 g3077_1 not1
X6949 g5891_2 vdd 0 g6165_1 not1
X6950 g4463_10 g4456_5 g2853_5 vdd 0 g5314_1 and3
X6951 g189_0 vdd 0 g7466_0 not1
X6952 g1898_0 g1459_0 vdd 0 g2141_1 or2
X6953 g5527_0 g5528_1 vdd 0 x362_1 or2
X6954 g1437_0 g1157_0 vdd 0 g1698_2 or2
X6955 g6223_1 g5966_0 vdd 0 g6412_1 nand2
X6956 g681_0 g682_0 g6902_0 vdd 0 g6939_0 and3
X6957 g6351_0 g6539_0 g6540_0 vdd 0 g6597_2 or3
X6958 g167_0 vdd 0 g455_0 not1
X6959 g4568_6 g2901_1 vdd 0 g5358_1 and2
X6960 g2897_2 g5361_1 g5362_1 g5363_0 vdd 0 g5912_0 nor4
X6961 g6199_2 g6051_0 vdd 0 g6442_1 and2
X6962 g1937_1 g1576_0 vdd 0 g2326_3 or2
X6963 g2752_3 vdd 0 g3540_0 not1
X6964 g3144_1 vdd 0 g3913_1 not1
X6965 g4698_0 g4687_0 vdd 0 g5416_1 and2
X6966 g628_2 vdd 0 g1027_1 not1
X6967 g2495_0 vdd 0 g2838_0 not1
X6968 g1616_0 vdd 0 g2689_1 not1
X6969 g1396_0 g699_1 vdd 0 g1600_1 and2
X6970 g2546_1 vdd 0 g2924_0 not1
X6971 g3355_0 vdd 0 g4187_1 not1
X6972 g3587_6 g1965_5 vdd 0 g4332_1 and2
X6973 g193_1 vdd 0 g7470_1 not1
X6974 g740_6 vdd 0 g1108_5 not1
X6975 g11_2 g1295_0 vdd 0 g1533_0 and2
X6976 g4539_6 g4532_3 g2885_1 vdd 0 g5346_1 and3
X6977 g767_2 vdd 0 g1369_0 not1
X6978 g1687_0 vdd 0 g2683_0 not1
X6979 g964_0 g3900_1 vdd 0 g4220_1 nand2
X6980 g1646_5 vdd 0 g2438_1 not1
X6981 g2133_6 vdd 0 g3288_1 not1
X6982 g6217_2 g5964_1 vdd 0 g6408_1 nand2
X6983 g5835_1 g6202_1 vdd 0 g6366_3 or2
X6984 g3339_2 g4070_1 vdd 0 g4274_1 nand2
X6985 g5044_1 vdd 0 g5597_0 not1
X6986 g3165_0 vdd 0 g3927_1 not1
X6987 g5160_1 g4345_1 vdd 0 g5861_0 or2
X6988 g5894_1 vdd 0 g6167_1 not1
X6989 g3828_2 vdd 0 g5107_2 not1
X6990 g1411_1 g1060_2 vdd 0 g1887_0 and2
X6991 g5770_2 g5250_1 vdd 0 g6155_1 and2
X6992 g865_2 vdd 0 g1127_1 not1
X6993 g3540_1 g2957_1 vdd 0 g3578_1 nand2
X6994 g3544_1 g3545_1 vdd 0 g4034_2 nand2
X6995 g4850_5 g4834_11 g4812_5 vdd 0 x281_0 and3
X6996 x261_0 x262_0 vdd 0 g5424_0 and2
X6997 g4997_2 vdd 0 g5246_1 not1
X6998 g4498_7 g4491_2 g2870_3 vdd 0 g5325_0 and3
X6999 g4598_0 g4582_0 g4560_0 vdd 0 x221_0 and3
X7000 g193_0 vdd 0 g602_0 not1
X7001 g3213_1 vdd 0 g4008_1 not1
X7002 g6363_1 g6362_1 vdd 0 g6484_0 nand2
X7003 g4742_4 vdd 0 g5554_0 not1
X7004 g387_0 g403_1 vdd 0 g7486_1 nand2
X7005 g3950_3 g2226_0 vdd 0 g4626_1 and2
X7006 g5694_2 vdd 0 g6036_1 not1
X7007 g4863_3 g4802_2 vdd 0 g5491_1 and2
X7008 g6853_0 g6103_0 vdd 0 g6975_0 nand2
X7009 g418_2 g1652_2 vdd 0 g2071_3 and2
X7010 g3129_1 g1227_1 vdd 0 g3897_0 nand2
X7011 g1710_2 vdd 0 g2498_1 not1
X7012 g3171_1 g6463_0 vdd 0 g6553_0 nand2
X7013 g1079_2 vdd 0 g1383_1 not1
X7014 g5341_1 g5809_0 vdd 0 g6180_1 and2
X7015 g2229_0 g3956_0 vdd 0 x102_1 and2
X7016 g204_2 vdd 0 g7480_0 not1
X7017 x41_0 x42_0 vdd 0 g4352_0 and2
X7018 g181_2 vdd 0 g7458_0 not1
X7019 g5668_0 g7156_1 vdd 0 g7170_1 nand2
X7020 g3444_1 vdd 0 g4135_1 not1
X7021 g6669_1 g6651_1 vdd 0 g6748_2 nand2
X7022 g2023_2 vdd 0 g2790_1 not1
X7023 g4550_8 g2890_5 g4539_4 vdd 0 g5349_1 and3
X7024 g4092_2 vdd 0 g4902_2 not1
X7025 g4850_6 g4834_12 g3037_5 g4820_7 vdd 0 g5484_0 and4
X7026 g1045_0 g4059_0 vdd 0 g4268_1 nand2
X7027 g560_0 g849_1 vdd 0 g1365_1 and2
X7028 g5153_1 vdd 0 g5765_1 not1
X7029 g6790_2 vdd 0 g6885_1 not1
X7030 g1683_3 vdd 0 g2552_2 not1
X7031 x321_1 x322_1 vdd 0 g5809_3 or2
X7032 g428_1 vdd 0 g871_2 not1
X7033 g1844_1 g1624_2 vdd 0 g2222_0 and2
X7034 g6930_1 g6879_1 vdd 0 g7521_0 or2
X7035 g6_3 vdd 0 g501_2 not1
X7036 g6549_0 g6450_0 vdd 0 g6615_2 nand2
X7037 g7257_0 g5170_1 g6687_1 vdd 0 g7300_1 and3
X7038 g5933_2 vdd 0 g6287_1 not1
X7039 g4598_5 g4582_5 g3928_4 g4568_4 vdd 0 g5363_1 and4
X7040 g4324_3 vdd 0 g5250_1 not1
X7041 g4812_4 vdd 0 g5737_2 not1
X7042 g2561_0 vdd 0 g2929_1 not1
X7043 g61_2 g1199_5 vdd 0 g1479_1 and2
X7044 g6072_0 g6071_0 vdd 0 g6278_0 nand2
X7045 g6313_1 g6911_2 vdd 0 g6995_0 and2
X7046 g7125_1 g7102_0 vdd 0 g7144_1 nand2
X7047 g3358_0 g4189_1 vdd 0 g4314_0 nand2
X7048 g3644_8 g2004_3 vdd 0 g4353_1 and2
X7049 g2133_7 g594_7 vdd 0 g3144_2 nor2
X7050 g4334_0 g4335_0 vdd 0 x192_0 or2
X7051 g4949_1 vdd 0 g5529_0 not1
X7052 g4292_1 g4293_0 vdd 0 g4949_2 nand2
X7053 g7281_1 vdd 0 g7330_1 not1
X7054 g1337_2 vdd 0 g1565_2 not1
X7055 g1591_0 vdd 0 g1957_0 not1
X7056 g60_0 g1269_4 vdd 0 g1511_1 and2
X7057 g2386_2 g1137_0 vdd 0 g2787_1 nand2
X7058 g4146_2 vdd 0 g5040_1 not1
X7059 g4054_1 g4266_1 vdd 0 g4802_3 nand2
X7060 g171_1 vdd 0 g473_5 not1
X7061 g7242_0 vdd 0 g7267_1 not1
X7062 g6874_1 g6824_0 vdd 0 g7517_0 or2
X7063 g7060_1 g6393_1 vdd 0 g7108_0 nand2
X7064 g2698_1 g4103_1 vdd 0 g4286_0 nand2
X7065 g4124_3 vdd 0 g4946_2 not1
X7066 g512_0 g428_2 vdd 0 g752_0 and2
X7067 g150_0 g1468_5 vdd 0 g1908_1 and2
X7068 g3852_2 g2092_1 vdd 0 g4450_0 and2
X7069 g1592_0 vdd 0 g2406_2 not1
X7070 g2778_0 g2777_0 vdd 0 g3466_1 nand2
X7071 g6625_0 g5884_1 vdd 0 g6729_1 nand2
X7072 g7141_0 g5604_0 vdd 0 g7184_0 nand2
X7073 g181_1 vdd 0 g413_2 not1
X7074 g6357_1 g6190_0 vdd 0 g6399_1 nand2
X7075 g3276_2 vdd 0 g4046_1 not1
X7076 x561_1 x562_1 vdd 0 g7505_0 or2
X7077 g5298_1 g5793_1 vdd 0 g5984_0 nand2
X7078 g1060_1 vdd 0 g1387_1 not1
X7079 g6932_0 g6888_0 vdd 0 g7523_0 nand2
X7080 g37_1 g1316_2 vdd 0 g1550_0 and2
X7081 g3114_0 vdd 0 g4150_1 not1
X7082 g7339_0 g7331_1 vdd 0 g7360_1 nand2
X7083 g3754_6 g2049_3 vdd 0 g4418_1 and2
X7084 g3516_0 g3517_0 vdd 0 g3947_0 nand2
X7085 g634_0 g2188_1 vdd 0 g2980_0 and2
X7086 g7203_1 g6143_1 vdd 0 g7251_1 nand2
X7087 g3294_1 g4176_1 vdd 0 g4309_1 nand2
X7088 g2817_1 g3497_1 vdd 0 g3746_6 nand2
X7089 x291_0 x292_0 vdd 0 g5522_1 and2
X7090 g1092_0 g1099_0 vdd 0 g1398_0 or2
X7091 g7394_0 g6829_1 vdd 0 g7403_1 and2
X7092 g166_1 g407_2 vdd 0 g7493_0 nand2
X7093 g5115_2 vdd 0 g5667_1 not1
X7094 g6329_1 g6172_1 vdd 0 g6422_1 nand2
X7095 g5163_2 g2019_3 vdd 0 g5768_1 and2
X7096 g2525_0 vdd 0 g2917_1 not1
X7097 g2141_0 vdd 0 g3153_0 not1
X7098 g7370_0 g7345_0 vdd 0 g7382_1 nand2
X7099 g5752_0 vdd 0 g6142_1 not1
X7100 g3261_2 vdd 0 g4171_1 not1
X7101 g2588_2 vdd 0 g2947_1 not1
X7102 g907_1 g2818_1 vdd 0 g3497_0 nand2
X7103 g994_2 g3927_1 vdd 0 g4230_1 nand2
X7104 g5830_0 g5404_0 vdd 0 g6184_0 and2
X7105 x121_0 x122_0 vdd 0 g4668_0 and2
X7106 g910_1 g2820_0 vdd 0 g3498_1 nand2
X7107 g7168_1 g7138_1 vdd 0 g7177_1 nand2
X7108 g4598_2 vdd 0 g5652_0 not1
X7109 g2322_2 g1727_0 vdd 0 g3064_1 and2
X7110 g2969_5 vdd 0 g4167_1 not1
X7111 g43_1 g1344_4 vdd 0 g1583_1 and2
X7112 g6954_2 vdd 0 g7023_0 not1
X7113 g512_3 vdd 0 g856_2 not1
X7114 g14_0 g1212_4 vdd 0 g1495_0 and2
X7115 g394_2 vdd 0 g7487_0 not1
X7116 g1102_2 g1115_1 vdd 0 g1402_0 or2
X7117 g1951_0 vdd 0 g2749_1 not1
X7118 g5300_0 g5794_0 vdd 0 g5957_1 nand2
X7119 g3086_1 vdd 0 g4138_0 not1

* the components sub circuits:

.subckt or4 a b c d vdd vss z
xm01 sig8  a     vdd   vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm02 vdd   a     05    vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm03 sig1  a     vss   vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm04 n2    b     sig8  vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm05 05    b     08    vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm06 vss   b     sig1  vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm07 10    c     n2    vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm08 08    c     11    vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm09 sig1  c     vss   vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm10 sig1  d     10    vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm11 11    d     sig1  vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm12 vss   d     sig1  vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm13 vdd   sig1  z     vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm14 vss   sig1  z     vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
c4  a     vss   1.356f
c5  b     vss   1.229f
c6  c     vss   1.043f
c7  d     vss   0.797f
c1  sig1  vss   1.003f
c3  z     vss   0.701f
.ends
.subckt xnr2v0x1 a b vdd vss z
xm01 z     b     sig3  vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm02 bn    sig3  z     vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
xm03 sig3  a     vdd   vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm04 vdd   b     bn    vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm05 z     bn    sig3  vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
xm06 vdd   sig3  n1    vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm07 sig3  a     vss   vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
xm08 n1    bn    z     vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm09 vss   b     bn    vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
c4  a     vss   0.389f
c2  bn    vss   1.593f
c5  b     vss   0.840f
c3  sig3  vss   0.618f
c6  z     vss   0.627f
.ends
.subckt nor2 a b vdd vss z
xm01 vdd   a     01    vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm02 vss   a     z     vss sg13_lv_nmos  l=0.13u  w=0.44u  as=0.1166p   ad=0.1166p   ps=1.41u   pd=1.41u
xm03 01    b     z     vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm04 z     b     vss   vss sg13_lv_nmos  l=0.13u  w=0.44u  as=0.1166p   ad=0.1166p   ps=1.41u   pd=1.41u
c4  a     vss   0.341f
c3  b     vss   0.433f
c2  z     vss   0.677f
.ends
.subckt or2 a b vdd vss z
xm01 03    a     vdd   vdd sg13_lv_pmos  l=0.13u  w=1.155u as=0.306075p ad=0.306075p ps=2.84u   pd=2.84u
xm02 sig1  a     vss   vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm03 sig1  b     03    vdd sg13_lv_pmos  l=0.13u  w=1.155u as=0.306075p ad=0.306075p ps=2.84u   pd=2.84u
xm04 vss   b     sig1  vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm5  vdd   sig1  z     vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm6  vss   sig1  z     vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
c4  a     vss   0.464f
c5  b     vss   0.507f
c1  sig1  vss   0.619f
c3  z     vss   0.593f
.ends
.subckt and4 a b c d vdd vss z
xm01 10    a     vdd   vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm02 n1    a     vss   vss sg13_lv_nmos  l=0.13u  w=0.88u  as=0.2332p   ad=0.2332p   ps=2.29u   pd=2.29u
xm03 vdd   b     10    vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm04 sig7  b     n1    vss sg13_lv_nmos  l=0.13u  w=0.88u  as=0.2332p   ad=0.2332p   ps=2.29u   pd=2.29u
xm05 10    c     vdd   vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm06 n3    c     sig7  vss sg13_lv_nmos  l=0.13u  w=0.88u  as=0.2332p   ad=0.2332p   ps=2.29u   pd=2.29u
xm07 vdd   d     10    vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm08 10    d     n3    vss sg13_lv_nmos  l=0.13u  w=0.88u  as=0.2332p   ad=0.2332p   ps=2.29u   pd=2.29u
xm09 vdd   10    z     vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm10 vss   10    z     vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
c4  10    vss   0.940f
c5  a     vss   0.674f
c8  b     vss   0.541f
c9  c     vss   0.622f
c10 d     vss   0.791f
c3  z     vss   0.765f
.ends
.subckt nor4 a b c d vdd vss z
xm1a 1b    a     vdd   vdd sg13_lv_pmos  l=0.13u  w=1.375u as=0.364375p ad=0.364375p ps=3.28u   pd=3.28u
xm1b sig8  b     1b    vdd sg13_lv_pmos  l=0.13u  w=1.375u as=0.364375p ad=0.364375p ps=3.28u   pd=3.28u
xm1c 1d    c     sig8  vdd sg13_lv_pmos  l=0.13u  w=1.375u as=0.364375p ad=0.364375p ps=3.28u   pd=3.28u
xm1d z     d     1d    vdd sg13_lv_pmos  l=0.13u  w=1.375u as=0.364375p ad=0.364375p ps=3.28u   pd=3.28u
xm2a vdd   a     2a    vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm2b 2a    b     sig11 vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm2c sig11 c     2c    vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm2d 2c    d     z     vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm3a z     a     vss   vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm3b vss   b     z     vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm3c z     c     vss   vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm3d vss   d     z     vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
c4  a     vss   1.510f
c3  b     vss   1.102f
c6  c     vss   0.817f
c5  d     vss   0.806f
c2  z     vss   0.935f
.ends
.subckt not1 a vdd vss z
xm01 vdd   a     z     vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm02 vss   a     z     vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
c3  a     vss   0.384f
c2  z     vss   0.576f
.ends
.subckt and3 a b c vdd vss z
xm01 08    a     vdd   vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm02 n1    a     vss   vss sg13_lv_nmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm03 vdd   b     08    vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm04 sig6  b     n1    vss sg13_lv_nmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm05 08    c     vdd   vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm06 08    c     sig6  vss sg13_lv_nmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm07 vdd   08    z     vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm08 vss   08    z     vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
c4  08    vss   1.142f
c5  a     vss   0.539f
c7  b     vss   0.609f
c8  c     vss   0.651f
c3  z     vss   0.745f
.ends
.subckt or3 a b c vdd vss z
xm01 01    a     vdd   vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm02 sig1  a     vss   vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm03 03    b     01    vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm04 vss   b     sig1  vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm05 sig1  c     03    vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm06 sig1  c     vss   vss sg13_lv_nmos  l=0.13u  w=0.33u  as=0.08745p  ad=0.08745p  ps=1.19u   pd=1.19u
xm07 vdd   sig1  z     vdd sg13_lv_pmos  l=0.13u  w=1.045u as=0.276925p ad=0.276925p ps=2.62u   pd=2.62u
xm08 vss   sig1  z     vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
c4  a     vss   0.544f
c5  b     vss   0.535f
c6  c     vss   0.625f
c1  sig1  vss   0.995f
c3  z     vss   0.544f
.ends
.subckt nand2 a b vdd vss z
xm01 vdd   a     z     vdd sg13_lv_pmos  l=0.13u  w=0.77u  as=0.20405p  ad=0.20405p  ps=2.07u   pd=2.07u
xm02 vss   a     sig3  vss sg13_lv_nmos  l=0.13u  w=0.66u  as=0.1749p   ad=0.1749p   ps=1.85u   pd=1.85u
xm03 z     b     vdd   vdd sg13_lv_pmos  l=0.13u  w=0.77u  as=0.20405p  ad=0.20405p  ps=2.07u   pd=2.07u
xm04 sig3  b     z     vss sg13_lv_nmos  l=0.13u  w=0.66u  as=0.1749p   ad=0.1749p   ps=1.85u   pd=1.85u
c4  a     vss   0.549f
c5  b     vss   0.578f
c1  z     vss   0.609f
.ends
.subckt and2 a b vdd vss z
xm01 06    a     vdd   vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm02 n1    a     vss   vss sg13_lv_nmos  l=0.13u  w=0.605u as=0.160325p ad=0.160325p ps=1.74u   pd=1.74u
xm03 vdd   b     06    vdd sg13_lv_pmos  l=0.13u  w=0.715u as=0.189475p ad=0.189475p ps=1.96u   pd=1.96u
xm04 06    b     n1    vss sg13_lv_nmos  l=0.13u  w=0.605u as=0.160325p ad=0.160325p ps=1.74u   pd=1.74u
xm05 vdd   06    z     vdd sg13_lv_pmos  l=0.13u  w=0.99u  as=0.26235p  ad=0.26235p  ps=2.51u   pd=2.51u
xm06 vss   06    z     vss sg13_lv_nmos  l=0.13u  w=0.495u as=0.131175p ad=0.131175p ps=1.52u   pd=1.52u
c4  06    vss   0.724f
c5  a     vss   0.663f
c6  b     vss   0.538f
c3  z     vss   0.595f
.ends
.subckt nor3 a b c vdd vss z
xm01 sig6  a     vdd   vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm02 vdd   a     02    vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm03 vss   a     z     vss sg13_lv_nmos  l=0.13u  w=0.55u  as=0.14575p  ad=0.14575p  ps=1.63u   pd=1.63u
xm04 04    b     sig6  vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm05 02    b     08    vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm06 z     b     vss   vss sg13_lv_nmos  l=0.13u  w=0.55u  as=0.14575p  ad=0.14575p  ps=1.63u   pd=1.63u
xm07 z     c     04    vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm08 08    c     z     vdd sg13_lv_pmos  l=0.13u  w=1.54u  as=0.4081p   ad=0.4081p   ps=3.61u   pd=3.61u
xm09 vss   c     z     vss sg13_lv_nmos  l=0.13u  w=0.55u  as=0.14575p  ad=0.14575p  ps=1.63u   pd=1.63u
c3  a     vss   0.957f
c4  b     vss   0.895f
c5  c     vss   0.693f
c2  z     vss   0.834f
.ends

*.options noopiter ; gminsteps=500 srcsteps=0 noinit
* simulation command:

*.save V(g7529_1) V(g7509_0) V(g7484_1) V(g7477_1) V(g7460_0) V(g7503_1) V(g7522_0) V(g7485_1) V(g7453_0) V(g7474_0) V(g7500_0) V(g7514_0) V(g7546_1) V(g7549_0) V(g7467_0) V(g7491_0) V(g7456_0) V(g7495_1) V(g7545_0) V(g7473_0) V(g7541_0) V(g7448_1) V(g7525_1) V(g7550_1) V(g165_1) V(g7510_1) V(g7535_1) V(g7534_1) V(g7469_1) V(g7476_0) V(g7517_1) V(g7537_0) V(g7489_1) V(g7521_1) V(g7486_0) V(g7533_1) V(g7449_0) V(g7447_0) V(g7528_0) V(g7513_1) V(g7548_0) V(g7544_1) V(g7552_0) V(g7540_1) V(g7507_0) V(g7481_0) V(g7455_0) V(g7502_1) V(g7446_1) V(g7478_1) V(g7470_0) V(g7526_0) V(g7494_1) V(g7452_1) V(g7463_0) V(g7532_1) V(g7512_0) V(g7527_0) V(g7451_0) V(g7472_0) V(g7498_1) V(g7475_0) V(g7536_0) V(g7488_1) V(g7493_1) V(g7551_1) V(g7482_0) V(g7487_1) V(g7501_1) V(g7520_1) V(g7516_1) V(g7450_1) V(g7508_0) V(g7458_1) V(g7479_1) V(g7506_1) V(g7499_0) V(g7471_0) V(g7465_1) V(g7464_1) V(g7543_1) V(g7524_0) V(g7539_1) V(g7468_1) V(g7459_0) V(g7504_1) V(g7515_1) V(g7492_1) V(g7511_0) V(g7462_1) V(g7530_0) V(g7497_1) V(g7454_1) V(g7519_1) V(g7531_0) V(g7547_0) V(g7483_1) V(g7466_1) V(g7480_1) V(g7523_1) V(g7496_0) V(g7538_0) V(g7490_1) V(g7518_1) V(g7461_0) V(g7542_0) V(g7457_0) V(g7505_1)
.tran 1ps 10ns 0 20p uic
.print tran  V(g7529_1) V(g7509_0) V(g7484_1) V(g7477_1) V(g7460_0) V(g7503_1) V(g7522_0) V(g7485_1) V(g7453_0) V(g7474_0) V(g7500_0) V(g7514_0) V(g7546_1) V(g7549_0) V(g7467_0) V(g7491_0) V(g7456_0) V(g7495_1) V(g7545_0) V(g7473_0) V(g7541_0) V(g7448_1) V(g7525_1) V(g7550_1) V(g165_1) V(g7510_1) V(g7535_1) V(g7534_1) V(g7469_1) V(g7476_0) V(g7517_1) V(g7537_0) V(g7489_1) V(g7521_1) V(g7486_0) V(g7533_1) V(g7449_0) V(g7447_0) V(g7528_0) V(g7513_1) V(g7548_0) V(g7544_1) V(g7552_0) V(g7540_1) V(g7507_0) V(g7481_0) V(g7455_0) V(g7502_1) V(g7446_1) V(g7478_1) V(g7470_0) V(g7526_0) V(g7494_1) V(g7452_1) V(g7463_0) V(g7532_1) V(g7512_0) V(g7527_0) V(g7451_0) V(g7472_0) V(g7498_1) V(g7475_0) V(g7536_0) V(g7488_1) V(g7493_1) V(g7551_1) V(g7482_0) V(g7487_1) V(g7501_1) V(g7520_1) V(g7516_1) V(g7450_1) V(g7508_0) V(g7458_1) V(g7479_1) V(g7506_1) V(g7499_0) V(g7471_0) V(g7465_1) V(g7464_1) V(g7543_1) V(g7524_0) V(g7539_1) V(g7468_1) V(g7459_0) V(g7504_1) V(g7515_1) V(g7492_1) V(g7511_0) V(g7462_1) V(g7530_0) V(g7497_1) V(g7454_1) V(g7519_1) V(g7531_0) V(g7547_0) V(g7483_1) V(g7466_1) V(g7480_1) V(g7523_1) V(g7496_0) V(g7538_0) V(g7490_1) V(g7518_1) V(g7461_0) V(g7542_0) V(g7457_0) V(g7505_1)

.end
